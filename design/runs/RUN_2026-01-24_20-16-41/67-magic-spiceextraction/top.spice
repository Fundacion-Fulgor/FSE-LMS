* NGSPICE file created from top.ext - technology: ihp-sg13g2

* Black-box entry subcircuit for sg13g2_xnor2_1 abstract view
.subckt sg13g2_xnor2_1 Y A B VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_fill_2 abstract view
.subckt sg13g2_fill_2 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_nand2b_1 abstract view
.subckt sg13g2_nand2b_1 Y B A_N VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_a21o_1 abstract view
.subckt sg13g2_a21o_1 A2 A1 B1 X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_decap_8 abstract view
.subckt sg13g2_decap_8 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_xor2_1 abstract view
.subckt sg13g2_xor2_1 B A X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_fill_1 abstract view
.subckt sg13g2_fill_1 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_inv_1 abstract view
.subckt sg13g2_inv_1 VDD Y A VSS
.ends

* Black-box entry subcircuit for sg13g2_dfrbpq_1 abstract view
.subckt sg13g2_dfrbpq_1 RESET_B VSS VDD D Q CLK
.ends

* Black-box entry subcircuit for sg13g2_tiehi abstract view
.subckt sg13g2_tiehi VDD VSS L_HI
.ends

* Black-box entry subcircuit for sg13g2_nand2_1 abstract view
.subckt sg13g2_nand2_1 Y A B VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_o21ai_1 abstract view
.subckt sg13g2_o21ai_1 B1 VDD Y VSS A1 A2
.ends

* Black-box entry subcircuit for sg13g2_decap_4 abstract view
.subckt sg13g2_decap_4 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_a21oi_1 abstract view
.subckt sg13g2_a21oi_1 VSS VDD A1 A2 Y B1
.ends

* Black-box entry subcircuit for sg13g2_buf_2 abstract view
.subckt sg13g2_buf_2 A X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_buf_1 abstract view
.subckt sg13g2_buf_1 A X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_nor2_1 abstract view
.subckt sg13g2_nor2_1 A B Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_nor2b_1 abstract view
.subckt sg13g2_nor2b_1 A B_N Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_and2_1 abstract view
.subckt sg13g2_and2_1 A B X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_or2_1 abstract view
.subckt sg13g2_or2_1 VSS VDD X B A
.ends

* Black-box entry subcircuit for sg13g2_nand3_1 abstract view
.subckt sg13g2_nand3_1 B C A Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_a22oi_1 abstract view
.subckt sg13g2_a22oi_1 Y B1 B2 A2 A1 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_buf_4 abstract view
.subckt sg13g2_buf_4 X A VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_buf_8 abstract view
.subckt sg13g2_buf_8 A X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_nor3_1 abstract view
.subckt sg13g2_nor3_1 A B C Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_nand4_1 abstract view
.subckt sg13g2_nand4_1 B C A Y VDD VSS D
.ends

* Black-box entry subcircuit for sg13g2_nor4_2 abstract view
.subckt sg13g2_nor4_2 A B C Y VSS VDD D
.ends

* Black-box entry subcircuit for sg13g2_nor4_1 abstract view
.subckt sg13g2_nor4_1 A B C D Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_nand2_2 abstract view
.subckt sg13g2_nand2_2 Y A B VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_mux2_1 abstract view
.subckt sg13g2_mux2_1 A0 A1 S X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_and4_1 abstract view
.subckt sg13g2_and4_1 A B C D X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_a221oi_1 abstract view
.subckt sg13g2_a221oi_1 VDD VSS B2 C1 B1 A1 Y A2
.ends

* Black-box entry subcircuit for sg13g2_dfrbpq_2 abstract view
.subckt sg13g2_dfrbpq_2 RESET_B VSS VDD D Q CLK
.ends

* Black-box entry subcircuit for sg13g2_antennanp abstract view
.subckt sg13g2_antennanp VDD VSS A
.ends

* Black-box entry subcircuit for sg13g2_and3_1 abstract view
.subckt sg13g2_and3_1 X A B C VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_or3_1 abstract view
.subckt sg13g2_or3_1 A B C X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_buf_16 abstract view
.subckt sg13g2_buf_16 X A VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_nand3b_1 abstract view
.subckt sg13g2_nand3b_1 B C Y VDD VSS A_N
.ends

* Black-box entry subcircuit for sg13g2_nor3_2 abstract view
.subckt sg13g2_nor3_2 A B C Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_a21oi_2 abstract view
.subckt sg13g2_a21oi_2 VSS VDD B1 Y A2 A1
.ends

* Black-box entry subcircuit for sg13g2_nor2_2 abstract view
.subckt sg13g2_nor2_2 A B Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_inv_2 abstract view
.subckt sg13g2_inv_2 Y A VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_inv_4 abstract view
.subckt sg13g2_inv_4 A Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_or3_2 abstract view
.subckt sg13g2_or3_2 A B C X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_ebufn_2 abstract view
.subckt sg13g2_ebufn_2 TE_B A Z VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_and2_2 abstract view
.subckt sg13g2_and2_2 A B X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_inv_8 abstract view
.subckt sg13g2_inv_8 Y A VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_mux2_2 abstract view
.subckt sg13g2_mux2_2 A0 A1 S X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_nor2b_2 abstract view
.subckt sg13g2_nor2b_2 A B_N Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_and3_2 abstract view
.subckt sg13g2_and3_2 X A B C VDD VSS
.ends

.subckt top VGND VPWR clkA reset spi_miso spi_mosi spi_sclk spi_ss_n x_serial y_serial
X_18869_ _09956_ _09949_ _09950_ VPWR VGND sg13g2_xnor2_1
XFILLER_28_929 VPWR VGND sg13g2_fill_2
X_20900_ _01540_ _01334_ _01302_ VPWR VGND sg13g2_nand2b_1
X_21880_ _02465_ _02464_ _02473_ _02474_ VPWR VGND sg13g2_a21o_1
XFILLER_55_759 VPWR VGND sg13g2_decap_8
X_20831_ _01468_ _01467_ _01471_ VPWR VGND sg13g2_xor2_1
XFILLER_70_729 VPWR VGND sg13g2_fill_1
XFILLER_35_461 VPWR VGND sg13g2_decap_8
XFILLER_74_1025 VPWR VGND sg13g2_fill_1
X_20762_ VPWR _01402_ _01401_ VGND sg13g2_inv_1
X_23550_ net1011 VGND VPWR _00612_ sys_enable_bus\[4\] clknet_leaf_37_clkA sg13g2_dfrbpq_1
X_23523__1325 VPWR VGND net1324 sg13g2_tiehi
XFILLER_51_965 VPWR VGND sg13g2_fill_1
XFILLER_23_656 VPWR VGND sg13g2_fill_2
X_22501_ _03000_ net952 _03591_ VPWR VGND sg13g2_nand2_1
X_23481_ net1479 VGND VPWR _00543_ u_LMS.x_r\[7\]\[0\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
X_20693_ _01331_ VPWR _01333_ VGND _01327_ _01332_ sg13g2_o21ai_1
XFILLER_11_818 VPWR VGND sg13g2_decap_4
XFILLER_11_829 VPWR VGND sg13g2_fill_1
X_22432_ VGND VPWR net436 _03253_ _00524_ _02965_ sg13g2_a21oi_1
XFILLER_50_486 VPWR VGND sg13g2_fill_1
XFILLER_109_728 VPWR VGND sg13g2_decap_8
X_22363_ net1027 VPWR _02931_ VGND net455 net709 sg13g2_o21ai_1
X_21314_ _01931_ _01930_ _01926_ VPWR VGND sg13g2_nand2b_1
XFILLER_11_1031 VPWR VGND sg13g2_decap_8
X_22294_ net9 VPWR _02880_ VGND _02848_ _02879_ sg13g2_o21ai_1
XFILLER_104_400 VPWR VGND sg13g2_decap_4
X_21245_ _01862_ _01850_ _01857_ VPWR VGND sg13g2_xnor2_1
XFILLER_105_945 VPWR VGND sg13g2_decap_8
XFILLER_7_7 VPWR VGND sg13g2_decap_8
XFILLER_81_1007 VPWR VGND sg13g2_fill_1
X_21176_ _01772_ VPWR _01793_ VGND _01769_ _01773_ sg13g2_o21ai_1
Xrebuffer2062 _01559_ net2061 VPWR VGND sg13g2_buf_2
XFILLER_77_26 VPWR VGND sg13g2_decap_8
XFILLER_117_77 VPWR VGND sg13g2_decap_8
XFILLER_105_989 VPWR VGND sg13g2_decap_8
Xrebuffer2073 net2076 net2072 VPWR VGND sg13g2_buf_1
Xfanout820 net821 net820 VPWR VGND sg13g2_buf_1
Xrebuffer2084 _10172_ net2083 VPWR VGND sg13g2_buf_2
XFILLER_78_829 VPWR VGND sg13g2_decap_4
XFILLER_104_477 VPWR VGND sg13g2_decap_4
Xrebuffer2095 _09313_ net2094 VPWR VGND sg13g2_buf_1
XFILLER_77_48 VPWR VGND sg13g2_fill_1
XFILLER_132_786 VPWR VGND sg13g2_decap_8
X_20127_ _11166_ _11167_ _11168_ VPWR VGND sg13g2_nor2_1
Xfanout831 u_FIR.x_reg\[6\] net831 VPWR VGND sg13g2_buf_1
XFILLER_77_328 VPWR VGND sg13g2_decap_8
Xfanout842 net843 net842 VPWR VGND sg13g2_buf_1
Xfanout853 u_FIR.x_reg\[4\] net853 VPWR VGND sg13g2_buf_1
Xfanout864 net865 net864 VPWR VGND sg13g2_buf_1
XFILLER_58_531 VPWR VGND sg13g2_fill_2
XFILLER_131_296 VPWR VGND sg13g2_decap_8
Xfanout875 net877 net875 VPWR VGND sg13g2_buf_1
XFILLER_19_907 VPWR VGND sg13g2_fill_1
X_20058_ _11099_ _11097_ _11098_ VPWR VGND sg13g2_nand2_1
Xfanout886 net888 net886 VPWR VGND sg13g2_buf_1
Xfanout897 net898 net897 VPWR VGND sg13g2_buf_1
XFILLER_73_501 VPWR VGND sg13g2_fill_2
X_11900_ VPWR _03321_ u_LMS.w\[5\]\[12\] VGND sg13g2_inv_1
X_22991__1220 VPWR VGND net1219 sg13g2_tiehi
X_12880_ _04241_ _04210_ _04240_ VPWR VGND sg13g2_xnor2_1
X_11831_ VPWR _03252_ net654 VGND sg13g2_inv_1
XFILLER_27_962 VPWR VGND sg13g2_fill_1
XFILLER_73_578 VPWR VGND sg13g2_decap_8
XFILLER_27_973 VPWR VGND sg13g2_fill_1
XFILLER_54_781 VPWR VGND sg13g2_decap_8
X_14550_ _05844_ _05835_ _05842_ VPWR VGND sg13g2_xnor2_1
X_23748_ net994 VGND VPWR _00810_ spi_wdata\[7\] clknet_3_4__leaf_spi_sclk sg13g2_dfrbpq_1
XFILLER_42_943 VPWR VGND sg13g2_decap_8
X_13501_ _04833_ _04834_ _04835_ VPWR VGND sg13g2_nor2b_1
X_14481_ net991 VPWR _05779_ VGND net489 u_FIR.sum\[5\]\[0\] sg13g2_o21ai_1
X_23679_ net1024 VGND VPWR _00741_ u_debug_unit.mon_w6_sync\[3\] clknet_leaf_21_clkA
+ sg13g2_dfrbpq_1
XFILLER_41_475 VPWR VGND sg13g2_fill_1
X_16220_ _07457_ net818 _07456_ VPWR VGND sg13g2_nand2_1
X_13432_ _04773_ _04746_ _04771_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_137 VPWR VGND sg13g2_fill_2
XFILLER_42_40 VPWR VGND sg13g2_decap_8
XFILLER_41_497 VPWR VGND sg13g2_fill_1
XFILLER_42_51 VPWR VGND sg13g2_fill_1
X_16151_ _07389_ _07386_ _07390_ VPWR VGND sg13g2_nor2b_1
X_13363_ VGND VPWR net538 _04705_ _00092_ _04706_ sg13g2_a21oi_1
X_15102_ _06353_ _06362_ _06375_ VPWR VGND sg13g2_and2_1
X_12314_ _03694_ _03686_ _03693_ VPWR VGND sg13g2_nand2_1
X_16082_ _07323_ _07290_ _07322_ VPWR VGND sg13g2_xnor2_1
X_13294_ VGND VPWR _04639_ u_FIR.w\[6\]\[2\] net743 sg13g2_or2_1
XFILLER_108_772 VPWR VGND sg13g2_decap_4
X_19910_ _10951_ net629 net154 VPWR VGND sg13g2_nand2_1
X_15033_ VGND VPWR net484 _06307_ _00160_ _06308_ sg13g2_a21oi_1
X_12245_ _03627_ _03598_ _03625_ VPWR VGND sg13g2_nand2_1
X_19841_ _10895_ _10842_ _10844_ VPWR VGND sg13g2_xnor2_1
X_12176_ net945 u_spi_slave.rx_shift\[6\] _00012_ VPWR VGND sg13g2_nor2b_1
XFILLER_96_615 VPWR VGND sg13g2_decap_4
XFILLER_3_56 VPWR VGND sg13g2_decap_8
XFILLER_111_959 VPWR VGND sg13g2_fill_1
X_19772_ _10836_ u_LMS.w\[4\]\[20\] net65 VPWR VGND sg13g2_nand2_1
X_16984_ _08140_ _08138_ _08139_ VPWR VGND sg13g2_nand2b_1
XFILLER_110_447 VPWR VGND sg13g2_decap_8
X_18723_ _09790_ VPWR _09810_ VGND _09787_ _09791_ sg13g2_o21ai_1
X_15935_ _07180_ _07165_ _07178_ VPWR VGND sg13g2_xnor2_1
XFILLER_49_553 VPWR VGND sg13g2_fill_2
XFILLER_3_1007 VPWR VGND sg13g2_decap_8
X_18654_ net354 VPWR _09746_ VGND u_LMS.w\[2\]\[7\] net370 sg13g2_o21ai_1
XFILLER_76_383 VPWR VGND sg13g2_fill_1
X_15866_ _07085_ _07113_ _07114_ VPWR VGND sg13g2_nor2b_1
XFILLER_37_748 VPWR VGND sg13g2_decap_8
XFILLER_92_854 VPWR VGND sg13g2_decap_4
XFILLER_64_545 VPWR VGND sg13g2_fill_2
XFILLER_18_940 VPWR VGND sg13g2_fill_1
X_17605_ _08734_ VPWR _08738_ VGND _08735_ _08737_ sg13g2_o21ai_1
X_14817_ _06104_ u_FIR.sum\[4\]\[11\] net397 VPWR VGND sg13g2_xnor2_1
X_18585_ _09691_ net33 net36 _09692_ VPWR VGND sg13g2_a21o_1
X_15797_ _07016_ _07046_ _07047_ VPWR VGND sg13g2_nor2_1
XFILLER_91_386 VPWR VGND sg13g2_fill_1
X_23701__1510 VPWR VGND net1509 sg13g2_tiehi
X_17536_ _08650_ _08667_ _08648_ _08669_ VPWR VGND sg13g2_nand3_1
X_14748_ _06037_ _06028_ _06035_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_420 VPWR VGND sg13g2_fill_1
XFILLER_32_431 VPWR VGND sg13g2_decap_4
X_23416__1101 VPWR VGND net1100 sg13g2_tiehi
X_17467_ _08600_ net81 _08598_ VPWR VGND sg13g2_nand2b_1
X_14679_ _05948_ VPWR _05969_ VGND _05949_ _05957_ sg13g2_o21ai_1
XFILLER_60_784 VPWR VGND sg13g2_fill_2
XFILLER_32_486 VPWR VGND sg13g2_decap_8
X_19206_ _10288_ net309 u_LMS.w\[3\]\[17\] coeff_force_packed\[26\] net560 VPWR VGND
+ sg13g2_a22oi_1
X_16418_ _07648_ u_FIR.sum\[7\]\[16\] net388 VPWR VGND sg13g2_nand2_1
XFILLER_20_637 VPWR VGND sg13g2_fill_2
X_17398_ _08483_ VPWR _08543_ VGND _08482_ _08485_ sg13g2_o21ai_1
X_19137_ _10224_ _03329_ _10187_ VPWR VGND sg13g2_nand2_1
X_16349_ _07568_ VPWR _07582_ VGND net271 _07566_ sg13g2_o21ai_1
XFILLER_121_1045 VPWR VGND sg13g2_decap_8
XFILLER_66_0 VPWR VGND sg13g2_decap_8
X_19068_ VGND VPWR net653 net158 _10155_ _10154_ sg13g2_a21oi_1
X_18019_ _09140_ _09085_ _09141_ VPWR VGND sg13g2_xor2_1
X_21030_ _01668_ net2062 _01631_ VPWR VGND sg13g2_xnor2_1
Xfanout105 net105 _07975_ VPWR VGND sg13g2_buf_4
Xfanout116 _01781_ net116 VPWR VGND sg13g2_buf_1
XFILLER_99_475 VPWR VGND sg13g2_fill_1
XFILLER_101_403 VPWR VGND sg13g2_decap_4
Xfanout127 net127 net128 VPWR VGND sg13g2_buf_4
Xfanout138 _07960_ net138 VPWR VGND sg13g2_buf_8
XFILLER_102_948 VPWR VGND sg13g2_fill_1
Xfanout149 net150 net149 VPWR VGND sg13g2_buf_1
XFILLER_113_285 VPWR VGND sg13g2_fill_2
XFILLER_86_136 VPWR VGND sg13g2_fill_2
XFILLER_47_29 VPWR VGND sg13g2_decap_4
XFILLER_41_1013 VPWR VGND sg13g2_decap_8
X_22981_ net1019 VGND VPWR _00043_ u_spi_slave.tx_shift\[11\] net1631 sg13g2_dfrbpq_1
XFILLER_67_361 VPWR VGND sg13g2_decap_4
XFILLER_28_715 VPWR VGND sg13g2_decap_4
XFILLER_95_681 VPWR VGND sg13g2_decap_8
XFILLER_55_523 VPWR VGND sg13g2_decap_8
XFILLER_28_737 VPWR VGND sg13g2_fill_2
X_21932_ _02525_ _02524_ _02526_ VPWR VGND sg13g2_xor2_1
XFILLER_67_394 VPWR VGND sg13g2_decap_8
XFILLER_103_57 VPWR VGND sg13g2_decap_8
X_21863_ _02455_ VPWR _02457_ VGND _02452_ _02454_ sg13g2_o21ai_1
XFILLER_42_217 VPWR VGND sg13g2_fill_2
X_23602_ net1015 VGND VPWR _00664_ coeff_force_packed\[42\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
X_20814_ _01452_ net2071 _01454_ VPWR VGND sg13g2_nor2_1
X_21794_ _02367_ VPWR _02388_ VGND _02364_ _02368_ sg13g2_o21ai_1
X_23533_ net987 VGND VPWR _00595_ u_debug_unit.sw_reset\[3\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
X_20745_ _01385_ _01383_ _01384_ VPWR VGND sg13g2_xnor2_1
X_20676_ _01316_ _01312_ _01315_ VPWR VGND sg13g2_nand2_1
X_23464_ net1539 VGND VPWR _00526_ u_LMS.x_r\[4\]\[7\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
X_22415_ net948 VPWR _02957_ VGND net431 net656 sg13g2_o21ai_1
X_23395_ net1163 VGND VPWR _00457_ u_LMS.w\[7\]\[5\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
XFILLER_109_547 VPWR VGND sg13g2_fill_1
XFILLER_128_21 VPWR VGND sg13g2_decap_8
X_22346_ VGND VPWR net47 _02919_ _02920_ net6 sg13g2_a21oi_1
X_22277_ net2171 VPWR _02866_ VGND _02824_ _02865_ sg13g2_o21ai_1
XFILLER_128_98 VPWR VGND sg13g2_decap_8
X_12030_ _03447_ net285 sys_enable_bus\[7\] net295 u_debug_unit.force_w5\[7\] VPWR
+ VGND sg13g2_a22oi_1
X_21228_ _01844_ _01755_ _01845_ VPWR VGND sg13g2_xor2_1
XFILLER_132_550 VPWR VGND sg13g2_decap_8
XFILLER_104_252 VPWR VGND sg13g2_fill_2
X_21159_ _01768_ _01775_ _01776_ VPWR VGND sg13g2_and2_1
XFILLER_59_840 VPWR VGND sg13g2_fill_1
Xfanout650 u_LMS.x_r\[4\]\[1\] net650 VPWR VGND sg13g2_buf_1
Xfanout661 u_LMS.x_r\[3\]\[3\] net661 VPWR VGND sg13g2_buf_1
Xfanout672 net673 net672 VPWR VGND sg13g2_buf_1
Xfanout683 u_LMS.x_r\[2\]\[0\] net683 VPWR VGND sg13g2_buf_1
X_13981_ _05297_ net763 net905 VPWR VGND sg13g2_nand2_1
XFILLER_19_704 VPWR VGND sg13g2_decap_4
Xfanout694 net695 net694 VPWR VGND sg13g2_buf_1
XFILLER_59_895 VPWR VGND sg13g2_decap_8
X_15720_ _06931_ _06933_ _06971_ _06972_ VPWR VGND sg13g2_nor3_1
XFILLER_19_737 VPWR VGND sg13g2_fill_2
X_12932_ _04255_ _04290_ _04291_ VPWR VGND sg13g2_nor2_1
XFILLER_74_832 VPWR VGND sg13g2_fill_2
X_15651_ net875 _06903_ net785 _06904_ VPWR VGND sg13g2_nand3_1
X_23118__1613 VPWR VGND net1612 sg13g2_tiehi
X_12863_ _04224_ _04223_ _04219_ VPWR VGND sg13g2_nand2b_1
XFILLER_74_887 VPWR VGND sg13g2_decap_4
XFILLER_61_504 VPWR VGND sg13g2_fill_1
XFILLER_73_375 VPWR VGND sg13g2_decap_4
XFILLER_34_729 VPWR VGND sg13g2_decap_4
XFILLER_33_217 VPWR VGND sg13g2_decap_8
X_14602_ _05894_ _05893_ _05855_ VPWR VGND sg13g2_nand2b_1
X_18370_ net682 net182 net680 _09480_ VPWR VGND net217 sg13g2_nand4_1
X_11814_ VPWR _03235_ net622 VGND sg13g2_inv_1
XFILLER_33_228 VPWR VGND sg13g2_fill_1
X_15582_ _06835_ _06828_ _06837_ VPWR VGND sg13g2_xor2_1
XFILLER_15_943 VPWR VGND sg13g2_fill_1
X_12794_ _04157_ _04153_ _04156_ VPWR VGND sg13g2_xnor2_1
X_17321_ _08477_ u_LMS.w\[0\]\[21\] net72 VPWR VGND sg13g2_nand2_1
X_14533_ _05827_ net772 net862 VPWR VGND sg13g2_nand2_1
XFILLER_41_250 VPWR VGND sg13g2_fill_1
XFILLER_105_1007 VPWR VGND sg13g2_fill_2
X_17252_ _08408_ _08373_ _08374_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_946 VPWR VGND sg13g2_fill_1
X_14464_ net1006 VPWR _05764_ VGND net512 u_FIR.sum\[4\]\[17\] sg13g2_o21ai_1
X_16203_ VGND VPWR net475 _07439_ _00198_ _07440_ sg13g2_a21oi_1
X_13415_ _04757_ _04740_ _04755_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_823 VPWR VGND sg13g2_decap_4
XFILLER_127_300 VPWR VGND sg13g2_decap_8
X_17183_ _08339_ _08329_ _08338_ VPWR VGND sg13g2_nand2_1
X_14395_ _05698_ u_FIR.sum\[3\]\[14\] net399 VPWR VGND sg13g2_nand2_1
X_16134_ _07373_ _07372_ _07368_ VPWR VGND sg13g2_nand2b_1
X_13346_ _04690_ _04678_ _04689_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_366 VPWR VGND sg13g2_fill_2
XFILLER_5_151 VPWR VGND sg13g2_decap_8
X_16065_ _07304_ _07297_ _07306_ VPWR VGND sg13g2_xor2_1
X_13277_ _04615_ _04622_ _04623_ VPWR VGND sg13g2_nor2b_1
XFILLER_5_173 VPWR VGND sg13g2_decap_4
X_15016_ _06290_ _06279_ _06292_ VPWR VGND sg13g2_xor2_1
X_12228_ _03611_ net725 net881 VPWR VGND sg13g2_nand2_1
X_23461__1549 VPWR VGND net1548 sg13g2_tiehi
XFILLER_69_626 VPWR VGND sg13g2_decap_4
XFILLER_38_4 VPWR VGND sg13g2_fill_1
X_19824_ net2134 VPWR _10881_ VGND _03326_ _10830_ sg13g2_o21ai_1
XFILLER_2_880 VPWR VGND sg13g2_decap_8
X_12159_ _03568_ net290 coeff_force_packed\[0\] _03404_ u_debug_unit.mon_w7_sync\[0\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_97_979 VPWR VGND sg13g2_fill_2
XFILLER_110_244 VPWR VGND sg13g2_fill_1
XFILLER_96_467 VPWR VGND sg13g2_decap_8
X_19755_ _10815_ VPWR _10819_ VGND _10422_ _10818_ sg13g2_o21ai_1
X_16967_ _08116_ VPWR _08123_ VGND _08078_ _08114_ sg13g2_o21ai_1
X_18706_ _09793_ _09787_ _09792_ VPWR VGND sg13g2_xnor2_1
X_15918_ net1001 VPWR _07164_ VGND net498 u_FIR.sum\[7\]\[14\] sg13g2_o21ai_1
X_19686_ _03327_ _10749_ _10750_ VPWR VGND sg13g2_nor2_1
X_16898_ _08054_ _08053_ _08032_ VPWR VGND sg13g2_nand2b_1
XFILLER_76_180 VPWR VGND sg13g2_fill_1
XFILLER_92_651 VPWR VGND sg13g2_fill_1
XFILLER_80_802 VPWR VGND sg13g2_fill_1
XFILLER_65_876 VPWR VGND sg13g2_fill_1
X_18637_ VGND VPWR net56 _09732_ _09733_ net32 sg13g2_a21oi_1
X_15849_ _07097_ _07096_ _07090_ VPWR VGND sg13g2_nand2b_1
XFILLER_18_770 VPWR VGND sg13g2_decap_4
XFILLER_91_172 VPWR VGND sg13g2_decap_4
X_18568_ _09676_ _09677_ _09675_ _09678_ VPWR VGND sg13g2_nand3_1
XFILLER_21_902 VPWR VGND sg13g2_fill_2
X_17519_ _08642_ VPWR _08652_ VGND _08609_ _08643_ sg13g2_o21ai_1
X_18499_ _09609_ _09538_ _09539_ VPWR VGND sg13g2_xnor2_1
X_20530_ _01170_ _01169_ _01164_ VPWR VGND sg13g2_nand2b_1
XFILLER_21_979 VPWR VGND sg13g2_fill_2
X_20461_ _01113_ _01065_ _01112_ VPWR VGND sg13g2_xnor2_1
X_22200_ _02780_ _02793_ _02794_ VPWR VGND sg13g2_nor2_1
X_23180_ net1515 VGND VPWR _00242_ u_FIR.w\[3\]\[4\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
X_20392_ _01052_ VPWR _01055_ VGND _03318_ net75 sg13g2_o21ai_1
XFILLER_118_366 VPWR VGND sg13g2_decap_8
X_22131_ _02723_ _02724_ _02725_ VPWR VGND sg13g2_and2_1
X_22062_ _02656_ net586 net203 VPWR VGND sg13g2_nand2_1
XFILLER_0_806 VPWR VGND sg13g2_decap_8
XFILLER_88_913 VPWR VGND sg13g2_fill_2
X_21013_ _01652_ _01648_ _01651_ _01653_ VGND VPWR _01646_ sg13g2_nor4_2
XFILLER_102_734 VPWR VGND sg13g2_decap_8
XFILLER_102_745 VPWR VGND sg13g2_fill_1
XFILLER_75_607 VPWR VGND sg13g2_fill_2
XFILLER_114_23 VPWR VGND sg13g2_fill_1
XFILLER_74_106 VPWR VGND sg13g2_fill_1
XFILLER_68_670 VPWR VGND sg13g2_decap_4
XFILLER_101_277 VPWR VGND sg13g2_fill_1
XFILLER_68_681 VPWR VGND sg13g2_fill_2
X_22964_ u_spi_slave.rd_toggle _00795_ VPWR VGND sg13g2_buf_1
XFILLER_114_78 VPWR VGND sg13g2_fill_2
XFILLER_74_49 VPWR VGND sg13g2_decap_4
X_21915_ _02502_ VPWR _02509_ VGND _02468_ _02500_ sg13g2_o21ai_1
XFILLER_28_578 VPWR VGND sg13g2_decap_8
XFILLER_43_504 VPWR VGND sg13g2_fill_1
X_22895_ _03176_ net297 u_FIR.x\[4\] net298 u_s2p_input.reg_sh\[3\] VPWR VGND sg13g2_a22oi_1
X_21846_ _02440_ _02437_ _02438_ VPWR VGND sg13g2_xnor2_1
XFILLER_70_345 VPWR VGND sg13g2_fill_1
XFILLER_24_740 VPWR VGND sg13g2_fill_1
XFILLER_130_77 VPWR VGND sg13g2_decap_8
XFILLER_30_209 VPWR VGND sg13g2_fill_2
X_21777_ _02363_ _02370_ _02371_ VPWR VGND sg13g2_and2_1
X_23516_ net1352 VGND VPWR _00578_ u_LMS.count\[19\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
X_20728_ VPWR _01368_ _01367_ VGND sg13g2_inv_1
XFILLER_8_906 VPWR VGND sg13g2_fill_2
XFILLER_23_64 VPWR VGND sg13g2_fill_1
XFILLER_109_300 VPWR VGND sg13g2_decap_4
X_23447_ net1590 VGND VPWR _00509_ u_LMS.x_r\[2\]\[6\] clknet_leaf_65_clkA sg13g2_dfrbpq_1
X_20659_ _01299_ _01296_ _01297_ VPWR VGND sg13g2_xnor2_1
X_13200_ _04517_ _04547_ _04548_ VPWR VGND sg13g2_and2_1
XFILLER_20_990 VPWR VGND sg13g2_fill_1
X_14180_ _05489_ net760 net851 VPWR VGND sg13g2_nand2_1
X_23378_ net1214 VGND VPWR _00440_ u_LMS.w\[6\]\[11\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
X_13131_ _04480_ net741 net883 VPWR VGND sg13g2_nand2_1
XFILLER_3_611 VPWR VGND sg13g2_decap_4
X_22329_ _02792_ _02791_ _02907_ VPWR VGND sg13g2_xor2_1
XFILLER_87_1057 VPWR VGND sg13g2_decap_4
X_13062_ VGND VPWR _04382_ _04396_ _04413_ _04395_ sg13g2_a21oi_1
XFILLER_2_154 VPWR VGND sg13g2_fill_1
X_12013_ _03417_ net326 _03430_ VPWR VGND sg13g2_nor2_1
XFILLER_79_946 VPWR VGND sg13g2_decap_4
XFILLER_3_699 VPWR VGND sg13g2_decap_4
X_17870_ _08942_ _08935_ _09003_ VPWR VGND sg13g2_xor2_1
XFILLER_78_423 VPWR VGND sg13g2_decap_8
XFILLER_132_391 VPWR VGND sg13g2_decap_8
X_16821_ _07977_ net702 net160 VPWR VGND sg13g2_nand2_1
XFILLER_66_618 VPWR VGND sg13g2_decap_8
Xfanout480 net481 net480 VPWR VGND sg13g2_buf_1
Xclkbuf_leaf_51_clkA clknet_4_6_0_clkA clknet_leaf_51_clkA VPWR VGND sg13g2_buf_8
Xfanout491 net494 net491 VPWR VGND sg13g2_buf_1
XFILLER_120_597 VPWR VGND sg13g2_decap_8
X_19540_ _10604_ _10600_ _10603_ VPWR VGND sg13g2_nand2_1
X_16752_ VPWR _07908_ _07907_ VGND sg13g2_inv_1
X_13964_ _05279_ VPWR _05282_ VGND _05267_ _05276_ sg13g2_o21ai_1
XFILLER_46_320 VPWR VGND sg13g2_decap_8
XFILLER_0_35 VPWR VGND sg13g2_decap_8
X_15703_ _06948_ _06954_ _06955_ VPWR VGND sg13g2_nor2b_1
X_12915_ _04275_ _04250_ _04274_ VPWR VGND sg13g2_xnor2_1
XFILLER_62_802 VPWR VGND sg13g2_fill_1
X_19471_ net208 _10534_ net643 _10535_ VPWR VGND sg13g2_nand3_1
X_16683_ u_LMS.w\[7\]\[24\] _07852_ _07853_ VPWR VGND sg13g2_nor2_1
X_13895_ _05217_ _05216_ _05195_ VPWR VGND sg13g2_nand2b_1
XFILLER_47_898 VPWR VGND sg13g2_fill_2
X_18422_ _09532_ net683 net253 VPWR VGND sg13g2_nand2_1
X_15634_ _06886_ _06860_ _06888_ VPWR VGND sg13g2_xor2_1
X_12846_ net1039 VPWR _04208_ VGND net545 u_FIR.sum\[1\]\[9\] sg13g2_o21ai_1
XFILLER_61_356 VPWR VGND sg13g2_decap_4
X_18353_ _03265_ _03266_ net176 net159 _09463_ VPWR VGND sg13g2_nor4_1
X_15565_ net973 VPWR _06821_ VGND net477 u_FIR.sum\[7\]\[4\] sg13g2_o21ai_1
XFILLER_61_378 VPWR VGND sg13g2_decap_8
XFILLER_21_209 VPWR VGND sg13g2_fill_1
X_12777_ _04138_ _04139_ _04140_ VPWR VGND sg13g2_and2_1
XFILLER_61_389 VPWR VGND sg13g2_fill_1
X_17304_ _08460_ _03356_ _08413_ VPWR VGND sg13g2_nand2_1
X_14516_ _05811_ net770 net890 VPWR VGND sg13g2_nand2_1
X_18284_ _09394_ net676 net217 VPWR VGND sg13g2_nand2_1
X_15496_ _06755_ _06753_ _06754_ VPWR VGND sg13g2_xnor2_1
XFILLER_14_294 VPWR VGND sg13g2_fill_2
XFILLER_9_88 VPWR VGND sg13g2_fill_1
X_17235_ _08391_ _08385_ _08390_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_776 VPWR VGND sg13g2_fill_1
X_14447_ VGND VPWR _05746_ _05747_ _05748_ net412 sg13g2_a21oi_1
XFILLER_128_653 VPWR VGND sg13g2_decap_8
X_17166_ _08309_ _08321_ _08322_ VPWR VGND sg13g2_nor2_1
X_14378_ _05682_ _05681_ _05650_ VPWR VGND sg13g2_nand2b_1
XFILLER_127_141 VPWR VGND sg13g2_decap_8
X_16117_ _07357_ _07327_ _07356_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_697 VPWR VGND sg13g2_decap_8
X_13329_ VGND VPWR net538 _04672_ _00091_ _04673_ sg13g2_a21oi_1
X_17097_ _08179_ _08173_ _08253_ VPWR VGND sg13g2_xor2_1
X_16048_ _07289_ _07287_ _07288_ _07270_ _07238_ VPWR VGND sg13g2_a22oi_1
XFILLER_131_829 VPWR VGND sg13g2_fill_2
X_19807_ _10868_ net310 u_LMS.w\[4\]\[15\] coeff_force_packed\[31\] net562 VPWR VGND
+ sg13g2_a22oi_1
X_23182__1513 VPWR VGND net1512 sg13g2_tiehi
XFILLER_29_0 VPWR VGND sg13g2_fill_2
X_23210__1464 VPWR VGND net1463 sg13g2_tiehi
XFILLER_97_798 VPWR VGND sg13g2_fill_2
X_17999_ _09125_ _09070_ _09124_ VPWR VGND sg13g2_xnor2_1
XFILLER_84_426 VPWR VGND sg13g2_decap_4
X_19738_ _10802_ u_LMS.w\[4\]\[13\] _10751_ VPWR VGND sg13g2_xnor2_1
XFILLER_84_459 VPWR VGND sg13g2_decap_4
XFILLER_65_640 VPWR VGND sg13g2_decap_8
X_19669_ _10730_ _10732_ _10733_ VPWR VGND sg13g2_and2_1
XFILLER_92_470 VPWR VGND sg13g2_fill_2
XFILLER_65_695 VPWR VGND sg13g2_fill_2
X_21700_ _02304_ net377 _02251_ VPWR VGND sg13g2_nand2_2
XFILLER_53_846 VPWR VGND sg13g2_decap_8
X_22680_ coeff_force_packed\[48\] net461 _03067_ _00670_ VPWR VGND sg13g2_mux2_1
X_21631_ _02246_ _02247_ net2154 _02248_ VPWR VGND sg13g2_nand3_1
XFILLER_127_1051 VPWR VGND sg13g2_decap_8
X_21562_ _03299_ _02178_ _02179_ VPWR VGND sg13g2_nor2_1
XFILLER_21_743 VPWR VGND sg13g2_fill_2
XFILLER_21_754 VPWR VGND sg13g2_fill_1
XFILLER_20_242 VPWR VGND sg13g2_fill_2
X_23301_ net1300 VGND VPWR _00363_ u_LMS.w\[3\]\[3\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
XFILLER_60_29 VPWR VGND sg13g2_fill_2
X_20513_ _01150_ _01152_ _01153_ VPWR VGND sg13g2_nor2_1
X_21493_ VPWR _02110_ _02109_ VGND sg13g2_inv_1
X_20444_ VGND VPWR _01098_ _01099_ _00402_ net940 sg13g2_a21oi_1
X_23232_ net1423 VGND VPWR _00294_ u_LMS.w\[0\]\[3\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
X_20375_ _01038_ _01037_ _00981_ VPWR VGND sg13g2_nand2b_1
X_23163_ net1544 VGND VPWR _00225_ u_FIR.w\[1\]\[1\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
XFILLER_107_7 VPWR VGND sg13g2_fill_2
X_22114_ _02600_ _02578_ _02599_ _02708_ VPWR VGND sg13g2_a21o_1
X_23094_ net1065 VGND VPWR _00156_ u_FIR.sum\[5\]\[18\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
XFILLER_121_317 VPWR VGND sg13g2_fill_1
X_22045_ _02638_ VPWR _02639_ VGND _02610_ _02636_ sg13g2_o21ai_1
XFILLER_88_743 VPWR VGND sg13g2_fill_1
XFILLER_102_542 VPWR VGND sg13g2_decap_8
XFILLER_130_873 VPWR VGND sg13g2_decap_4
XFILLER_125_77 VPWR VGND sg13g2_decap_4
XFILLER_69_990 VPWR VGND sg13g2_decap_8
XFILLER_75_437 VPWR VGND sg13g2_fill_2
XFILLER_28_320 VPWR VGND sg13g2_fill_2
XFILLER_28_331 VPWR VGND sg13g2_fill_2
XFILLER_28_342 VPWR VGND sg13g2_decap_8
X_23014__1186 VPWR VGND net1185 sg13g2_tiehi
X_22947_ net470 u_spi_slave.rx_shift\[0\] _03575_ _00804_ VPWR VGND sg13g2_mux2_1
XFILLER_83_470 VPWR VGND sg13g2_fill_1
XFILLER_18_97 VPWR VGND sg13g2_fill_1
X_12700_ VGND VPWR _04065_ _04064_ _04025_ sg13g2_or2_1
XFILLER_83_492 VPWR VGND sg13g2_fill_2
X_13680_ net864 _05007_ net748 _05008_ VPWR VGND sg13g2_nand3_1
X_22878_ u_p2s_output.reg_cnt\[1\] _03164_ _03167_ VPWR VGND sg13g2_and2_1
XFILLER_70_131 VPWR VGND sg13g2_fill_1
XFILLER_44_879 VPWR VGND sg13g2_fill_1
X_12631_ _03998_ _03992_ _03996_ VPWR VGND sg13g2_xnor2_1
X_21829_ _02403_ _02401_ _02420_ _02423_ VPWR VGND sg13g2_a21o_1
X_15350_ VPWR _06617_ _06616_ VGND sg13g2_inv_1
X_12562_ _03921_ _03861_ _03934_ VPWR VGND sg13g2_xor2_1
XFILLER_8_703 VPWR VGND sg13g2_fill_2
X_14301_ _05607_ u_FIR.w\[4\]\[6\] net838 VPWR VGND sg13g2_nand2b_1
XFILLER_7_202 VPWR VGND sg13g2_decap_4
X_15281_ _06549_ net250 _06550_ VPWR VGND sg13g2_xor2_1
X_12493_ net827 _03867_ net719 _03868_ VPWR VGND sg13g2_nand3_1
XFILLER_12_798 VPWR VGND sg13g2_decap_8
X_17020_ VGND VPWR _08176_ _08175_ _08174_ sg13g2_or2_1
X_14232_ VGND VPWR net822 _05538_ _05540_ _05537_ sg13g2_a21oi_1
XFILLER_7_257 VPWR VGND sg13g2_fill_1
XFILLER_50_62 VPWR VGND sg13g2_fill_1
X_14163_ _05473_ _05468_ _05471_ VPWR VGND sg13g2_xnor2_1
X_13114_ _04464_ _04463_ _04425_ VPWR VGND sg13g2_nand2b_1
XFILLER_125_678 VPWR VGND sg13g2_fill_2
X_18971_ _10049_ _10057_ _10058_ VPWR VGND sg13g2_nor2_1
X_14094_ _05404_ _05405_ _00124_ VPWR VGND sg13g2_nor2_1
XFILLER_79_721 VPWR VGND sg13g2_fill_2
XFILLER_3_485 VPWR VGND sg13g2_decap_8
X_17922_ _09055_ _09053_ _09054_ VPWR VGND sg13g2_nand2_1
X_13045_ _04397_ _04381_ _04396_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_199 VPWR VGND sg13g2_fill_2
XFILLER_78_220 VPWR VGND sg13g2_decap_8
XFILLER_78_231 VPWR VGND sg13g2_fill_1
XFILLER_121_840 VPWR VGND sg13g2_decap_4
XFILLER_59_93 VPWR VGND sg13g2_fill_2
XFILLER_22_7 VPWR VGND sg13g2_fill_2
X_17853_ _08986_ _08967_ _08968_ VPWR VGND sg13g2_xnor2_1
XFILLER_120_372 VPWR VGND sg13g2_decap_8
X_16804_ _07960_ _07957_ _07955_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_757 VPWR VGND sg13g2_fill_1
X_17784_ net206 net697 _08888_ _08917_ VPWR VGND sg13g2_a21o_1
X_14996_ VPWR _06273_ _06272_ VGND sg13g2_inv_1
XFILLER_82_908 VPWR VGND sg13g2_decap_8
XFILLER_81_407 VPWR VGND sg13g2_fill_2
X_19523_ _10573_ VPWR _10587_ VGND _10570_ _10575_ sg13g2_o21ai_1
XFILLER_75_70 VPWR VGND sg13g2_fill_1
X_16735_ u_FIR.sum\[8\]\[18\] u_FIR.sum\[8\]\[17\] u_FIR.sum\[8\]\[16\] u_FIR.sum\[8\]\[15\]
+ _07891_ VPWR VGND sg13g2_and4_1
X_13947_ _05190_ _05257_ _05266_ VPWR VGND sg13g2_nor2_1
XFILLER_81_418 VPWR VGND sg13g2_fill_1
XFILLER_93_289 VPWR VGND sg13g2_decap_4
XFILLER_75_993 VPWR VGND sg13g2_fill_1
XFILLER_75_92 VPWR VGND sg13g2_fill_2
X_19454_ _10518_ _10515_ _10516_ VPWR VGND sg13g2_xnor2_1
X_16666_ VGND VPWR u_LMS.w\[6\]\[15\] _07832_ _07840_ _07833_ sg13g2_a21oi_1
XFILLER_35_857 VPWR VGND sg13g2_fill_1
X_13878_ _05201_ _05194_ _05199_ VPWR VGND sg13g2_xnor2_1
XFILLER_61_131 VPWR VGND sg13g2_decap_8
XFILLER_62_665 VPWR VGND sg13g2_fill_1
X_18405_ _09508_ VPWR _09515_ VGND _09502_ _09509_ sg13g2_o21ai_1
X_15617_ VGND VPWR _06871_ _06869_ _06831_ sg13g2_or2_1
XFILLER_22_507 VPWR VGND sg13g2_decap_8
X_12829_ VPWR _04191_ _04190_ VGND sg13g2_inv_1
XFILLER_62_687 VPWR VGND sg13g2_decap_8
XFILLER_61_164 VPWR VGND sg13g2_fill_2
XFILLER_22_518 VPWR VGND sg13g2_fill_1
X_19385_ _10449_ _10446_ _10447_ VPWR VGND sg13g2_xnor2_1
X_16597_ u_LMS.w\[4\]\[19\] u_LMS.w\[4\]\[18\] u_LMS.w\[4\]\[20\] _07788_ VPWR VGND
+ sg13g2_nand3_1
XFILLER_22_529 VPWR VGND sg13g2_fill_2
XFILLER_61_175 VPWR VGND sg13g2_decap_8
XFILLER_43_890 VPWR VGND sg13g2_fill_1
XFILLER_91_80 VPWR VGND sg13g2_fill_1
X_18336_ _09446_ _09402_ _09413_ VPWR VGND sg13g2_xnor2_1
X_15548_ _06804_ _06795_ _06802_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_562 VPWR VGND sg13g2_decap_8
X_18267_ _09375_ _09376_ _09377_ VPWR VGND sg13g2_nor2_1
X_15479_ _06740_ u_FIR.sum\[5\]\[18\] _06723_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_584 VPWR VGND sg13g2_decap_8
X_17218_ _08162_ _08132_ _08374_ VPWR VGND sg13g2_xor2_1
X_18198_ _09308_ _09303_ _09306_ VPWR VGND sg13g2_xnor2_1
X_17149_ _08305_ _08283_ _08304_ VPWR VGND sg13g2_nand2_1
Xfanout7 _02848_ net7 VPWR VGND sg13g2_buf_2
X_20160_ _00823_ net633 net172 VPWR VGND sg13g2_nand2_1
XFILLER_118_1017 VPWR VGND sg13g2_decap_8
XFILLER_131_637 VPWR VGND sg13g2_decap_4
XFILLER_115_188 VPWR VGND sg13g2_fill_1
X_20091_ _11128_ _11127_ _11131_ _11132_ VPWR VGND sg13g2_a21o_1
XFILLER_97_540 VPWR VGND sg13g2_fill_1
XFILLER_29_106 VPWR VGND sg13g2_fill_1
XFILLER_58_949 VPWR VGND sg13g2_fill_2
Xclkbuf_leaf_3_clkA clknet_4_2_0_clkA clknet_leaf_3_clkA VPWR VGND sg13g2_buf_8
XFILLER_84_223 VPWR VGND sg13g2_fill_2
XFILLER_111_394 VPWR VGND sg13g2_fill_2
XFILLER_84_234 VPWR VGND sg13g2_decap_8
XFILLER_73_908 VPWR VGND sg13g2_fill_1
X_22801_ VGND VPWR _07838_ net350 _00740_ _03118_ sg13g2_a21oi_1
XFILLER_72_418 VPWR VGND sg13g2_decap_4
XFILLER_44_109 VPWR VGND sg13g2_decap_4
X_23781_ net983 VGND VPWR _00039_ _00023_ clknet_leaf_51_clkA sg13g2_dfrbpq_1
X_20993_ VPWR VGND _01630_ _01575_ _01629_ u_LMS.w\[6\]\[15\] _01633_ _01571_ sg13g2_a221oi_1
XFILLER_77_1034 VPWR VGND sg13g2_fill_2
XFILLER_37_183 VPWR VGND sg13g2_fill_2
XFILLER_26_846 VPWR VGND sg13g2_decap_8
X_22732_ u_debug_unit.mon_w1_sync\[3\] net333 _03084_ VPWR VGND sg13g2_nor2_1
X_23010__1192 VPWR VGND net1191 sg13g2_tiehi
XFILLER_41_816 VPWR VGND sg13g2_fill_1
XFILLER_111_57 VPWR VGND sg13g2_fill_2
XFILLER_53_687 VPWR VGND sg13g2_decap_8
X_22663_ u_debug_unit.force_w4\[7\] net459 _03065_ _00655_ VPWR VGND sg13g2_mux2_1
XFILLER_40_304 VPWR VGND sg13g2_fill_1
XFILLER_34_890 VPWR VGND sg13g2_decap_4
X_21614_ _02231_ u_LMS.w\[7\]\[18\] net64 VPWR VGND sg13g2_xnor2_1
X_22594_ net470 u_debug_unit.sw_reset\[1\] _03058_ _00593_ VPWR VGND sg13g2_mux2_1
X_21545_ _02162_ u_LMS.w\[7\]\[16\] _02160_ VPWR VGND sg13g2_xnor2_1
X_21476_ _02085_ _02092_ _02093_ VPWR VGND sg13g2_nor2_1
XFILLER_107_612 VPWR VGND sg13g2_fill_1
X_23215_ net1454 VGND VPWR _00277_ u_FIR.w\[8\]\[4\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
XFILLER_119_483 VPWR VGND sg13g2_fill_1
X_20427_ _01086_ net2129 _01043_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_32 VPWR VGND sg13g2_decap_8
XFILLER_107_656 VPWR VGND sg13g2_fill_1
X_23146_ net1570 VGND VPWR _00208_ u_FIR.sum\[8\]\[18\] clknet_leaf_43_clkA sg13g2_dfrbpq_2
X_20358_ _01021_ _01020_ _00994_ VPWR VGND sg13g2_nand2b_1
XFILLER_122_615 VPWR VGND sg13g2_fill_1
XFILLER_96_14 VPWR VGND sg13g2_fill_1
X_20289_ _00952_ _11090_ _11089_ VPWR VGND sg13g2_nand2b_1
X_23077_ net1090 VGND VPWR _00139_ u_FIR.sum\[5\]\[1\] clknet_leaf_51_clkA sg13g2_dfrbpq_1
X_22028_ _02622_ _02619_ _02621_ VPWR VGND sg13g2_nand2_1
XFILLER_1_989 VPWR VGND sg13g2_decap_8
X_14850_ _06136_ u_FIR.sum\[4\]\[12\] net397 VPWR VGND sg13g2_xnor2_1
XFILLER_60_1060 VPWR VGND sg13g2_fill_1
X_13801_ _05124_ _05125_ _05126_ VPWR VGND sg13g2_nor2_1
XFILLER_17_802 VPWR VGND sg13g2_decap_4
X_23296__1307 VPWR VGND net1306 sg13g2_tiehi
X_14781_ VPWR _06069_ _06068_ VGND sg13g2_inv_1
X_11993_ net327 _03409_ _03410_ VPWR VGND sg13g2_nor2_1
X_16520_ _07732_ _07730_ _07731_ VPWR VGND sg13g2_nand2_1
XFILLER_84_790 VPWR VGND sg13g2_decap_4
X_13732_ _05053_ _05058_ _05059_ VPWR VGND sg13g2_nor2b_1
XFILLER_91_1009 VPWR VGND sg13g2_decap_8
X_16451_ net1001 VPWR _07680_ VGND net497 u_FIR.sum\[8\]\[17\] sg13g2_o21ai_1
X_13663_ _04991_ _04983_ _04992_ VPWR VGND sg13g2_xor2_1
XFILLER_71_495 VPWR VGND sg13g2_fill_1
X_15402_ VGND VPWR _06639_ _06647_ _06667_ _06654_ sg13g2_a21oi_1
X_19170_ _10250_ _10251_ _10256_ _10257_ VPWR VGND sg13g2_nor3_1
X_12614_ _03982_ _03974_ _03981_ VPWR VGND sg13g2_nand2_1
X_16382_ _07613_ net270 _07614_ VPWR VGND sg13g2_xor2_1
X_13594_ _04910_ VPWR _04924_ VGND _04905_ _04908_ sg13g2_o21ai_1
XFILLER_31_359 VPWR VGND sg13g2_fill_1
X_18121_ _09229_ _09230_ _09231_ VPWR VGND sg13g2_nor2b_1
X_15333_ _06599_ _06569_ _06601_ VPWR VGND sg13g2_xor2_1
X_12545_ _03894_ _03917_ _03865_ _03918_ VPWR VGND sg13g2_nand3_1
XFILLER_12_595 VPWR VGND sg13g2_decap_4
X_18052_ VPWR VGND _09165_ _08554_ net37 _03344_ _00322_ net369 sg13g2_a221oi_1
X_15264_ _06518_ VPWR _06533_ VGND _06514_ _06516_ sg13g2_o21ai_1
XFILLER_8_566 VPWR VGND sg13g2_fill_1
X_12476_ _03852_ _03822_ _03850_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_577 VPWR VGND sg13g2_decap_8
X_17003_ _08125_ _08122_ _08159_ VPWR VGND sg13g2_xor2_1
X_14215_ _05522_ _05523_ _00127_ VPWR VGND sg13g2_nor2_1
XANTENNA_5 VPWR VGND net2067 sg13g2_antennanp
X_15195_ _06466_ net835 net778 net820 net780 VPWR VGND sg13g2_a22oi_1
XFILLER_6_56 VPWR VGND sg13g2_decap_8
XFILLER_125_431 VPWR VGND sg13g2_fill_1
X_14146_ _05456_ _05450_ _05454_ VPWR VGND sg13g2_xnor2_1
XFILLER_113_615 VPWR VGND sg13g2_decap_8
XFILLER_113_648 VPWR VGND sg13g2_fill_1
X_18954_ _10041_ net662 net218 VPWR VGND sg13g2_nand2_1
X_14077_ net838 u_FIR.sum\[3\]\[5\] net766 _05389_ VPWR VGND sg13g2_nand3_1
XFILLER_79_540 VPWR VGND sg13g2_fill_1
XFILLER_3_293 VPWR VGND sg13g2_fill_2
XFILLER_100_309 VPWR VGND sg13g2_decap_8
X_17905_ _09038_ _09037_ _08992_ VPWR VGND sg13g2_nand2b_1
X_13028_ net882 u_FIR.sum\[1\]\[2\] net746 _04381_ VPWR VGND sg13g2_nand3_1
XFILLER_39_404 VPWR VGND sg13g2_decap_4
X_18885_ _09964_ _09963_ _09966_ _09972_ VPWR VGND sg13g2_a21o_1
XFILLER_121_681 VPWR VGND sg13g2_decap_8
XFILLER_121_692 VPWR VGND sg13g2_fill_2
X_23067__1106 VPWR VGND net1105 sg13g2_tiehi
X_17836_ VGND VPWR _08967_ _08968_ _08969_ _08763_ sg13g2_a21oi_1
XFILLER_66_245 VPWR VGND sg13g2_decap_4
XFILLER_67_779 VPWR VGND sg13g2_fill_1
XFILLER_66_267 VPWR VGND sg13g2_decap_4
X_17767_ _08892_ _08890_ _08894_ _08900_ VPWR VGND sg13g2_a21o_1
X_14979_ net1007 VPWR _06259_ VGND net510 u_FIR.sum\[5\]\[18\] sg13g2_o21ai_1
X_19506_ _10570_ net648 net169 VPWR VGND sg13g2_nand2_1
X_16718_ net1029 VPWR _07879_ VGND net526 net724 sg13g2_o21ai_1
X_17698_ _08831_ net696 net186 VPWR VGND sg13g2_nand2_1
XFILLER_23_816 VPWR VGND sg13g2_fill_2
X_19437_ net642 net237 net639 _10501_ VPWR VGND net208 sg13g2_nand4_1
X_16649_ VGND VPWR _03315_ net533 _00258_ _07826_ sg13g2_a21oi_1
X_23134__1589 VPWR VGND net1588 sg13g2_tiehi
XFILLER_96_0 VPWR VGND sg13g2_decap_8
XFILLER_37_1040 VPWR VGND sg13g2_fill_1
X_19368_ _10414_ _10412_ _10431_ _10432_ VPWR VGND sg13g2_a21o_1
X_18319_ _09429_ _09425_ _09428_ VPWR VGND sg13g2_nand2_1
X_19299_ _10363_ net85 _10362_ VPWR VGND sg13g2_nand2_1
XFILLER_124_1054 VPWR VGND sg13g2_decap_8
X_21330_ _01947_ net599 net189 VPWR VGND sg13g2_nand2_1
XFILLER_129_781 VPWR VGND sg13g2_decap_8
XFILLER_117_921 VPWR VGND sg13g2_decap_8
X_21261_ _01870_ _01877_ _01878_ VPWR VGND sg13g2_nor2b_1
XFILLER_128_291 VPWR VGND sg13g2_fill_1
X_23000_ net1206 VGND VPWR _00062_ u_FIR.sum\[0\]\[12\] clknet_leaf_29_clkA sg13g2_dfrbpq_1
Xrebuffer2200 net2200 net2199 VPWR VGND sg13g2_buf_2
X_20212_ net636 net633 net192 _00875_ VPWR VGND net230 sg13g2_nand4_1
Xrebuffer2211 _09041_ net2210 VPWR VGND sg13g2_buf_1
X_21192_ _01806_ _01808_ _01809_ VPWR VGND sg13g2_and2_1
XFILLER_104_648 VPWR VGND sg13g2_fill_2
X_20143_ _11178_ VPWR _11184_ VGND _11174_ _11179_ sg13g2_o21ai_1
XFILLER_132_968 VPWR VGND sg13g2_decap_8
XFILLER_89_359 VPWR VGND sg13g2_fill_2
X_20074_ _11115_ _11111_ _11114_ VPWR VGND sg13g2_nand2_1
XFILLER_106_68 VPWR VGND sg13g2_fill_1
X_23753__1347 VPWR VGND net1346 sg13g2_tiehi
XFILLER_57_234 VPWR VGND sg13g2_fill_2
XFILLER_131_1058 VPWR VGND sg13g2_fill_2
XFILLER_57_278 VPWR VGND sg13g2_decap_8
XFILLER_45_429 VPWR VGND sg13g2_fill_1
XFILLER_26_621 VPWR VGND sg13g2_fill_1
X_23764_ net994 VGND VPWR _00011_ u_spi_slave.rx_shift\[6\] clknet_3_4__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_20976_ u_LMS.w\[6\]\[9\] _01585_ _01616_ VPWR VGND sg13g2_nor2_1
XFILLER_25_142 VPWR VGND sg13g2_decap_8
XFILLER_14_816 VPWR VGND sg13g2_fill_2
X_22715_ VGND VPWR _07717_ net343 _00697_ _03075_ sg13g2_a21oi_1
X_23292__1313 VPWR VGND net1312 sg13g2_tiehi
XFILLER_54_996 VPWR VGND sg13g2_fill_2
X_23695_ net987 VGND VPWR _00757_ u_debug_unit.mon_w8_sync\[5\] clknet_leaf_38_clkA
+ sg13g2_dfrbpq_1
XFILLER_13_326 VPWR VGND sg13g2_decap_8
XFILLER_25_197 VPWR VGND sg13g2_fill_1
XFILLER_13_348 VPWR VGND sg13g2_decap_8
X_22646_ _03064_ net429 net289 VPWR VGND sg13g2_nand2_1
XFILLER_15_65 VPWR VGND sg13g2_fill_1
X_22577_ _03214_ _03047_ _03049_ VPWR VGND sg13g2_and2_1
X_12330_ VGND VPWR _03673_ _03675_ _03710_ _03708_ sg13g2_a21oi_1
X_21528_ VGND VPWR _01817_ _01819_ _02145_ _02144_ sg13g2_a21oi_1
XFILLER_31_31 VPWR VGND sg13g2_fill_1
XFILLER_31_64 VPWR VGND sg13g2_decap_8
X_12261_ _03641_ _03642_ _03643_ VPWR VGND sg13g2_nor2_1
XFILLER_5_536 VPWR VGND sg13g2_decap_4
X_21459_ _02075_ VPWR _02076_ VGND _02066_ _02068_ sg13g2_o21ai_1
XFILLER_31_86 VPWR VGND sg13g2_decap_8
X_14000_ _05313_ _05314_ _05315_ VPWR VGND sg13g2_nor2_1
X_12192_ u_LMS.count\[10\] _03215_ u_LMS.count\[8\] u_LMS.count\[7\] _03580_ VPWR
+ VGND sg13g2_nor4_1
X_23129_ net1595 VGND VPWR _00191_ u_FIR.sum\[7\]\[15\] clknet_leaf_43_clkA sg13g2_dfrbpq_1
XFILLER_96_819 VPWR VGND sg13g2_fill_1
XFILLER_122_456 VPWR VGND sg13g2_decap_8
XFILLER_89_860 VPWR VGND sg13g2_fill_2
XFILLER_122_467 VPWR VGND sg13g2_fill_1
X_15951_ VGND VPWR _07173_ _07177_ _07195_ _07194_ sg13g2_a21oi_1
XFILLER_0_263 VPWR VGND sg13g2_decap_8
XFILLER_89_893 VPWR VGND sg13g2_fill_2
XFILLER_88_381 VPWR VGND sg13g2_fill_2
X_14902_ _06186_ _06185_ _06164_ VPWR VGND sg13g2_nand2b_1
X_18670_ net356 VPWR _09758_ VGND u_LMS.w\[2\]\[11\] net372 sg13g2_o21ai_1
X_15882_ _07129_ _07022_ _07127_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_576 VPWR VGND sg13g2_fill_2
X_17621_ _03273_ net92 _08754_ VPWR VGND sg13g2_nor2_1
X_14833_ VGND VPWR _06087_ _06111_ _06119_ _06110_ sg13g2_a21oi_1
XFILLER_5_1060 VPWR VGND sg13g2_fill_1
XFILLER_63_215 VPWR VGND sg13g2_decap_8
XFILLER_63_226 VPWR VGND sg13g2_fill_2
X_23063__1112 VPWR VGND net1111 sg13g2_tiehi
X_17552_ _08679_ _08684_ _08685_ VPWR VGND sg13g2_nor2b_1
X_14764_ net806 VPWR _06052_ VGND u_FIR.w\[3\]\[3\] u_FIR.w\[3\]\[2\] sg13g2_o21ai_1
X_11976_ net946 net328 _03390_ _03394_ _00793_ VPWR VGND sg13g2_nor4_1
XFILLER_60_900 VPWR VGND sg13g2_decap_4
XFILLER_17_676 VPWR VGND sg13g2_fill_1
X_16503_ net971 VPWR _07720_ VGND net475 net797 sg13g2_o21ai_1
X_13715_ _05029_ VPWR _05042_ VGND _05025_ _05027_ sg13g2_o21ai_1
X_17483_ _08613_ _08615_ _08616_ VPWR VGND sg13g2_nor2_1
X_14695_ _05983_ _05984_ _05985_ VPWR VGND sg13g2_nor2b_1
XFILLER_32_624 VPWR VGND sg13g2_decap_8
X_19222_ VGND VPWR u_LMS.w\[3\]\[20\] net305 _10301_ _10292_ sg13g2_a21oi_1
X_16434_ VGND VPWR net497 _07662_ _00206_ _07663_ sg13g2_a21oi_1
X_13646_ _04975_ net752 net838 VPWR VGND sg13g2_nand2_1
XFILLER_72_71 VPWR VGND sg13g2_decap_8
XFILLER_72_93 VPWR VGND sg13g2_decap_8
XFILLER_9_820 VPWR VGND sg13g2_decap_4
X_19153_ _10240_ u_LMS.w\[3\]\[17\] net2083 VPWR VGND sg13g2_xnor2_1
X_16365_ _07598_ _07565_ _07596_ VPWR VGND sg13g2_xnor2_1
X_13577_ _04908_ _04906_ _04907_ VPWR VGND sg13g2_nand2_1
XFILLER_9_853 VPWR VGND sg13g2_decap_4
X_23130__1595 VPWR VGND net1594 sg13g2_tiehi
X_18104_ _09214_ net682 net145 VPWR VGND sg13g2_nand2_1
X_15316_ _06583_ net250 _06584_ VPWR VGND sg13g2_xor2_1
XFILLER_118_718 VPWR VGND sg13g2_fill_1
X_12528_ _03902_ _03891_ _03901_ VPWR VGND sg13g2_nand2_1
X_19084_ _10171_ _09845_ _09844_ VPWR VGND sg13g2_nand2b_1
X_16296_ _07530_ net272 _07531_ VPWR VGND sg13g2_xor2_1
X_18035_ VGND VPWR _09147_ _09152_ _00317_ _09153_ sg13g2_a21oi_1
X_15247_ _06517_ _06513_ _06516_ VPWR VGND sg13g2_xnor2_1
X_12459_ net854 net718 _03835_ VPWR VGND sg13g2_nor2b_1
X_15178_ net980 VPWR _06450_ VGND net485 u_FIR.sum\[6\]\[7\] sg13g2_o21ai_1
X_14129_ _05440_ _05400_ _05403_ _05439_ VPWR VGND sg13g2_and3_1
X_19986_ net425 net229 _11027_ VPWR VGND sg13g2_nor2_1
Xfanout309 _08500_ net309 VPWR VGND sg13g2_buf_1
XFILLER_87_819 VPWR VGND sg13g2_fill_2
XFILLER_113_456 VPWR VGND sg13g2_decap_8
X_18937_ _10022_ _10021_ _10024_ VPWR VGND sg13g2_xor2_1
XFILLER_95_841 VPWR VGND sg13g2_fill_1
XFILLER_67_543 VPWR VGND sg13g2_decap_8
X_18868_ _09955_ _09953_ _09954_ VPWR VGND sg13g2_nand2_1
XFILLER_67_565 VPWR VGND sg13g2_decap_8
XFILLER_11_0 VPWR VGND sg13g2_decap_8
XFILLER_67_576 VPWR VGND sg13g2_fill_2
X_17819_ _08902_ _08903_ _08952_ VPWR VGND sg13g2_and2_1
X_18799_ _09886_ _09884_ _09885_ VPWR VGND sg13g2_nand2_1
XFILLER_82_546 VPWR VGND sg13g2_decap_4
X_20830_ _01462_ _01460_ _01464_ _01470_ VPWR VGND sg13g2_a21o_1
XFILLER_82_557 VPWR VGND sg13g2_fill_1
XFILLER_54_248 VPWR VGND sg13g2_decap_8
XFILLER_36_952 VPWR VGND sg13g2_fill_2
XFILLER_82_568 VPWR VGND sg13g2_decap_8
XFILLER_54_259 VPWR VGND sg13g2_fill_1
XFILLER_70_719 VPWR VGND sg13g2_fill_1
XFILLER_23_613 VPWR VGND sg13g2_fill_2
X_20761_ _01401_ _01365_ _01399_ VPWR VGND sg13g2_xnor2_1
XFILLER_23_635 VPWR VGND sg13g2_decap_8
X_22500_ VGND VPWR net442 net427 _00558_ _02999_ sg13g2_a21oi_1
XFILLER_22_123 VPWR VGND sg13g2_decap_8
XFILLER_22_134 VPWR VGND sg13g2_fill_2
X_23480_ net1483 VGND VPWR _00542_ u_LMS.x_r\[6\]\[7\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
X_20692_ _01332_ _01329_ _01330_ VPWR VGND sg13g2_xnor2_1
XFILLER_50_454 VPWR VGND sg13g2_fill_2
X_22431_ net949 VPWR _02965_ VGND net436 net644 sg13g2_o21ai_1
X_22362_ VGND VPWR net454 _03288_ _00489_ _02930_ sg13g2_a21oi_1
XFILLER_11_1010 VPWR VGND sg13g2_fill_1
X_21313_ _01929_ _01928_ _01930_ VPWR VGND sg13g2_xor2_1
X_22293_ _02877_ _02829_ _02879_ VPWR VGND sg13g2_xor2_1
XFILLER_117_740 VPWR VGND sg13g2_fill_1
X_23323__1279 VPWR VGND net1278 sg13g2_tiehi
XFILLER_123_209 VPWR VGND sg13g2_fill_2
X_21244_ _01859_ VPWR _01861_ VGND _01856_ _01858_ sg13g2_o21ai_1
XFILLER_117_784 VPWR VGND sg13g2_fill_1
XFILLER_116_261 VPWR VGND sg13g2_fill_2
XFILLER_117_45 VPWR VGND sg13g2_decap_8
XFILLER_105_968 VPWR VGND sg13g2_fill_1
X_21175_ VGND VPWR _01766_ _01777_ _01792_ _01776_ sg13g2_a21oi_1
Xrebuffer2063 _01629_ net2062 VPWR VGND sg13g2_buf_1
Xrebuffer2074 _07921_ net2073 VPWR VGND sg13g2_buf_1
Xfanout810 net816 net810 VPWR VGND sg13g2_buf_1
Xfanout821 u_FIR.x_reg\[6\] net821 VPWR VGND sg13g2_buf_1
Xrebuffer2085 _10140_ net2084 VPWR VGND sg13g2_buf_1
X_20126_ _11167_ _11140_ _11141_ VPWR VGND sg13g2_xnor2_1
Xfanout832 net833 net832 VPWR VGND sg13g2_buf_1
Xrebuffer2096 _09549_ net2095 VPWR VGND sg13g2_buf_1
XFILLER_131_264 VPWR VGND sg13g2_decap_8
XFILLER_120_938 VPWR VGND sg13g2_fill_2
Xfanout843 net844 net843 VPWR VGND sg13g2_buf_1
Xfanout854 net857 net854 VPWR VGND sg13g2_buf_1
Xfanout865 net871 net865 VPWR VGND sg13g2_buf_1
X_20057_ _11098_ _11060_ _11062_ VPWR VGND sg13g2_xnor2_1
Xfanout876 net877 net876 VPWR VGND sg13g2_buf_1
Xfanout887 net888 net887 VPWR VGND sg13g2_buf_1
Xfanout898 u_FIR.x_reg\[1\] net898 VPWR VGND sg13g2_buf_1
XFILLER_85_340 VPWR VGND sg13g2_fill_1
XFILLER_18_429 VPWR VGND sg13g2_decap_4
X_11830_ VPWR _03251_ net653 VGND sg13g2_inv_1
X_23223__1440 VPWR VGND net1439 sg13g2_tiehi
XFILLER_14_613 VPWR VGND sg13g2_fill_1
X_23747_ net988 VGND VPWR _00809_ spi_wdata\[6\] clknet_3_1__leaf_spi_sclk sg13g2_dfrbpq_1
X_20959_ _01595_ u_LMS.w\[6\]\[3\] _01599_ VPWR VGND sg13g2_xor2_1
X_13500_ _04818_ VPWR _04834_ VGND _04814_ _04819_ sg13g2_o21ai_1
XFILLER_41_432 VPWR VGND sg13g2_decap_8
XFILLER_14_657 VPWR VGND sg13g2_decap_4
X_14480_ VGND VPWR _05776_ _05777_ _05778_ net412 sg13g2_a21oi_1
XFILLER_42_977 VPWR VGND sg13g2_fill_2
X_23678_ net1029 VGND VPWR _00740_ u_debug_unit.mon_w6_sync\[2\] clknet_leaf_23_clkA
+ sg13g2_dfrbpq_1
XFILLER_41_454 VPWR VGND sg13g2_decap_8
XFILLER_13_167 VPWR VGND sg13g2_decap_4
X_13431_ _04746_ _04771_ _04772_ VPWR VGND sg13g2_nor2b_1
X_22629_ net472 coeff_force_packed\[7\] _03062_ _00624_ VPWR VGND sg13g2_mux2_1
XFILLER_107_1060 VPWR VGND sg13g2_fill_1
X_16150_ _07389_ u_FIR.sum\[7\]\[7\] net386 VPWR VGND sg13g2_xnor2_1
X_13362_ net1036 VPWR _04706_ VGND net538 u_FIR.sum\[2\]\[11\] sg13g2_o21ai_1
X_15101_ _06360_ VPWR _06374_ VGND _06355_ _06358_ sg13g2_o21ai_1
X_12313_ _03693_ _03687_ _03691_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_834 VPWR VGND sg13g2_fill_1
XFILLER_5_311 VPWR VGND sg13g2_fill_2
X_16081_ _07320_ _07291_ _07322_ VPWR VGND sg13g2_xor2_1
XFILLER_5_322 VPWR VGND sg13g2_fill_2
X_13293_ _04606_ _04599_ _04613_ _04638_ VPWR VGND sg13g2_a21o_1
XFILLER_6_856 VPWR VGND sg13g2_fill_1
XFILLER_108_751 VPWR VGND sg13g2_decap_4
XFILLER_6_878 VPWR VGND sg13g2_fill_2
XFILLER_5_344 VPWR VGND sg13g2_decap_8
X_15032_ net979 VPWR _06308_ VGND net484 u_FIR.sum\[6\]\[3\] sg13g2_o21ai_1
X_12244_ _03626_ net722 net881 VPWR VGND sg13g2_nand2_1
XFILLER_123_721 VPWR VGND sg13g2_decap_4
XFILLER_5_399 VPWR VGND sg13g2_decap_8
X_19840_ VGND VPWR _10893_ _10894_ _00381_ net925 sg13g2_a21oi_1
XFILLER_122_220 VPWR VGND sg13g2_fill_1
X_12175_ net945 u_spi_slave.rx_shift\[5\] _00011_ VPWR VGND sg13g2_nor2b_1
XFILLER_123_754 VPWR VGND sg13g2_decap_8
XFILLER_123_776 VPWR VGND sg13g2_fill_1
XFILLER_122_242 VPWR VGND sg13g2_decap_8
XFILLER_3_35 VPWR VGND sg13g2_decap_8
XFILLER_110_404 VPWR VGND sg13g2_fill_1
X_19771_ _10834_ VPWR _10835_ VGND net2134 _10833_ sg13g2_o21ai_1
X_16983_ _08106_ _08104_ _08139_ VPWR VGND sg13g2_xor2_1
XFILLER_122_286 VPWR VGND sg13g2_fill_2
XFILLER_104_990 VPWR VGND sg13g2_decap_4
XFILLER_95_137 VPWR VGND sg13g2_fill_1
XFILLER_77_841 VPWR VGND sg13g2_decap_4
X_18722_ VGND VPWR _09784_ _09795_ _09809_ _09794_ sg13g2_a21oi_1
X_15934_ _07179_ _07178_ _07165_ VPWR VGND sg13g2_nand2b_1
XFILLER_37_727 VPWR VGND sg13g2_decap_8
X_18653_ VGND VPWR net56 _09744_ _09745_ net32 sg13g2_a21oi_1
XFILLER_64_513 VPWR VGND sg13g2_fill_1
X_15865_ _07111_ _07086_ _07113_ VPWR VGND sg13g2_xor2_1
XFILLER_92_833 VPWR VGND sg13g2_fill_2
XFILLER_91_310 VPWR VGND sg13g2_fill_2
X_17604_ _08737_ _08734_ _08736_ VPWR VGND sg13g2_nand2_1
X_14816_ _06103_ u_FIR.sum\[4\]\[11\] net397 VPWR VGND sg13g2_nand2_1
XFILLER_97_1059 VPWR VGND sg13g2_fill_2
XFILLER_52_708 VPWR VGND sg13g2_fill_2
X_18584_ _09691_ _09651_ net2101 VPWR VGND sg13g2_xnor2_1
X_23401__1146 VPWR VGND net1145 sg13g2_tiehi
X_15796_ _07046_ _07017_ _07045_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_888 VPWR VGND sg13g2_decap_8
X_17535_ _08650_ _08648_ _08667_ _08668_ VPWR VGND sg13g2_a21o_1
X_14747_ _06028_ _06035_ _06036_ VPWR VGND sg13g2_nor2b_1
X_11959_ VPWR _03380_ u_FIR.sum\[2\]\[17\] VGND sg13g2_inv_1
XFILLER_45_793 VPWR VGND sg13g2_decap_8
XFILLER_83_92 VPWR VGND sg13g2_decap_8
XFILLER_33_955 VPWR VGND sg13g2_decap_8
XFILLER_60_752 VPWR VGND sg13g2_fill_2
X_17466_ net92 _08598_ _08599_ VPWR VGND sg13g2_nor2_1
X_14678_ VGND VPWR _05950_ _05956_ _05968_ _05955_ sg13g2_a21oi_1
XFILLER_60_774 VPWR VGND sg13g2_fill_1
X_23434__1047 VPWR VGND net1046 sg13g2_tiehi
X_23440__1612 VPWR VGND net1611 sg13g2_tiehi
X_19205_ net31 VPWR _10287_ VGND net29 _10286_ sg13g2_o21ai_1
XFILLER_32_476 VPWR VGND sg13g2_fill_1
X_16417_ VGND VPWR net497 _07646_ _00205_ _07647_ sg13g2_a21oi_1
X_13629_ VGND VPWR _04959_ _04958_ _04957_ sg13g2_or2_1
X_17397_ VGND VPWR _08541_ _08542_ _00290_ net939 sg13g2_a21oi_1
X_19136_ _10190_ VPWR _10223_ VGND _10220_ _10221_ sg13g2_o21ai_1
X_16348_ VGND VPWR _07550_ _07573_ _07581_ _07572_ sg13g2_a21oi_1
XFILLER_9_694 VPWR VGND sg13g2_fill_1
X_19067_ _10154_ _09811_ _09830_ VPWR VGND sg13g2_nand2_1
X_16279_ net978 VPWR _07515_ VGND net476 u_FIR.sum\[8\]\[10\] sg13g2_o21ai_1
XFILLER_105_209 VPWR VGND sg13g2_decap_4
X_18018_ _09082_ VPWR _09140_ VGND _09081_ _09084_ sg13g2_o21ai_1
XFILLER_59_0 VPWR VGND sg13g2_decap_4
XFILLER_113_231 VPWR VGND sg13g2_fill_1
Xfanout106 net106 net107 VPWR VGND sg13g2_buf_4
Xfanout117 _01190_ net117 VPWR VGND sg13g2_buf_1
XFILLER_59_307 VPWR VGND sg13g2_decap_8
Xfanout128 net128 net129 VPWR VGND sg13g2_buf_4
X_19969_ _11008_ _11007_ _11010_ VPWR VGND sg13g2_xor2_1
Xfanout139 net140 net139 VPWR VGND sg13g2_buf_1
XFILLER_80_1030 VPWR VGND sg13g2_fill_2
X_22980_ net1019 VGND VPWR _00042_ u_spi_slave.tx_shift\[10\] net1630 sg13g2_dfrbpq_1
XFILLER_68_863 VPWR VGND sg13g2_fill_1
XFILLER_83_800 VPWR VGND sg13g2_decap_8
X_21931_ _02525_ net578 net203 VPWR VGND sg13g2_nand2_1
XFILLER_83_833 VPWR VGND sg13g2_fill_1
XFILLER_28_749 VPWR VGND sg13g2_fill_1
XFILLER_82_321 VPWR VGND sg13g2_decap_8
X_21862_ _02452_ _02454_ _02455_ _02456_ VPWR VGND sg13g2_nor3_1
XFILLER_82_365 VPWR VGND sg13g2_decap_8
X_23601_ net1012 VGND VPWR _00663_ u_debug_unit.force_w5\[7\] clknet_leaf_37_clkA
+ sg13g2_dfrbpq_1
X_20813_ _01453_ _01425_ _01426_ VPWR VGND sg13g2_xnor2_1
XFILLER_24_933 VPWR VGND sg13g2_fill_1
X_21793_ VGND VPWR _02361_ _02372_ _02387_ _02371_ sg13g2_a21oi_1
X_23532_ net1013 VGND VPWR _00594_ u_debug_unit.sw_reset\[2\] clknet_leaf_37_clkA
+ sg13g2_dfrbpq_1
X_20744_ _03233_ net141 _01384_ VPWR VGND sg13g2_nor2_1
XFILLER_11_616 VPWR VGND sg13g2_fill_1
X_23463_ net1542 VGND VPWR _00525_ u_LMS.x_r\[4\]\[6\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
X_20675_ _01315_ _01282_ _01314_ VPWR VGND sg13g2_xnor2_1
XFILLER_50_284 VPWR VGND sg13g2_fill_2
XFILLER_11_649 VPWR VGND sg13g2_decap_4
XFILLER_50_295 VPWR VGND sg13g2_fill_2
X_22414_ VGND VPWR net431 _03262_ _00515_ _02956_ sg13g2_a21oi_1
X_23394_ net1166 VGND VPWR _00456_ u_LMS.w\[7\]\[4\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
X_22345_ _02919_ _02802_ _02804_ VPWR VGND sg13g2_xnor2_1
X_22276_ _02758_ _02821_ _02822_ _02865_ VPWR VGND sg13g2_nor3_1
XFILLER_128_77 VPWR VGND sg13g2_decap_8
X_21227_ _01844_ _01841_ _01842_ VPWR VGND sg13g2_xnor2_1
XFILLER_104_231 VPWR VGND sg13g2_decap_8
X_21158_ _01775_ _01769_ _01774_ VPWR VGND sg13g2_xnor2_1
XFILLER_104_297 VPWR VGND sg13g2_decap_8
Xfanout640 u_LMS.x_r\[4\]\[7\] net640 VPWR VGND sg13g2_buf_1
Xfanout651 u_LMS.x_r\[4\]\[0\] net651 VPWR VGND sg13g2_buf_1
XFILLER_77_137 VPWR VGND sg13g2_decap_8
X_20109_ _11116_ _11110_ _11150_ VPWR VGND sg13g2_xor2_1
Xfanout662 u_LMS.x_r\[3\]\[2\] net662 VPWR VGND sg13g2_buf_1
X_13980_ _05295_ _05296_ _00119_ VPWR VGND sg13g2_nor2_1
XFILLER_77_159 VPWR VGND sg13g2_fill_1
X_21089_ VGND VPWR _01657_ _01714_ _01715_ net14 sg13g2_a21oi_1
Xfanout673 u_LMS.x_r\[2\]\[5\] net673 VPWR VGND sg13g2_buf_1
Xfanout684 net685 net684 VPWR VGND sg13g2_buf_1
Xfanout695 u_LMS.x_r\[1\]\[3\] net695 VPWR VGND sg13g2_buf_1
X_12931_ _04290_ _04287_ _04288_ VPWR VGND sg13g2_xnor2_1
XFILLER_37_30 VPWR VGND sg13g2_decap_8
XFILLER_85_181 VPWR VGND sg13g2_decap_8
XFILLER_73_321 VPWR VGND sg13g2_fill_2
XFILLER_18_226 VPWR VGND sg13g2_decap_8
X_15650_ _03373_ net889 _06903_ VPWR VGND sg13g2_nor2_1
X_12862_ _04221_ _04222_ _04223_ VPWR VGND sg13g2_and2_1
XFILLER_2_1041 VPWR VGND sg13g2_decap_8
X_14601_ _03367_ net903 _05893_ VPWR VGND sg13g2_nor2_1
X_11813_ VPWR _03234_ net620 VGND sg13g2_inv_1
XFILLER_15_922 VPWR VGND sg13g2_fill_2
X_15581_ _06836_ _06828_ _06835_ VPWR VGND sg13g2_nand2_1
X_12793_ _04156_ u_FIR.sum\[0\]\[8\] net407 VPWR VGND sg13g2_xnor2_1
X_17320_ _08476_ u_LMS.w\[0\]\[20\] net72 VPWR VGND sg13g2_nand2_1
X_14532_ _05826_ net769 net903 VPWR VGND sg13g2_nand2_1
XFILLER_57_1054 VPWR VGND sg13g2_decap_8
XFILLER_30_903 VPWR VGND sg13g2_fill_2
XFILLER_30_914 VPWR VGND sg13g2_fill_1
XFILLER_41_262 VPWR VGND sg13g2_fill_2
XFILLER_18_1049 VPWR VGND sg13g2_decap_8
X_17251_ u_LMS.w\[0\]\[15\] _08406_ _08407_ VPWR VGND sg13g2_nor2_1
X_14463_ _05763_ _05750_ _05762_ VPWR VGND sg13g2_xnor2_1
X_16202_ net971 VPWR _07440_ VGND net475 u_FIR.sum\[8\]\[8\] sg13g2_o21ai_1
X_13414_ _04740_ _04755_ _04756_ VPWR VGND sg13g2_nor2b_1
XFILLER_128_813 VPWR VGND sg13g2_fill_1
X_17182_ _08338_ _08337_ _08330_ VPWR VGND sg13g2_nand2b_1
X_14394_ VGND VPWR _05669_ _05677_ _05697_ _05684_ sg13g2_a21oi_1
XFILLER_128_846 VPWR VGND sg13g2_decap_4
X_16133_ _07370_ _07371_ _07372_ VPWR VGND sg13g2_and2_1
X_13345_ _04689_ _04644_ _04688_ VPWR VGND sg13g2_xnor2_1
X_16064_ _07305_ _07297_ _07304_ VPWR VGND sg13g2_nand2_1
XFILLER_108_570 VPWR VGND sg13g2_fill_2
X_13276_ _04622_ _04580_ _04620_ VPWR VGND sg13g2_xnor2_1
X_15015_ _06279_ _06290_ _06291_ VPWR VGND sg13g2_nor2_1
X_12227_ _03610_ _03599_ _03608_ VPWR VGND sg13g2_xnor2_1
XFILLER_64_1014 VPWR VGND sg13g2_fill_2
X_19823_ VGND VPWR _10878_ _10880_ _00378_ net931 sg13g2_a21oi_1
XFILLER_97_936 VPWR VGND sg13g2_decap_4
XFILLER_111_724 VPWR VGND sg13g2_decap_8
X_12158_ _03567_ _03438_ u_debug_unit.error_signal_sync\[0\] _03407_ u_debug_unit.mon_w1_sync\[0\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_111_735 VPWR VGND sg13g2_fill_1
XFILLER_97_958 VPWR VGND sg13g2_decap_8
X_19754_ _10818_ _10419_ _10817_ VPWR VGND sg13g2_nand2_1
X_16966_ _08122_ _08119_ _08120_ VPWR VGND sg13g2_xnor2_1
X_12089_ _03484_ VPWR _00044_ VGND _03500_ _03501_ sg13g2_o21ai_1
XFILLER_84_619 VPWR VGND sg13g2_fill_1
XFILLER_65_811 VPWR VGND sg13g2_fill_1
XFILLER_37_502 VPWR VGND sg13g2_fill_1
X_18705_ _09789_ _09791_ _09792_ VPWR VGND sg13g2_nor2_1
XFILLER_37_513 VPWR VGND sg13g2_fill_1
X_15917_ _07161_ _07146_ _07163_ VPWR VGND sg13g2_xor2_1
X_19685_ _10749_ _10729_ _10730_ VPWR VGND sg13g2_xnor2_1
X_16897_ _08051_ _08052_ _08053_ VPWR VGND sg13g2_and2_1
XFILLER_65_844 VPWR VGND sg13g2_decap_8
X_18636_ _09732_ _09616_ _09618_ VPWR VGND sg13g2_xnor2_1
XFILLER_25_708 VPWR VGND sg13g2_fill_2
X_15848_ _07094_ _07058_ _07096_ VPWR VGND sg13g2_xor2_1
XFILLER_64_365 VPWR VGND sg13g2_fill_2
XFILLER_92_685 VPWR VGND sg13g2_decap_8
XFILLER_24_218 VPWR VGND sg13g2_decap_8
X_18567_ u_LMS.w\[2\]\[24\] net69 _09677_ VPWR VGND sg13g2_and2_1
X_15779_ _07029_ _07028_ _07024_ VPWR VGND sg13g2_nand2b_1
XFILLER_91_195 VPWR VGND sg13g2_fill_1
X_17518_ _08646_ VPWR _08651_ VGND _08634_ _08644_ sg13g2_o21ai_1
X_18498_ _09540_ _09520_ _09608_ VPWR VGND sg13g2_xor2_1
XFILLER_32_273 VPWR VGND sg13g2_fill_1
X_17449_ _08581_ _08582_ _00302_ VPWR VGND sg13g2_nor2_1
X_20460_ VGND VPWR _01062_ _01064_ _01112_ _01063_ sg13g2_a21oi_1
XFILLER_118_323 VPWR VGND sg13g2_fill_2
X_19119_ _10202_ VPWR _10206_ VGND _10203_ _10204_ sg13g2_o21ai_1
X_20391_ net75 u_LMS.w\[5\]\[20\] _01054_ VPWR VGND sg13g2_nor2b_1
X_22130_ _02720_ VPWR _02724_ VGND _02715_ _02721_ sg13g2_o21ai_1
X_22061_ _02655_ net584 net221 VPWR VGND sg13g2_nand2_1
XFILLER_114_540 VPWR VGND sg13g2_fill_2
X_21012_ _01652_ u_LMS.w\[6\]\[23\] net74 VPWR VGND sg13g2_xnor2_1
XFILLER_99_262 VPWR VGND sg13g2_decap_4
XFILLER_99_295 VPWR VGND sg13g2_decap_8
XFILLER_87_457 VPWR VGND sg13g2_fill_2
XFILLER_59_159 VPWR VGND sg13g2_decap_8
XFILLER_96_980 VPWR VGND sg13g2_decap_8
XFILLER_28_513 VPWR VGND sg13g2_decap_8
X_22963_ _00021_ _00038_ VPWR VGND sg13g2_buf_1
XFILLER_110_790 VPWR VGND sg13g2_fill_2
X_23255__1384 VPWR VGND net1383 sg13g2_tiehi
XFILLER_55_321 VPWR VGND sg13g2_fill_2
X_21914_ _02508_ _02505_ _02506_ VPWR VGND sg13g2_xnor2_1
XFILLER_83_652 VPWR VGND sg13g2_decap_8
XFILLER_28_557 VPWR VGND sg13g2_decap_4
X_22894_ VPWR _00776_ _03175_ VGND sg13g2_inv_1
XFILLER_82_173 VPWR VGND sg13g2_decap_8
X_21845_ VGND VPWR _02439_ _02436_ _02352_ sg13g2_or2_1
XFILLER_128_1019 VPWR VGND sg13g2_decap_8
XFILLER_130_56 VPWR VGND sg13g2_decap_8
X_21776_ _02370_ _02364_ _02369_ VPWR VGND sg13g2_xnor2_1
XFILLER_90_38 VPWR VGND sg13g2_fill_1
XFILLER_24_774 VPWR VGND sg13g2_fill_2
XFILLER_24_785 VPWR VGND sg13g2_decap_8
X_23515_ net1356 VGND VPWR _00577_ u_LMS.count\[18\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
X_20727_ VGND VPWR _01367_ _01366_ _01345_ sg13g2_or2_1
XFILLER_23_284 VPWR VGND sg13g2_decap_8
XFILLER_23_295 VPWR VGND sg13g2_fill_2
X_23446_ net1593 VGND VPWR _00508_ u_LMS.x_r\[2\]\[5\] clknet_leaf_65_clkA sg13g2_dfrbpq_1
X_20658_ _01298_ _01296_ _01297_ VPWR VGND sg13g2_nand2_1
XFILLER_109_334 VPWR VGND sg13g2_decap_8
XFILLER_99_25 VPWR VGND sg13g2_fill_2
XFILLER_87_1003 VPWR VGND sg13g2_decap_8
X_23377_ net1217 VGND VPWR _00439_ u_LMS.w\[6\]\[10\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
X_20589_ _01229_ _01225_ _01228_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_816 VPWR VGND sg13g2_decap_4
X_13130_ _04457_ _04466_ _04479_ VPWR VGND sg13g2_and2_1
X_22328_ _02905_ _02906_ _00479_ VPWR VGND sg13g2_nor2_1
X_13061_ VGND VPWR net521 _04411_ _00084_ _04412_ sg13g2_a21oi_1
X_22259_ net8 VPWR _02852_ VGND net7 _02851_ sg13g2_o21ai_1
XFILLER_2_133 VPWR VGND sg13g2_decap_8
X_12012_ _03403_ net326 _03429_ VPWR VGND sg13g2_nor2_1
XFILLER_78_402 VPWR VGND sg13g2_decap_8
XFILLER_132_370 VPWR VGND sg13g2_decap_8
XFILLER_120_521 VPWR VGND sg13g2_fill_2
X_16820_ _03277_ net102 _07976_ VPWR VGND sg13g2_nor2_1
XFILLER_120_554 VPWR VGND sg13g2_fill_2
Xfanout470 spi_wdata\[1\] net470 VPWR VGND sg13g2_buf_1
Xfanout481 net487 net481 VPWR VGND sg13g2_buf_1
XFILLER_87_980 VPWR VGND sg13g2_fill_2
Xfanout492 net494 net492 VPWR VGND sg13g2_buf_1
X_16751_ _07907_ net914 net1658 VPWR VGND sg13g2_nand2_1
XFILLER_47_833 VPWR VGND sg13g2_fill_1
X_13963_ VGND VPWR net539 _05280_ _00117_ _05281_ sg13g2_a21oi_1
XFILLER_0_14 VPWR VGND sg13g2_decap_8
X_15702_ _06952_ _06953_ _06954_ VPWR VGND sg13g2_nor2b_1
XFILLER_111_1056 VPWR VGND sg13g2_decap_4
X_19470_ _10532_ _10531_ _10534_ VPWR VGND sg13g2_xor2_1
X_12914_ _04274_ _04251_ _04272_ VPWR VGND sg13g2_xnor2_1
XFILLER_19_568 VPWR VGND sg13g2_decap_8
X_23472__1512 VPWR VGND net1511 sg13g2_tiehi
X_16682_ _07851_ VPWR _07852_ VGND _07847_ _07848_ sg13g2_o21ai_1
X_13894_ _05215_ net280 _05216_ VPWR VGND sg13g2_xor2_1
XFILLER_94_1007 VPWR VGND sg13g2_decap_8
XFILLER_94_1018 VPWR VGND sg13g2_fill_1
XFILLER_73_162 VPWR VGND sg13g2_decap_4
X_18421_ _09531_ _09523_ _09527_ VPWR VGND sg13g2_xnor2_1
X_15633_ _06860_ _06886_ _06887_ VPWR VGND sg13g2_nor2_1
X_12845_ _04207_ _04206_ _04205_ VPWR VGND sg13g2_nand2b_1
X_23525__1318 VPWR VGND net1317 sg13g2_tiehi
XFILLER_27_590 VPWR VGND sg13g2_fill_2
XFILLER_62_869 VPWR VGND sg13g2_decap_8
X_18352_ _09462_ _09454_ _09461_ VPWR VGND sg13g2_xnor2_1
X_15564_ _06820_ _06791_ _06818_ VPWR VGND sg13g2_xnor2_1
X_12776_ net869 net729 _04137_ _04139_ VPWR VGND sg13g2_a21o_1
X_17303_ _08416_ VPWR _08459_ VGND _08457_ _08456_ sg13g2_o21ai_1
X_14515_ _05810_ net772 net876 VPWR VGND sg13g2_nand2_1
X_18283_ _09393_ net678 net164 VPWR VGND sg13g2_nand2_1
X_15495_ _06754_ net789 net899 VPWR VGND sg13g2_nand2_1
XFILLER_9_56 VPWR VGND sg13g2_decap_8
XFILLER_30_733 VPWR VGND sg13g2_fill_2
X_17234_ _08390_ _08027_ _08389_ VPWR VGND sg13g2_xnor2_1
X_14446_ _05745_ VPWR _05747_ VGND _05729_ _05731_ sg13g2_o21ai_1
XFILLER_31_1002 VPWR VGND sg13g2_fill_2
XFILLER_128_610 VPWR VGND sg13g2_decap_4
XFILLER_80_82 VPWR VGND sg13g2_decap_4
XFILLER_127_120 VPWR VGND sg13g2_fill_2
XFILLER_11_991 VPWR VGND sg13g2_fill_1
X_17165_ _08321_ net263 net709 net246 net710 VPWR VGND sg13g2_a22oi_1
X_14377_ _05680_ net277 _05681_ VPWR VGND sg13g2_xor2_1
XFILLER_7_973 VPWR VGND sg13g2_decap_8
XFILLER_6_450 VPWR VGND sg13g2_fill_1
X_16116_ _07354_ _07328_ _07356_ VPWR VGND sg13g2_xor2_1
X_13328_ net1036 VPWR _04673_ VGND net538 u_FIR.sum\[2\]\[10\] sg13g2_o21ai_1
X_17096_ _08234_ _08251_ _08252_ VPWR VGND sg13g2_nor2_1
X_16047_ _07288_ _07275_ _07286_ VPWR VGND sg13g2_nand2_1
X_13259_ _04605_ _04604_ _04600_ VPWR VGND sg13g2_nand2b_1
XFILLER_130_307 VPWR VGND sg13g2_fill_2
XFILLER_124_882 VPWR VGND sg13g2_fill_1
XFILLER_96_210 VPWR VGND sg13g2_fill_2
XFILLER_123_370 VPWR VGND sg13g2_fill_1
XFILLER_9_1047 VPWR VGND sg13g2_decap_8
XFILLER_69_446 VPWR VGND sg13g2_decap_8
X_19806_ net26 VPWR _10867_ VGND net25 _10866_ sg13g2_o21ai_1
XFILLER_96_243 VPWR VGND sg13g2_decap_8
X_17998_ VGND VPWR u_LMS.w\[1\]\[18\] net78 _09124_ _09069_ sg13g2_a21oi_1
X_19737_ VGND VPWR _10798_ _10799_ _10801_ _10754_ sg13g2_a21oi_1
X_16949_ _08105_ net197 net702 net232 net704 VPWR VGND sg13g2_a22oi_1
XFILLER_93_950 VPWR VGND sg13g2_decap_8
XFILLER_38_855 VPWR VGND sg13g2_decap_8
XFILLER_38_877 VPWR VGND sg13g2_decap_8
X_19668_ _10497_ _10498_ _10732_ VPWR VGND sg13g2_nor2b_1
XFILLER_64_162 VPWR VGND sg13g2_decap_4
X_18619_ VGND VPWR u_LMS.w\[2\]\[22\] net301 _09719_ _09702_ sg13g2_a21oi_1
XFILLER_25_538 VPWR VGND sg13g2_decap_8
X_19599_ _10663_ _10567_ _10633_ VPWR VGND sg13g2_xnor2_1
X_21630_ u_LMS.w\[7\]\[24\] net63 _02247_ VPWR VGND sg13g2_and2_1
XFILLER_40_508 VPWR VGND sg13g2_fill_2
XFILLER_127_1030 VPWR VGND sg13g2_decap_8
X_21561_ _02178_ _02101_ net2150 VPWR VGND sg13g2_xnor2_1
XFILLER_20_210 VPWR VGND sg13g2_decap_8
X_23300_ net1301 VGND VPWR _00362_ u_LMS.w\[3\]\[2\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
X_20512_ _01152_ net171 net608 net179 net606 VPWR VGND sg13g2_a22oi_1
XFILLER_20_254 VPWR VGND sg13g2_fill_1
X_21492_ _01994_ _02010_ _02109_ VPWR VGND sg13g2_xor2_1
X_23094__1066 VPWR VGND net1065 sg13g2_tiehi
X_23231_ net1425 VGND VPWR _00293_ u_LMS.w\[0\]\[2\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
XFILLER_119_643 VPWR VGND sg13g2_decap_4
X_20443_ VGND VPWR u_LMS.w\[5\]\[19\] net318 _01099_ _01094_ sg13g2_a21oi_1
XFILLER_20_298 VPWR VGND sg13g2_decap_8
XFILLER_109_24 VPWR VGND sg13g2_fill_1
XFILLER_107_827 VPWR VGND sg13g2_decap_8
X_23162_ net1546 VGND VPWR _00224_ u_FIR.w\[1\]\[0\] clknet_leaf_49_clkA sg13g2_dfrbpq_1
X_20374_ VGND VPWR _01037_ _00980_ u_LMS.w\[5\]\[14\] sg13g2_or2_1
XFILLER_69_28 VPWR VGND sg13g2_decap_8
X_22113_ _02607_ VPWR _02707_ VGND _02706_ _02704_ sg13g2_o21ai_1
X_23093_ net1066 VGND VPWR _00155_ u_FIR.sum\[5\]\[17\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
XFILLER_122_819 VPWR VGND sg13g2_fill_1
X_22044_ net203 _02637_ net582 _02638_ VPWR VGND sg13g2_nand3_1
XFILLER_102_510 VPWR VGND sg13g2_fill_1
XFILLER_125_56 VPWR VGND sg13g2_decap_8
XFILLER_88_799 VPWR VGND sg13g2_fill_1
XFILLER_47_107 VPWR VGND sg13g2_decap_8
XFILLER_87_276 VPWR VGND sg13g2_decap_4
XFILLER_85_49 VPWR VGND sg13g2_decap_4
XFILLER_47_118 VPWR VGND sg13g2_fill_1
XFILLER_18_43 VPWR VGND sg13g2_fill_1
XFILLER_18_54 VPWR VGND sg13g2_fill_1
X_22946_ net472 net2 _03575_ _00803_ VPWR VGND sg13g2_mux2_1
XFILLER_29_877 VPWR VGND sg13g2_fill_1
XFILLER_18_65 VPWR VGND sg13g2_decap_8
XFILLER_18_76 VPWR VGND sg13g2_fill_1
XFILLER_16_505 VPWR VGND sg13g2_decap_8
X_23383__1200 VPWR VGND net1199 sg13g2_tiehi
XFILLER_55_151 VPWR VGND sg13g2_decap_8
XFILLER_16_516 VPWR VGND sg13g2_fill_2
XFILLER_43_302 VPWR VGND sg13g2_decap_8
XFILLER_71_622 VPWR VGND sg13g2_fill_1
XFILLER_56_696 VPWR VGND sg13g2_decap_8
XFILLER_71_633 VPWR VGND sg13g2_decap_8
XFILLER_16_538 VPWR VGND sg13g2_decap_8
X_22877_ u_p2s_output.reg_cnt\[1\] _03164_ _03166_ VPWR VGND sg13g2_nor2_1
XFILLER_70_110 VPWR VGND sg13g2_fill_1
XFILLER_44_858 VPWR VGND sg13g2_decap_4
X_12630_ _03997_ _03996_ _03992_ VPWR VGND sg13g2_nand2b_1
X_21828_ VPWR _02422_ _02421_ VGND sg13g2_inv_1
XFILLER_43_368 VPWR VGND sg13g2_decap_8
X_12561_ _03923_ VPWR _03933_ VGND _03862_ _03924_ sg13g2_o21ai_1
X_21759_ _02353_ net84 _02351_ VPWR VGND sg13g2_nand2b_1
XFILLER_11_210 VPWR VGND sg13g2_fill_2
XFILLER_54_1057 VPWR VGND sg13g2_decap_4
X_14300_ u_FIR.w\[4\]\[4\] net809 _05606_ VPWR VGND sg13g2_and2_1
X_15280_ _06549_ _06540_ _06547_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_429 VPWR VGND sg13g2_fill_2
X_12492_ net841 u_FIR.w\[8\]\[6\] _03867_ VPWR VGND sg13g2_nor2b_1
XFILLER_12_788 VPWR VGND sg13g2_fill_1
X_14231_ _05539_ net822 _05538_ VPWR VGND sg13g2_nand2_1
XFILLER_126_0 VPWR VGND sg13g2_decap_8
X_23429_ net1061 VGND VPWR _00491_ u_LMS.x_r\[0\]\[4\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
XFILLER_109_142 VPWR VGND sg13g2_decap_4
XFILLER_125_602 VPWR VGND sg13g2_fill_1
X_14162_ _05471_ _05468_ _05472_ VPWR VGND sg13g2_nor2b_1
XFILLER_50_85 VPWR VGND sg13g2_decap_8
X_13113_ _04462_ _04459_ _04463_ VPWR VGND sg13g2_xor2_1
XFILLER_113_808 VPWR VGND sg13g2_fill_1
X_18970_ _10057_ _10051_ _10056_ VPWR VGND sg13g2_xnor2_1
X_14093_ net1005 VPWR _05405_ VGND net506 u_FIR.sum\[4\]\[5\] sg13g2_o21ai_1
XFILLER_4_976 VPWR VGND sg13g2_fill_1
XFILLER_112_318 VPWR VGND sg13g2_fill_1
X_17921_ _08633_ _08652_ _08662_ _09054_ VPWR VGND sg13g2_or3_1
X_13044_ _04394_ _04377_ _04396_ VPWR VGND sg13g2_xor2_1
XFILLER_105_381 VPWR VGND sg13g2_decap_8
XFILLER_59_72 VPWR VGND sg13g2_decap_8
XFILLER_59_83 VPWR VGND sg13g2_fill_2
XFILLER_79_766 VPWR VGND sg13g2_decap_4
X_17852_ u_LMS.w\[1\]\[15\] _08984_ _08985_ VPWR VGND sg13g2_nor2_1
XFILLER_121_874 VPWR VGND sg13g2_fill_2
XFILLER_79_799 VPWR VGND sg13g2_fill_1
X_23336__1266 VPWR VGND net1265 sg13g2_tiehi
X_16803_ _07959_ _07957_ _07956_ VPWR VGND sg13g2_xnor2_1
X_17783_ _08915_ _08913_ _08916_ VPWR VGND sg13g2_xor2_1
X_14995_ net876 u_FIR.sum\[5\]\[2\] net782 _06272_ VPWR VGND sg13g2_nand3_1
XFILLER_59_490 VPWR VGND sg13g2_decap_8
X_19522_ VGND VPWR _10582_ _10583_ _10586_ _10585_ sg13g2_a21oi_1
X_16734_ _07890_ u_FIR.sum\[8\]\[14\] u_FIR.sum\[8\]\[13\] u_FIR.sum\[8\]\[12\] VPWR
+ VGND sg13g2_and3_1
XFILLER_93_268 VPWR VGND sg13g2_decap_8
X_13946_ VGND VPWR net536 _05264_ _00116_ _05265_ sg13g2_a21oi_1
XFILLER_75_82 VPWR VGND sg13g2_fill_1
XFILLER_62_600 VPWR VGND sg13g2_decap_8
XFILLER_19_365 VPWR VGND sg13g2_fill_1
XFILLER_62_611 VPWR VGND sg13g2_fill_2
XFILLER_34_313 VPWR VGND sg13g2_fill_1
X_19453_ _10517_ _10515_ _10516_ VPWR VGND sg13g2_nand2_1
X_16665_ VGND VPWR net527 _07838_ _00261_ _07839_ sg13g2_a21oi_1
X_13877_ _05194_ _05199_ _05200_ VPWR VGND sg13g2_nor2b_1
X_18404_ _09499_ _09513_ _09514_ VPWR VGND sg13g2_nor2_1
XFILLER_50_806 VPWR VGND sg13g2_fill_1
X_15616_ _06870_ net788 net845 VPWR VGND sg13g2_nand2_1
X_19384_ _10448_ _10446_ _10447_ VPWR VGND sg13g2_nand2_1
X_12828_ _04147_ VPWR _04190_ VGND _04103_ _04145_ sg13g2_o21ai_1
X_23185__1507 VPWR VGND net1506 sg13g2_tiehi
X_16596_ VGND VPWR _03333_ net506 _00244_ _07787_ sg13g2_a21oi_1
XFILLER_15_560 VPWR VGND sg13g2_fill_2
X_23213__1458 VPWR VGND net1457 sg13g2_tiehi
X_18335_ VGND VPWR _09436_ _09444_ _09445_ _09435_ sg13g2_a21oi_1
X_15547_ _06803_ _06802_ _06795_ VPWR VGND sg13g2_nand2b_1
X_12759_ _04090_ _04122_ _04123_ VPWR VGND sg13g2_and2_1
X_18266_ _09376_ _09372_ _09373_ VPWR VGND sg13g2_xnor2_1
X_15478_ _06739_ _06737_ _06738_ _06724_ _06586_ VPWR VGND sg13g2_a22oi_1
XFILLER_129_941 VPWR VGND sg13g2_fill_1
X_17217_ _08370_ _08372_ _08373_ VPWR VGND sg13g2_nor2_1
X_14429_ _05713_ _05730_ _05731_ VPWR VGND sg13g2_nor2b_1
X_18197_ _09307_ net2103 _09303_ VPWR VGND sg13g2_nand2b_1
XFILLER_128_451 VPWR VGND sg13g2_decap_8
X_17148_ _08303_ VPWR _08304_ VGND net417 net180 sg13g2_o21ai_1
Xfanout8 _02845_ net8 VPWR VGND sg13g2_buf_2
X_23090__1072 VPWR VGND net1071 sg13g2_tiehi
X_17079_ _08235_ _08225_ _08226_ VPWR VGND sg13g2_nand2_1
XFILLER_115_156 VPWR VGND sg13g2_decap_4
XFILLER_41_0 VPWR VGND sg13g2_fill_2
X_20090_ _11129_ _11130_ _11131_ VPWR VGND sg13g2_and2_1
XFILLER_57_416 VPWR VGND sg13g2_fill_1
XFILLER_57_438 VPWR VGND sg13g2_fill_1
X_22800_ u_debug_unit.mon_w6_sync\[2\] net350 _03118_ VPWR VGND sg13g2_nor2_1
X_23780_ net983 VGND VPWR _00038_ _00022_ clknet_leaf_51_clkA sg13g2_dfrbpq_1
XFILLER_84_268 VPWR VGND sg13g2_decap_8
X_20992_ _01630_ net2062 _01575_ _01632_ VPWR VGND sg13g2_a21o_1
XFILLER_26_814 VPWR VGND sg13g2_decap_8
XFILLER_53_611 VPWR VGND sg13g2_decap_8
XFILLER_38_685 VPWR VGND sg13g2_decap_4
XFILLER_25_302 VPWR VGND sg13g2_decap_4
X_22731_ VGND VPWR _07739_ net330 _00705_ _03083_ sg13g2_a21oi_1
XFILLER_93_791 VPWR VGND sg13g2_fill_2
XFILLER_111_25 VPWR VGND sg13g2_fill_2
XFILLER_52_143 VPWR VGND sg13g2_fill_1
X_22662_ coeff_force_packed\[34\] net460 _03065_ _00654_ VPWR VGND sg13g2_mux2_1
X_21613_ _02230_ u_LMS.w\[7\]\[18\] net64 VPWR VGND sg13g2_nand2_1
XFILLER_40_327 VPWR VGND sg13g2_fill_2
X_22593_ net472 u_debug_unit.sw_reset\[0\] _03058_ _00592_ VPWR VGND sg13g2_mux2_1
X_21544_ u_LMS.w\[7\]\[16\] _02160_ _02161_ VPWR VGND sg13g2_and2_1
XFILLER_21_596 VPWR VGND sg13g2_decap_4
Xclkbuf_leaf_41_clkA clknet_4_7_0_clkA clknet_leaf_41_clkA VPWR VGND sg13g2_buf_8
XFILLER_14_1041 VPWR VGND sg13g2_decap_8
X_21475_ _02092_ net604 net262 VPWR VGND sg13g2_nand2_1
X_23214_ net1456 VGND VPWR _00276_ u_FIR.w\[8\]\[3\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
X_20426_ VGND VPWR _01084_ _01085_ _00398_ net934 sg13g2_a21oi_1
XFILLER_106_134 VPWR VGND sg13g2_fill_2
X_23145_ net1571 VGND VPWR _00207_ u_FIR.sum\[8\]\[17\] clknet_leaf_44_clkA sg13g2_dfrbpq_1
XFILLER_84_1017 VPWR VGND sg13g2_decap_8
X_20357_ _01020_ _03312_ _00993_ VPWR VGND sg13g2_nand2_1
XFILLER_20_66 VPWR VGND sg13g2_fill_2
XFILLER_20_77 VPWR VGND sg13g2_fill_2
XFILLER_106_167 VPWR VGND sg13g2_decap_8
XFILLER_106_178 VPWR VGND sg13g2_fill_1
X_23076_ net1092 VGND VPWR _00138_ u_FIR.sum\[5\]\[0\] clknet_leaf_51_clkA sg13g2_dfrbpq_1
X_20288_ _00951_ _11090_ _00950_ VPWR VGND sg13g2_nand2_1
XFILLER_121_126 VPWR VGND sg13g2_fill_1
XFILLER_0_445 VPWR VGND sg13g2_decap_8
XFILLER_1_968 VPWR VGND sg13g2_decap_8
X_22027_ _02552_ _02620_ _02621_ VPWR VGND sg13g2_and2_1
XFILLER_0_456 VPWR VGND sg13g2_fill_2
XFILLER_29_31 VPWR VGND sg13g2_decap_8
XFILLER_29_42 VPWR VGND sg13g2_decap_4
XFILLER_29_75 VPWR VGND sg13g2_fill_2
XFILLER_21_1001 VPWR VGND sg13g2_decap_4
X_13800_ _05125_ net748 net826 VPWR VGND sg13g2_nand2_1
X_14780_ _06023_ VPWR _06068_ VGND _05980_ _06020_ sg13g2_o21ai_1
X_11992_ _03409_ _03401_ _03408_ VPWR VGND sg13g2_nand2_1
XFILLER_91_739 VPWR VGND sg13g2_fill_1
XFILLER_29_685 VPWR VGND sg13g2_fill_2
XFILLER_28_173 VPWR VGND sg13g2_decap_8
XFILLER_17_836 VPWR VGND sg13g2_fill_1
X_13731_ _05058_ _05014_ _05057_ VPWR VGND sg13g2_xnor2_1
XFILLER_28_184 VPWR VGND sg13g2_fill_1
X_22929_ _03194_ _03574_ u_spi_slave.rx_shift\[0\] u_spi_slave.rx_shift\[8\] u_spi_slave.bit_cnt\[3\]
+ VPWR VGND sg13g2_a22oi_1
X_16450_ _07679_ _07664_ _07678_ VPWR VGND sg13g2_xnor2_1
XFILLER_72_986 VPWR VGND sg13g2_decap_8
XFILLER_32_817 VPWR VGND sg13g2_decap_8
X_13662_ _04991_ _04984_ _04990_ VPWR VGND sg13g2_xnor2_1
XFILLER_71_474 VPWR VGND sg13g2_fill_2
X_15401_ _06652_ VPWR _06666_ VGND _06586_ _06650_ sg13g2_o21ai_1
X_12613_ _03981_ _03975_ _03979_ VPWR VGND sg13g2_xnor2_1
X_16381_ _07613_ u_FIR.sum\[7\]\[14\] net387 VPWR VGND sg13g2_xnor2_1
X_13593_ VGND VPWR _04888_ _04915_ _04923_ _04914_ sg13g2_a21oi_1
X_18120_ _09226_ VPWR _09230_ VGND _09227_ _09228_ sg13g2_o21ai_1
X_15332_ _06569_ _06599_ _06600_ VPWR VGND sg13g2_nor2b_1
X_12544_ _03917_ u_FIR.w\[8\]\[6\] net811 VPWR VGND sg13g2_nand2b_1
XFILLER_12_574 VPWR VGND sg13g2_decap_8
X_18051_ _09165_ net57 _09164_ VPWR VGND sg13g2_nand2_1
XFILLER_129_259 VPWR VGND sg13g2_decap_8
X_15263_ VGND VPWR _06492_ _06523_ _06532_ _06522_ sg13g2_a21oi_1
X_12475_ _03822_ _03850_ _03851_ VPWR VGND sg13g2_nor2_1
X_17002_ _08150_ VPWR _08158_ VGND _08151_ _08157_ sg13g2_o21ai_1
XFILLER_126_922 VPWR VGND sg13g2_decap_8
X_14214_ net1005 VPWR _05523_ VGND net506 u_FIR.sum\[4\]\[8\] sg13g2_o21ai_1
XFILLER_6_35 VPWR VGND sg13g2_decap_8
X_15194_ _03371_ net410 _06425_ _06465_ VPWR VGND sg13g2_nor3_1
XFILLER_99_806 VPWR VGND sg13g2_decap_8
XFILLER_126_966 VPWR VGND sg13g2_decap_8
X_14145_ _05455_ _05454_ _05450_ VPWR VGND sg13g2_nand2b_1
XFILLER_4_773 VPWR VGND sg13g2_fill_2
XFILLER_112_104 VPWR VGND sg13g2_decap_8
X_23052__1129 VPWR VGND net1128 sg13g2_tiehi
X_18953_ _10040_ _10018_ _10020_ VPWR VGND sg13g2_xnor2_1
X_14076_ _05347_ _05349_ _05388_ VPWR VGND sg13g2_and2_1
X_17904_ _09037_ _03349_ _08991_ VPWR VGND sg13g2_nand2_1
X_13027_ _04378_ _04379_ _04380_ VPWR VGND sg13g2_nor2_1
X_18884_ _09969_ _09970_ _09971_ VPWR VGND sg13g2_nor2b_1
XFILLER_117_1051 VPWR VGND sg13g2_decap_8
Xfanout1040 net1041 net1040 VPWR VGND sg13g2_buf_1
XFILLER_67_725 VPWR VGND sg13g2_fill_1
XFILLER_6_1039 VPWR VGND sg13g2_decap_8
X_17835_ _08968_ _08732_ _08762_ VPWR VGND sg13g2_xnor2_1
XFILLER_86_81 VPWR VGND sg13g2_fill_1
XFILLER_39_449 VPWR VGND sg13g2_fill_2
XFILLER_94_544 VPWR VGND sg13g2_fill_2
XFILLER_82_717 VPWR VGND sg13g2_decap_8
X_17766_ _08897_ _08898_ _08899_ VPWR VGND sg13g2_nor2_1
XFILLER_82_728 VPWR VGND sg13g2_fill_1
X_14978_ _06258_ _06250_ _06257_ VPWR VGND sg13g2_xnor2_1
XFILLER_35_611 VPWR VGND sg13g2_fill_1
X_19505_ _10569_ _10566_ _10568_ VPWR VGND sg13g2_xnor2_1
XFILLER_81_227 VPWR VGND sg13g2_decap_8
X_16717_ VGND VPWR u_LMS.w\[8\]\[14\] _07872_ _07878_ _07873_ sg13g2_a21oi_1
XFILLER_63_942 VPWR VGND sg13g2_fill_2
X_13929_ _05241_ _05240_ _05239_ _05249_ VPWR VGND sg13g2_a21o_1
X_17697_ _08828_ _08794_ _08830_ VPWR VGND sg13g2_xor2_1
X_19436_ _10500_ net640 net237 VPWR VGND sg13g2_nand2_1
X_16648_ net1034 VPWR _07826_ VGND net533 u_FIR.w\[5\]\[6\] sg13g2_o21ai_1
XFILLER_37_1030 VPWR VGND sg13g2_fill_2
Xclkbuf_leaf_64_clkA clknet_4_0_0_clkA clknet_leaf_64_clkA VPWR VGND sg13g2_buf_8
X_19367_ _10431_ _10396_ _10430_ VPWR VGND sg13g2_xnor2_1
X_16579_ VGND VPWR net491 _07775_ _00238_ _07776_ sg13g2_a21oi_1
X_18318_ _09427_ _09394_ _09428_ VPWR VGND sg13g2_xor2_1
XFILLER_89_0 VPWR VGND sg13g2_decap_4
XFILLER_124_1033 VPWR VGND sg13g2_decap_8
X_19298_ _03246_ _10361_ _10362_ VPWR VGND sg13g2_nor2_1
XFILLER_30_360 VPWR VGND sg13g2_decap_4
X_18249_ _09358_ _09335_ _09359_ VPWR VGND sg13g2_xor2_1
X_21260_ _01877_ _01871_ _01876_ VPWR VGND sg13g2_xnor2_1
X_20211_ _00874_ net636 net230 VPWR VGND sg13g2_nand2_1
Xrebuffer2201 net2200 net124 VPWR VGND sg13g2_buf_16
Xrebuffer2212 _01908_ net2211 VPWR VGND sg13g2_buf_1
X_21191_ _01808_ _01782_ _01807_ VPWR VGND sg13g2_nand2_1
XFILLER_104_616 VPWR VGND sg13g2_fill_1
XFILLER_116_476 VPWR VGND sg13g2_fill_2
XFILLER_131_402 VPWR VGND sg13g2_decap_8
X_20142_ _11181_ _11182_ _11183_ VPWR VGND sg13g2_nor2_1
XFILLER_132_947 VPWR VGND sg13g2_decap_8
XFILLER_103_159 VPWR VGND sg13g2_decap_4
XFILLER_106_47 VPWR VGND sg13g2_decap_8
X_20073_ _10977_ _11112_ _11114_ VPWR VGND sg13g2_and2_1
XFILLER_44_1034 VPWR VGND sg13g2_decap_4
XFILLER_106_58 VPWR VGND sg13g2_fill_2
XFILLER_97_360 VPWR VGND sg13g2_decap_8
XFILLER_66_18 VPWR VGND sg13g2_fill_1
XFILLER_44_1056 VPWR VGND sg13g2_decap_4
XFILLER_100_833 VPWR VGND sg13g2_decap_4
XFILLER_131_1037 VPWR VGND sg13g2_decap_8
XFILLER_100_866 VPWR VGND sg13g2_fill_2
XFILLER_39_972 VPWR VGND sg13g2_decap_8
XFILLER_72_227 VPWR VGND sg13g2_decap_8
XFILLER_38_482 VPWR VGND sg13g2_fill_1
X_23763_ net988 VGND VPWR _00010_ u_spi_slave.rx_shift\[5\] clknet_3_1__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_20975_ VGND VPWR _01612_ _01613_ _01615_ _01588_ sg13g2_a21oi_1
X_22714_ u_debug_unit.mon_w0_sync\[1\] net343 _03075_ VPWR VGND sg13g2_nor2_1
X_23694_ net1019 VGND VPWR _00756_ u_debug_unit.mon_w8_sync\[4\] clknet_leaf_36_clkA
+ sg13g2_dfrbpq_1
XFILLER_81_794 VPWR VGND sg13g2_decap_8
X_22645_ u_debug_unit.force_w2\[7\] net458 _03063_ _00639_ VPWR VGND sg13g2_mux2_1
XFILLER_41_658 VPWR VGND sg13g2_fill_1
XFILLER_40_135 VPWR VGND sg13g2_fill_1
XFILLER_90_1054 VPWR VGND sg13g2_decap_8
X_22576_ _03046_ _03048_ _00585_ VPWR VGND sg13g2_nor2_1
XFILLER_21_360 VPWR VGND sg13g2_decap_8
X_21527_ _01767_ _01817_ _01818_ _02144_ VPWR VGND sg13g2_nor3_1
XFILLER_31_21 VPWR VGND sg13g2_fill_2
XFILLER_21_393 VPWR VGND sg13g2_fill_2
XFILLER_126_207 VPWR VGND sg13g2_fill_1
XFILLER_31_43 VPWR VGND sg13g2_decap_8
X_12260_ VGND VPWR _03602_ _03618_ _03642_ _03620_ sg13g2_a21oi_1
X_21458_ _02061_ _02065_ _02040_ _02075_ VPWR VGND sg13g2_nand3_1
XFILLER_119_270 VPWR VGND sg13g2_decap_8
XFILLER_108_977 VPWR VGND sg13g2_decap_8
X_20409_ _03315_ net76 _01072_ VPWR VGND _01066_ sg13g2_nand3b_1
XFILLER_123_903 VPWR VGND sg13g2_fill_1
X_12191_ u_LMS.count\[5\] u_LMS.count\[4\] _03579_ VPWR VGND sg13g2_nor2b_1
X_21389_ VPWR _02006_ _02005_ VGND sg13g2_inv_1
XFILLER_1_710 VPWR VGND sg13g2_fill_1
XFILLER_123_936 VPWR VGND sg13g2_decap_4
X_23128_ net1597 VGND VPWR _00190_ u_FIR.sum\[7\]\[14\] clknet_leaf_43_clkA sg13g2_dfrbpq_1
XFILLER_0_242 VPWR VGND sg13g2_decap_8
X_23059_ net1117 VGND VPWR _00121_ u_FIR.sum\[4\]\[2\] clknet_leaf_38_clkA sg13g2_dfrbpq_1
X_15950_ _07194_ _07185_ _07192_ VPWR VGND sg13g2_xnor2_1
XFILLER_89_872 VPWR VGND sg13g2_fill_2
XFILLER_1_765 VPWR VGND sg13g2_fill_1
XFILLER_49_714 VPWR VGND sg13g2_decap_8
XFILLER_49_725 VPWR VGND sg13g2_fill_1
X_14901_ _06184_ net267 _06185_ VPWR VGND sg13g2_xor2_1
X_15881_ VGND VPWR _07128_ _07126_ _07125_ sg13g2_or2_1
XFILLER_49_758 VPWR VGND sg13g2_decap_8
X_17620_ _03273_ _03274_ _08753_ VPWR VGND sg13g2_nor2_1
X_14832_ _06113_ _06115_ _06118_ VPWR VGND sg13g2_nor2_1
X_17551_ _08683_ _08597_ _08684_ VPWR VGND sg13g2_xor2_1
XFILLER_91_547 VPWR VGND sg13g2_decap_8
X_14763_ _06018_ _06011_ _06026_ _06051_ VPWR VGND sg13g2_a21o_1
XFILLER_45_953 VPWR VGND sg13g2_fill_1
X_11975_ VGND VPWR u_spi_slave.tx_cnt\[0\] _03393_ _03394_ u_spi_slave.tx_cnt\[1\]
+ sg13g2_a21oi_1
X_16502_ VGND VPWR u_LMS.w\[0\]\[14\] _07713_ _07719_ _07714_ sg13g2_a21oi_1
X_13714_ _05032_ VPWR _05041_ VGND _05002_ _05033_ sg13g2_o21ai_1
X_17482_ VGND VPWR net686 net109 _08615_ _08612_ sg13g2_a21oi_1
XFILLER_60_923 VPWR VGND sg13g2_decap_8
X_14694_ _05980_ VPWR _05984_ VGND _05981_ _05982_ sg13g2_o21ai_1
XFILLER_108_1006 VPWR VGND sg13g2_decap_8
XFILLER_60_934 VPWR VGND sg13g2_decap_8
X_19221_ net30 VPWR _10300_ VGND net28 _10299_ sg13g2_o21ai_1
X_16433_ net1001 VPWR _07663_ VGND net497 u_FIR.sum\[8\]\[16\] sg13g2_o21ai_1
X_13645_ _04974_ _04966_ _04973_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_658 VPWR VGND sg13g2_decap_4
XFILLER_108_1039 VPWR VGND sg13g2_decap_8
XFILLER_60_989 VPWR VGND sg13g2_fill_2
X_19152_ _10176_ _10178_ _10238_ _10239_ VPWR VGND sg13g2_nor3_2
X_16364_ _07597_ _07596_ _07565_ VPWR VGND sg13g2_nand2b_1
X_13576_ net840 net756 u_FIR.sum\[2\]\[5\] _04907_ VPWR VGND sg13g2_a21o_1
X_18103_ _09196_ _09212_ _09213_ VPWR VGND sg13g2_nor2_1
X_15315_ _06583_ _06574_ _06581_ VPWR VGND sg13g2_xnor2_1
X_19083_ VPWR _10170_ _10169_ VGND sg13g2_inv_1
X_12527_ _03901_ _03832_ _03899_ VPWR VGND sg13g2_xnor2_1
X_16295_ _07530_ _07521_ _07528_ VPWR VGND sg13g2_xnor2_1
X_18034_ net359 VPWR _09153_ VGND u_LMS.w\[1\]\[3\] net375 sg13g2_o21ai_1
X_15246_ _06516_ u_FIR.sum\[5\]\[9\] net395 VPWR VGND sg13g2_xnor2_1
X_12458_ _03834_ net721 net827 VPWR VGND sg13g2_nand2_1
XFILLER_67_1001 VPWR VGND sg13g2_decap_4
X_15177_ _06447_ _06411_ _06449_ VPWR VGND sg13g2_xor2_1
X_12389_ _03767_ net726 net811 VPWR VGND sg13g2_nand2_1
XFILLER_99_636 VPWR VGND sg13g2_decap_8
XFILLER_67_1056 VPWR VGND sg13g2_decap_4
X_14128_ _05439_ _05406_ _05437_ VPWR VGND sg13g2_xnor2_1
XFILLER_113_424 VPWR VGND sg13g2_fill_1
X_19985_ _11026_ _10978_ _11002_ VPWR VGND sg13g2_xnor2_1
XFILLER_114_969 VPWR VGND sg13g2_decap_8
X_18936_ _10021_ _10022_ _10023_ VPWR VGND sg13g2_nor2_1
X_14059_ _05358_ VPWR _05371_ VGND _05353_ _05356_ sg13g2_o21ai_1
XFILLER_39_224 VPWR VGND sg13g2_decap_4
X_18867_ net128 net662 _09952_ _09954_ VPWR VGND sg13g2_a21o_1
X_23413__1110 VPWR VGND net1109 sg13g2_tiehi
X_17818_ VGND VPWR _08947_ _08949_ _08951_ _08950_ sg13g2_a21oi_1
X_18798_ _09885_ _09849_ _09851_ VPWR VGND sg13g2_xnor2_1
XFILLER_54_205 VPWR VGND sg13g2_decap_4
XFILLER_48_780 VPWR VGND sg13g2_fill_1
X_17749_ VGND VPWR _08880_ _08881_ _08882_ _08879_ sg13g2_a21oi_1
XFILLER_63_750 VPWR VGND sg13g2_decap_8
X_20760_ _01365_ _01399_ _01400_ VPWR VGND sg13g2_nor2_1
XFILLER_62_260 VPWR VGND sg13g2_decap_8
XFILLER_22_102 VPWR VGND sg13g2_decap_8
X_19419_ _10475_ _10482_ _10483_ VPWR VGND sg13g2_nor2b_1
XFILLER_51_956 VPWR VGND sg13g2_decap_8
X_20691_ _01331_ _01329_ _01330_ VPWR VGND sg13g2_nand2_1
X_22430_ VGND VPWR net436 _03254_ _00523_ _02964_ sg13g2_a21oi_1
XFILLER_22_168 VPWR VGND sg13g2_fill_2
XFILLER_22_179 VPWR VGND sg13g2_fill_2
XFILLER_31_680 VPWR VGND sg13g2_fill_1
X_22361_ net1027 VPWR _02930_ VGND net454 net711 sg13g2_o21ai_1
X_21312_ _01929_ net597 net208 VPWR VGND sg13g2_nand2_1
XFILLER_50_1060 VPWR VGND sg13g2_fill_1
X_22292_ _02878_ _02829_ _02877_ VPWR VGND sg13g2_nand2_1
X_21243_ _01856_ _01858_ _01859_ _01860_ VPWR VGND sg13g2_nor3_1
X_23331__1271 VPWR VGND net1270 sg13g2_tiehi
XFILLER_105_925 VPWR VGND sg13g2_decap_8
X_21174_ _01788_ net116 _01791_ VPWR VGND sg13g2_xor2_1
Xrebuffer2064 net2064 net2063 VPWR VGND sg13g2_buf_1
Xfanout800 u_FIR.w\[0\]\[1\] net800 VPWR VGND sg13g2_buf_1
Xrebuffer2075 _01426_ net2074 VPWR VGND sg13g2_buf_1
Xfanout811 net812 net811 VPWR VGND sg13g2_buf_1
XFILLER_131_243 VPWR VGND sg13g2_decap_8
X_20125_ VGND VPWR _11154_ _11156_ _11166_ _11165_ sg13g2_a21oi_1
Xrebuffer2086 _10181_ net2085 VPWR VGND sg13g2_buf_1
XFILLER_77_39 VPWR VGND sg13g2_decap_8
Xfanout822 net823 net822 VPWR VGND sg13g2_buf_1
Xfanout833 net837 net833 VPWR VGND sg13g2_buf_1
Xrebuffer2097 _09352_ net2096 VPWR VGND sg13g2_buf_1
Xfanout844 u_FIR.x_reg\[5\] net844 VPWR VGND sg13g2_buf_1
Xfanout855 net856 net855 VPWR VGND sg13g2_buf_1
XFILLER_86_831 VPWR VGND sg13g2_decap_8
Xfanout866 net870 net866 VPWR VGND sg13g2_buf_1
X_20056_ _11093_ VPWR _11097_ VGND _11094_ _11096_ sg13g2_o21ai_1
Xfanout877 u_FIR.x_reg\[2\] net877 VPWR VGND sg13g2_buf_1
Xfanout888 net889 net888 VPWR VGND sg13g2_buf_1
Xfanout899 net900 net899 VPWR VGND sg13g2_buf_1
XFILLER_46_728 VPWR VGND sg13g2_fill_2
XFILLER_73_514 VPWR VGND sg13g2_decap_4
XFILLER_100_685 VPWR VGND sg13g2_decap_4
XFILLER_85_385 VPWR VGND sg13g2_decap_8
XFILLER_73_525 VPWR VGND sg13g2_decap_8
XFILLER_45_227 VPWR VGND sg13g2_decap_4
XFILLER_39_780 VPWR VGND sg13g2_decap_8
XFILLER_27_953 VPWR VGND sg13g2_decap_8
XFILLER_26_32 VPWR VGND sg13g2_decap_4
XFILLER_54_761 VPWR VGND sg13g2_decap_4
XFILLER_42_912 VPWR VGND sg13g2_decap_8
X_20958_ u_LMS.w\[6\]\[3\] _01595_ _01598_ VPWR VGND sg13g2_nor2_1
X_23746_ net983 VGND VPWR _00808_ spi_wdata\[5\] clknet_3_0__leaf_spi_sclk sg13g2_dfrbpq_1
XFILLER_13_102 VPWR VGND sg13g2_fill_1
XFILLER_13_113 VPWR VGND sg13g2_fill_2
X_20889_ _01332_ _01327_ _01529_ VPWR VGND sg13g2_xor2_1
X_23677_ net1029 VGND VPWR _00739_ u_debug_unit.mon_w6_sync\[1\] clknet_leaf_23_clkA
+ sg13g2_dfrbpq_1
Xclkbuf_0_spi_sclk clknet_0_spi_sclk spi_sclk VPWR VGND sg13g2_buf_16
X_13430_ _04771_ _04749_ _04769_ VPWR VGND sg13g2_xnor2_1
X_22628_ _03062_ net429 net296 VPWR VGND sg13g2_nand2_1
XFILLER_9_139 VPWR VGND sg13g2_fill_1
XFILLER_10_842 VPWR VGND sg13g2_decap_4
X_13361_ _04703_ _04674_ _04705_ VPWR VGND sg13g2_xor2_1
X_22559_ net917 _03037_ _00579_ VPWR VGND sg13g2_nor2_1
XFILLER_42_86 VPWR VGND sg13g2_fill_1
X_15100_ VGND VPWR _06338_ _06365_ _06373_ _06364_ sg13g2_a21oi_1
X_12312_ _03692_ _03691_ _03687_ VPWR VGND sg13g2_nand2b_1
XFILLER_127_538 VPWR VGND sg13g2_decap_8
X_16080_ _07321_ _07291_ _07320_ VPWR VGND sg13g2_nand2b_1
X_13292_ VGND VPWR _04598_ _04614_ _04637_ _04623_ sg13g2_a21oi_1
XFILLER_127_549 VPWR VGND sg13g2_fill_1
X_15031_ _06307_ _06285_ _06305_ VPWR VGND sg13g2_xnor2_1
X_12243_ net722 net881 _03625_ VPWR VGND sg13g2_and2_1
X_12174_ net943 u_spi_slave.rx_shift\[4\] _00010_ VPWR VGND sg13g2_nor2b_1
XFILLER_3_14 VPWR VGND sg13g2_decap_8
XFILLER_111_917 VPWR VGND sg13g2_fill_1
X_19770_ net65 VPWR _10834_ VGND u_LMS.w\[4\]\[19\] u_LMS.w\[4\]\[18\] sg13g2_o21ai_1
X_16982_ _08134_ VPWR _08138_ VGND _08135_ _08137_ sg13g2_o21ai_1
XFILLER_77_820 VPWR VGND sg13g2_fill_2
XFILLER_1_573 VPWR VGND sg13g2_fill_2
XFILLER_107_90 VPWR VGND sg13g2_decap_4
X_18721_ _09806_ net119 _09808_ VPWR VGND sg13g2_xor2_1
X_15933_ _07176_ _07175_ _07178_ VPWR VGND sg13g2_xor2_1
XFILLER_76_341 VPWR VGND sg13g2_fill_1
X_18652_ _09744_ _09628_ _09629_ VPWR VGND sg13g2_xnor2_1
X_15864_ _07086_ _07111_ _07112_ VPWR VGND sg13g2_nor2_1
X_17603_ _08733_ VPWR _08736_ VGND _03268_ net195 sg13g2_o21ai_1
X_14815_ _06022_ _06054_ _06102_ VPWR VGND sg13g2_nor2_1
X_18583_ VGND VPWR _09689_ _09690_ _00328_ net921 sg13g2_a21oi_1
X_15795_ _07045_ _07018_ _07043_ VPWR VGND sg13g2_xnor2_1
XFILLER_17_430 VPWR VGND sg13g2_decap_8
XFILLER_18_975 VPWR VGND sg13g2_decap_8
X_17534_ _08667_ _08632_ _08666_ VPWR VGND sg13g2_xnor2_1
XFILLER_45_772 VPWR VGND sg13g2_fill_2
X_14746_ _06035_ _05992_ _06033_ VPWR VGND sg13g2_xnor2_1
X_23373__1229 VPWR VGND net1228 sg13g2_tiehi
X_11958_ VPWR _03379_ u_FIR.sum\[2\]\[18\] VGND sg13g2_inv_1
XFILLER_72_580 VPWR VGND sg13g2_fill_1
X_17465_ net693 net147 net691 _08598_ VPWR VGND sg13g2_nand3_1
X_14677_ VGND VPWR _05930_ _05958_ _05967_ _05960_ sg13g2_a21oi_1
X_11889_ VPWR _03310_ u_LMS.w\[6\]\[12\] VGND sg13g2_inv_1
XFILLER_60_764 VPWR VGND sg13g2_fill_1
X_19204_ _10241_ _10285_ _10286_ VPWR VGND sg13g2_and2_1
X_16416_ net1001 VPWR _07647_ VGND net497 u_FIR.sum\[8\]\[15\] sg13g2_o21ai_1
XFILLER_73_1060 VPWR VGND sg13g2_fill_1
XFILLER_60_786 VPWR VGND sg13g2_fill_1
X_13628_ VGND VPWR _04917_ _04920_ _04958_ _04956_ sg13g2_a21oi_1
X_17396_ VGND VPWR u_LMS.w\[0\]\[22\] net314 _08542_ _08524_ sg13g2_a21oi_1
XFILLER_20_639 VPWR VGND sg13g2_fill_1
X_19135_ _10189_ u_LMS.w\[3\]\[9\] _10222_ VPWR VGND sg13g2_xor2_1
X_16347_ _07577_ VPWR _07580_ VGND _07549_ _07574_ sg13g2_o21ai_1
X_13559_ _04860_ _04889_ _04890_ VPWR VGND sg13g2_nor2_1
X_19066_ net656 net146 net654 _10153_ VPWR VGND sg13g2_nand3_1
X_16278_ _07514_ _07513_ _07512_ VPWR VGND sg13g2_nand2b_1
XFILLER_8_183 VPWR VGND sg13g2_fill_2
X_18017_ VGND VPWR _09138_ _09139_ _00313_ net923 sg13g2_a21oi_1
X_15229_ net848 net775 _06497_ _06499_ VPWR VGND sg13g2_a21o_1
XFILLER_126_582 VPWR VGND sg13g2_fill_1
XFILLER_114_744 VPWR VGND sg13g2_fill_1
XFILLER_113_221 VPWR VGND sg13g2_fill_2
Xfanout107 net107 net108 VPWR VGND sg13g2_buf_4
Xfanout118 _10387_ net118 VPWR VGND sg13g2_buf_1
Xfanout129 net129 net2114 VPWR VGND sg13g2_buf_4
XFILLER_102_939 VPWR VGND sg13g2_fill_1
X_19968_ _11007_ _11008_ _11009_ VPWR VGND sg13g2_nor2_1
XFILLER_113_287 VPWR VGND sg13g2_fill_1
XFILLER_86_138 VPWR VGND sg13g2_fill_1
XFILLER_101_449 VPWR VGND sg13g2_fill_2
X_18919_ VGND VPWR _09994_ _10005_ _10006_ _09993_ sg13g2_a21oi_1
X_19899_ _10939_ _10937_ _10936_ _10940_ VPWR VGND sg13g2_a21o_1
X_22969__1633 VPWR net1632 clknet_3_7__leaf_spi_sclk VGND sg13g2_inv_1
X_21930_ _02524_ net580 net221 VPWR VGND sg13g2_nand2_1
XFILLER_28_739 VPWR VGND sg13g2_fill_1
XFILLER_82_311 VPWR VGND sg13g2_fill_2
X_21861_ _02402_ _02377_ _02455_ VPWR VGND sg13g2_xor2_1
XFILLER_27_249 VPWR VGND sg13g2_decap_4
X_20812_ VGND VPWR _01449_ _01451_ _01452_ _01448_ sg13g2_a21oi_1
X_23600_ net1017 VGND VPWR _00662_ coeff_force_packed\[41\] clknet_leaf_20_clkA sg13g2_dfrbpq_1
Xclkbuf_4_8_0_clkA clknet_0_clkA clknet_4_8_0_clkA VPWR VGND sg13g2_buf_8
XFILLER_42_219 VPWR VGND sg13g2_fill_1
XFILLER_36_772 VPWR VGND sg13g2_decap_8
X_21792_ _02383_ net115 _02386_ VPWR VGND sg13g2_xor2_1
XFILLER_82_388 VPWR VGND sg13g2_fill_1
XFILLER_24_923 VPWR VGND sg13g2_decap_4
XFILLER_23_411 VPWR VGND sg13g2_fill_2
X_23349__1253 VPWR VGND net1252 sg13g2_tiehi
XFILLER_63_591 VPWR VGND sg13g2_decap_4
X_20743_ _03234_ net1641 net125 _01383_ VGND VPWR net1668 sg13g2_nor4_2
X_23531_ net987 VGND VPWR _00593_ u_debug_unit.sw_reset\[1\] clknet_leaf_38_clkA sg13g2_dfrbpq_1
XFILLER_11_606 VPWR VGND sg13g2_fill_1
X_23462_ net1545 VGND VPWR _00524_ u_LMS.x_r\[4\]\[5\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
XFILLER_11_628 VPWR VGND sg13g2_decap_8
X_20674_ _01314_ net612 net171 VPWR VGND sg13g2_nand2_1
X_22413_ net948 VPWR _02956_ VGND net431 net658 sg13g2_o21ai_1
XFILLER_10_149 VPWR VGND sg13g2_decap_4
X_23393_ net1169 VGND VPWR _00455_ u_LMS.w\[7\]\[3\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
XFILLER_6_109 VPWR VGND sg13g2_fill_1
X_22344_ _02917_ _02918_ _00483_ VPWR VGND sg13g2_nor2_1
XFILLER_12_78 VPWR VGND sg13g2_fill_2
XFILLER_128_56 VPWR VGND sg13g2_decap_8
X_22275_ VGND VPWR _02863_ _02864_ _00468_ net924 sg13g2_a21oi_1
X_21226_ _01843_ _01841_ _01842_ VPWR VGND sg13g2_nand2_1
XFILLER_2_337 VPWR VGND sg13g2_fill_1
X_21157_ _01771_ _01773_ _01774_ VPWR VGND sg13g2_nor2_1
XFILLER_105_799 VPWR VGND sg13g2_decap_4
XFILLER_132_585 VPWR VGND sg13g2_decap_8
Xfanout630 u_LMS.x_r\[5\]\[3\] net630 VPWR VGND sg13g2_buf_1
XFILLER_59_831 VPWR VGND sg13g2_decap_8
X_20108_ VGND VPWR _11146_ _11148_ _11149_ _11145_ sg13g2_a21oi_1
Xfanout641 net642 net641 VPWR VGND sg13g2_buf_1
Xfanout652 u_LMS.x_r\[4\]\[0\] net652 VPWR VGND sg13g2_buf_1
X_21088_ _01714_ _01597_ _01599_ VPWR VGND sg13g2_xnor2_1
Xfanout663 u_LMS.x_r\[3\]\[2\] net663 VPWR VGND sg13g2_buf_1
Xfanout674 u_LMS.x_r\[2\]\[4\] net674 VPWR VGND sg13g2_buf_1
XFILLER_101_961 VPWR VGND sg13g2_decap_4
Xfanout685 u_LMS.x_r\[1\]\[7\] net685 VPWR VGND sg13g2_buf_1
X_20039_ _11071_ _11073_ _10976_ _11080_ VPWR VGND sg13g2_nand3_1
Xfanout696 u_LMS.x_r\[1\]\[2\] net696 VPWR VGND sg13g2_buf_1
X_12930_ _04287_ _04288_ _04289_ VPWR VGND sg13g2_nor2_1
XFILLER_74_812 VPWR VGND sg13g2_fill_1
XFILLER_100_460 VPWR VGND sg13g2_fill_2
XFILLER_92_119 VPWR VGND sg13g2_decap_8
XFILLER_18_205 VPWR VGND sg13g2_decap_8
XFILLER_18_216 VPWR VGND sg13g2_fill_1
XFILLER_2_1020 VPWR VGND sg13g2_decap_8
XFILLER_73_333 VPWR VGND sg13g2_fill_2
X_12861_ net844 net729 _04220_ _04222_ VPWR VGND sg13g2_a21o_1
X_14600_ _05892_ net769 net876 VPWR VGND sg13g2_nand2_1
X_11812_ VPWR _03233_ net619 VGND sg13g2_inv_1
X_15580_ _06835_ _06829_ _06833_ VPWR VGND sg13g2_xnor2_1
X_12792_ _04155_ u_FIR.sum\[0\]\[8\] net407 VPWR VGND sg13g2_nand2_1
XFILLER_27_794 VPWR VGND sg13g2_fill_1
X_14531_ VGND VPWR _05789_ _05808_ _05825_ _05807_ sg13g2_a21oi_1
X_23729_ net997 VGND VPWR _00791_ u_spi_slave.rd_toggle clknet_3_6__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_18_1017 VPWR VGND sg13g2_fill_2
XFILLER_18_1028 VPWR VGND sg13g2_decap_8
X_17250_ _08406_ _08376_ _08405_ VPWR VGND sg13g2_xnor2_1
X_14462_ _05762_ _05752_ _05760_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_959 VPWR VGND sg13g2_fill_1
X_16201_ _07437_ _07401_ _07439_ VPWR VGND sg13g2_xor2_1
X_23159__1551 VPWR VGND net1550 sg13g2_tiehi
X_13413_ _04755_ _04748_ _04753_ VPWR VGND sg13g2_xnor2_1
X_17181_ _08331_ _08336_ _08337_ VPWR VGND sg13g2_nor2_1
X_14393_ _05682_ VPWR _05696_ VGND net277 _05680_ sg13g2_o21ai_1
XFILLER_10_650 VPWR VGND sg13g2_fill_1
XFILLER_10_672 VPWR VGND sg13g2_decap_4
X_16132_ net873 net793 _07369_ _07371_ VPWR VGND sg13g2_a21o_1
XFILLER_127_324 VPWR VGND sg13g2_decap_8
X_13344_ _04688_ _04679_ _04686_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_858 VPWR VGND sg13g2_fill_1
XFILLER_127_335 VPWR VGND sg13g2_decap_4
XFILLER_128_869 VPWR VGND sg13g2_decap_8
XFILLER_10_694 VPWR VGND sg13g2_decap_8
XFILLER_6_654 VPWR VGND sg13g2_decap_8
X_16063_ _07304_ _07298_ _07302_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_379 VPWR VGND sg13g2_decap_8
X_13275_ _04621_ _04620_ _04580_ VPWR VGND sg13g2_nand2b_1
X_15014_ _06290_ _06288_ _06289_ VPWR VGND sg13g2_nand2_1
X_12226_ _03609_ net727 net866 _03599_ VPWR VGND sg13g2_and3_1
XFILLER_97_915 VPWR VGND sg13g2_fill_2
X_19822_ VGND VPWR u_LMS.w\[4\]\[18\] net311 _10880_ _10879_ sg13g2_a21oi_1
X_12157_ _03562_ _03565_ _03566_ VPWR VGND sg13g2_nor2_1
XFILLER_64_1059 VPWR VGND sg13g2_fill_2
XFILLER_78_82 VPWR VGND sg13g2_decap_4
XFILLER_111_758 VPWR VGND sg13g2_decap_8
XFILLER_111_769 VPWR VGND sg13g2_fill_2
X_19753_ _10418_ _10816_ _10400_ _10817_ VPWR VGND sg13g2_nand3_1
X_16965_ _08121_ _08119_ _08120_ VPWR VGND sg13g2_nand2_1
X_12088_ _00019_ VPWR _03501_ VGND u_spi_slave.tx_shift\[11\] net328 sg13g2_o21ai_1
XFILLER_110_279 VPWR VGND sg13g2_decap_8
X_18704_ VGND VPWR net654 net106 _09791_ _09788_ sg13g2_a21oi_1
X_15916_ _07146_ _07161_ _07162_ VPWR VGND sg13g2_nor2b_1
X_19684_ VGND VPWR _10748_ _10746_ u_LMS.w\[4\]\[15\] sg13g2_or2_1
X_16896_ _08050_ VPWR _08052_ VGND net418 net87 sg13g2_o21ai_1
X_18635_ _09730_ _09731_ _00339_ VPWR VGND sg13g2_nor2_1
X_15847_ _07095_ _07058_ _07094_ VPWR VGND sg13g2_nand2_1
XFILLER_91_130 VPWR VGND sg13g2_fill_1
X_18566_ net69 VPWR _09676_ VGND u_LMS.w\[2\]\[23\] u_LMS.w\[2\]\[22\] sg13g2_o21ai_1
X_15778_ _07026_ _07027_ _07028_ VPWR VGND sg13g2_and2_1
XFILLER_17_260 VPWR VGND sg13g2_fill_1
X_17517_ _08650_ _08624_ _08649_ VPWR VGND sg13g2_nand2_1
X_14729_ _06018_ _06012_ _06016_ VPWR VGND sg13g2_xnor2_1
XFILLER_33_753 VPWR VGND sg13g2_decap_8
X_18497_ _03337_ _09606_ _09607_ VPWR VGND sg13g2_nor2_1
XFILLER_21_904 VPWR VGND sg13g2_fill_1
XFILLER_60_550 VPWR VGND sg13g2_decap_8
XFILLER_60_561 VPWR VGND sg13g2_fill_1
XFILLER_20_403 VPWR VGND sg13g2_decap_8
X_17448_ net364 VPWR _08582_ VGND u_LMS.w\[0\]\[11\] net382 sg13g2_o21ai_1
XFILLER_60_572 VPWR VGND sg13g2_fill_2
XFILLER_33_797 VPWR VGND sg13g2_decap_8
XFILLER_20_414 VPWR VGND sg13g2_fill_2
X_17379_ net45 VPWR _08528_ VGND net43 _08527_ sg13g2_o21ai_1
X_19118_ _10201_ u_LMS.w\[3\]\[3\] _10205_ VPWR VGND sg13g2_xor2_1
XFILLER_119_847 VPWR VGND sg13g2_decap_8
X_20390_ _01053_ _01051_ _01052_ VPWR VGND sg13g2_nand2_1
XFILLER_118_346 VPWR VGND sg13g2_fill_2
X_19049_ _10065_ _10064_ _10136_ VPWR VGND sg13g2_xor2_1
X_22060_ _02654_ _02644_ _02645_ VPWR VGND sg13g2_xnor2_1
XFILLER_88_915 VPWR VGND sg13g2_fill_1
X_21011_ _01651_ u_LMS.w\[6\]\[22\] net74 VPWR VGND sg13g2_xnor2_1
XFILLER_114_585 VPWR VGND sg13g2_fill_2
XFILLER_88_959 VPWR VGND sg13g2_decap_4
XFILLER_114_36 VPWR VGND sg13g2_fill_2
X_22962_ _00022_ _00039_ VPWR VGND sg13g2_buf_1
XFILLER_56_834 VPWR VGND sg13g2_decap_8
XFILLER_83_631 VPWR VGND sg13g2_decap_8
XFILLER_28_536 VPWR VGND sg13g2_decap_8
X_21913_ _02507_ _02505_ _02506_ VPWR VGND sg13g2_nand2_1
XFILLER_67_193 VPWR VGND sg13g2_fill_2
X_22893_ _03175_ net297 u_FIR.x\[3\] net298 u_s2p_input.reg_sh\[2\] VPWR VGND sg13g2_a22oi_1
XFILLER_83_686 VPWR VGND sg13g2_decap_8
X_21844_ _02438_ net581 net83 VPWR VGND sg13g2_nand2_1
XFILLER_130_35 VPWR VGND sg13g2_decap_8
XFILLER_71_859 VPWR VGND sg13g2_decap_8
X_21775_ _02366_ _02368_ _02369_ VPWR VGND sg13g2_nor2_1
X_23108__1045 VPWR VGND net1044 sg13g2_tiehi
XFILLER_12_926 VPWR VGND sg13g2_fill_2
X_20726_ _01366_ net611 net261 VPWR VGND sg13g2_nand2_1
X_23514_ net1360 VGND VPWR _00576_ u_LMS.count\[17\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
XFILLER_12_937 VPWR VGND sg13g2_fill_1
X_20657_ _01259_ _01258_ _01297_ VPWR VGND sg13g2_xor2_1
X_23445_ net1596 VGND VPWR _00507_ u_LMS.x_r\[2\]\[4\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
XFILLER_109_313 VPWR VGND sg13g2_fill_2
XFILLER_23_88 VPWR VGND sg13g2_decap_4
X_23376_ net1220 VGND VPWR _00438_ u_LMS.w\[6\]\[9\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
X_20588_ _01228_ _01175_ _01226_ VPWR VGND sg13g2_xnor2_1
XFILLER_87_1015 VPWR VGND sg13g2_decap_8
XFILLER_109_368 VPWR VGND sg13g2_fill_2
X_22327_ net357 VPWR _02906_ VGND u_LMS.w\[8\]\[4\] net374 sg13g2_o21ai_1
XFILLER_124_316 VPWR VGND sg13g2_decap_8
XFILLER_124_327 VPWR VGND sg13g2_fill_2
X_13060_ net1025 VPWR _04412_ VGND net521 u_FIR.sum\[2\]\[3\] sg13g2_o21ai_1
XFILLER_2_112 VPWR VGND sg13g2_decap_8
X_22258_ _02815_ _02814_ _02851_ VPWR VGND sg13g2_xor2_1
X_12011_ _03406_ _03427_ _03428_ VPWR VGND sg13g2_nor2_1
X_21209_ _01826_ _01810_ _01824_ VPWR VGND sg13g2_xnor2_1
XFILLER_3_679 VPWR VGND sg13g2_fill_2
XFILLER_105_585 VPWR VGND sg13g2_decap_8
X_22189_ VGND VPWR _02678_ _02782_ _02783_ _02691_ sg13g2_a21oi_1
XFILLER_94_907 VPWR VGND sg13g2_decap_8
Xfanout460 net461 net460 VPWR VGND sg13g2_buf_1
XFILLER_93_406 VPWR VGND sg13g2_fill_2
Xfanout471 spi_wdata\[1\] net471 VPWR VGND sg13g2_buf_1
Xfanout482 net487 net482 VPWR VGND sg13g2_buf_1
X_16750_ _07904_ _07905_ _07906_ VPWR VGND sg13g2_xor2_1
Xfanout493 net494 net493 VPWR VGND sg13g2_buf_1
X_13962_ net1035 VPWR _05281_ VGND net539 u_FIR.sum\[3\]\[17\] sg13g2_o21ai_1
XFILLER_93_439 VPWR VGND sg13g2_decap_8
X_15701_ _06949_ VPWR _06953_ VGND _06950_ _06951_ sg13g2_o21ai_1
X_12913_ _04251_ _04272_ _04273_ VPWR VGND sg13g2_nor2b_1
X_16681_ _07851_ _07849_ _07850_ VPWR VGND sg13g2_nand2_1
X_13893_ _05215_ u_FIR.sum\[2\]\[14\] net402 VPWR VGND sg13g2_xnor2_1
X_18420_ _09530_ _09529_ _09521_ VPWR VGND sg13g2_nand2b_1
XFILLER_34_517 VPWR VGND sg13g2_fill_2
X_15632_ _06886_ _06876_ _06884_ VPWR VGND sg13g2_xnor2_1
X_12844_ _04204_ VPWR _04206_ VGND _04164_ _04166_ sg13g2_o21ai_1
XFILLER_64_62 VPWR VGND sg13g2_decap_8
X_18351_ _09390_ _09460_ _09461_ VPWR VGND sg13g2_nor2b_1
XFILLER_64_84 VPWR VGND sg13g2_decap_4
X_15563_ VGND VPWR _06819_ _06818_ _06791_ sg13g2_or2_1
X_12775_ net869 _04137_ net729 _04138_ VPWR VGND sg13g2_nand3_1
X_17302_ _08415_ u_LMS.w\[0\]\[11\] _08458_ VPWR VGND sg13g2_xor2_1
XFILLER_42_561 VPWR VGND sg13g2_decap_8
XFILLER_15_775 VPWR VGND sg13g2_fill_2
X_14514_ _05809_ _05788_ _05808_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_35 VPWR VGND sg13g2_decap_8
X_18282_ _09392_ _09389_ _09391_ VPWR VGND sg13g2_xnor2_1
X_15494_ _06751_ _06745_ _06753_ VPWR VGND sg13g2_xor2_1
XFILLER_42_594 VPWR VGND sg13g2_decap_8
XFILLER_14_296 VPWR VGND sg13g2_fill_1
X_17233_ _08388_ VPWR _08389_ VGND _03276_ _08032_ sg13g2_o21ai_1
X_14445_ _05729_ _05731_ _05745_ _05746_ VPWR VGND sg13g2_or3_1
XFILLER_30_789 VPWR VGND sg13g2_decap_4
XFILLER_31_1025 VPWR VGND sg13g2_fill_1
X_22968__1632 VPWR net1631 clknet_3_5__leaf_spi_sclk VGND sg13g2_inv_1
X_17164_ _08320_ _08313_ _08315_ VPWR VGND sg13g2_xnor2_1
X_14376_ _05680_ u_FIR.sum\[3\]\[13\] net399 VPWR VGND sg13g2_xnor2_1
XFILLER_7_952 VPWR VGND sg13g2_decap_4
X_16115_ _07328_ _07354_ _07355_ VPWR VGND sg13g2_nor2_1
X_13327_ _04670_ _04634_ _04672_ VPWR VGND sg13g2_xor2_1
XFILLER_116_828 VPWR VGND sg13g2_decap_4
X_17095_ _08251_ _08236_ _08249_ VPWR VGND sg13g2_xnor2_1
XFILLER_116_839 VPWR VGND sg13g2_fill_1
XFILLER_109_891 VPWR VGND sg13g2_fill_1
X_16046_ _07274_ VPWR _07287_ VGND _07275_ _07286_ sg13g2_o21ai_1
XFILLER_89_70 VPWR VGND sg13g2_fill_1
X_13258_ _04602_ _04603_ _04604_ VPWR VGND sg13g2_and2_1
XFILLER_124_861 VPWR VGND sg13g2_fill_1
XFILLER_97_701 VPWR VGND sg13g2_decap_4
X_12209_ net727 net894 net725 _03594_ VPWR VGND net906 sg13g2_nand4_1
X_13189_ _04537_ _04519_ _04535_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_1026 VPWR VGND sg13g2_decap_8
XFILLER_124_894 VPWR VGND sg13g2_decap_8
XFILLER_123_382 VPWR VGND sg13g2_decap_8
X_19805_ _10866_ _10805_ _10865_ VPWR VGND sg13g2_xnor2_1
XFILLER_97_756 VPWR VGND sg13g2_decap_8
XFILLER_85_907 VPWR VGND sg13g2_fill_2
X_17997_ VGND VPWR _09121_ _09123_ _00309_ net919 sg13g2_a21oi_1
XFILLER_85_929 VPWR VGND sg13g2_decap_4
XFILLER_38_812 VPWR VGND sg13g2_fill_2
X_19736_ _10800_ _10799_ _10754_ VPWR VGND sg13g2_nand2b_1
X_16948_ _08104_ net705 net193 VPWR VGND sg13g2_nand2_1
XFILLER_49_160 VPWR VGND sg13g2_decap_8
XFILLER_37_311 VPWR VGND sg13g2_fill_2
XFILLER_49_193 VPWR VGND sg13g2_fill_2
XFILLER_37_333 VPWR VGND sg13g2_fill_2
X_19667_ VGND VPWR _10729_ _10730_ _10731_ _10530_ sg13g2_a21oi_1
X_16879_ _08032_ _08033_ _08034_ _08035_ VPWR VGND sg13g2_nor3_1
XFILLER_64_152 VPWR VGND sg13g2_fill_2
XFILLER_53_826 VPWR VGND sg13g2_decap_8
XFILLER_52_303 VPWR VGND sg13g2_decap_8
X_18618_ _09717_ net34 net35 _09718_ VPWR VGND sg13g2_a21o_1
X_19598_ _10662_ _10653_ _10660_ VPWR VGND sg13g2_xnor2_1
X_23251__1391 VPWR VGND net1390 sg13g2_tiehi
XFILLER_64_196 VPWR VGND sg13g2_decap_8
X_18549_ u_LMS.w\[2\]\[18\] net70 _09659_ VPWR VGND sg13g2_and2_1
X_21560_ _02177_ u_LMS.w\[7\]\[9\] _02176_ VPWR VGND sg13g2_nand2_1
XFILLER_21_745 VPWR VGND sg13g2_fill_1
X_20511_ _03229_ net141 _01151_ VPWR VGND sg13g2_nor2_1
X_23258__1378 VPWR VGND net1377 sg13g2_tiehi
X_21491_ VGND VPWR _02038_ _02108_ _02107_ _02106_ sg13g2_a21oi_2
X_23104__1051 VPWR VGND net1050 sg13g2_tiehi
X_23230_ net1427 VGND VPWR _00292_ u_LMS.w\[0\]\[24\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
X_20442_ net22 VPWR _01098_ VGND net20 _01097_ sg13g2_o21ai_1
XFILLER_119_655 VPWR VGND sg13g2_fill_1
X_23161_ net1547 VGND VPWR _00223_ u_FIR.w\[0\]\[6\] clknet_leaf_51_clkA sg13g2_dfrbpq_1
X_20373_ _00984_ VPWR _01036_ VGND _01034_ _01035_ sg13g2_o21ai_1
XFILLER_118_176 VPWR VGND sg13g2_fill_1
X_22112_ VPWR _02706_ _02705_ VGND sg13g2_inv_1
XFILLER_106_349 VPWR VGND sg13g2_decap_8
X_23117__1614 VPWR VGND net1613 sg13g2_tiehi
X_23092_ net1068 VGND VPWR _00154_ u_FIR.sum\[5\]\[16\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
XFILLER_47_1021 VPWR VGND sg13g2_fill_2
X_22043_ _02636_ _02610_ _02637_ VPWR VGND sg13g2_xor2_1
XFILLER_114_360 VPWR VGND sg13g2_fill_1
XFILLER_87_211 VPWR VGND sg13g2_decap_8
XFILLER_125_35 VPWR VGND sg13g2_decap_8
XFILLER_88_756 VPWR VGND sg13g2_fill_2
XFILLER_87_244 VPWR VGND sg13g2_fill_2
XFILLER_76_918 VPWR VGND sg13g2_decap_4
XFILLER_130_897 VPWR VGND sg13g2_fill_2
XFILLER_102_599 VPWR VGND sg13g2_decap_8
XFILLER_75_439 VPWR VGND sg13g2_fill_1
XFILLER_87_299 VPWR VGND sg13g2_decap_8
XFILLER_56_620 VPWR VGND sg13g2_fill_1
X_22945_ VGND VPWR net324 _03204_ _00802_ _03203_ sg13g2_a21oi_1
XFILLER_83_450 VPWR VGND sg13g2_fill_2
XFILLER_28_355 VPWR VGND sg13g2_fill_2
XFILLER_44_815 VPWR VGND sg13g2_decap_4
XFILLER_84_995 VPWR VGND sg13g2_decap_8
XFILLER_71_612 VPWR VGND sg13g2_fill_2
XFILLER_28_377 VPWR VGND sg13g2_decap_8
X_22876_ _03163_ _03164_ _03165_ _00768_ VPWR VGND sg13g2_nor3_1
XFILLER_70_122 VPWR VGND sg13g2_fill_1
XFILLER_43_347 VPWR VGND sg13g2_fill_1
XFILLER_71_667 VPWR VGND sg13g2_decap_8
X_21827_ _02421_ _02401_ _02403_ _02420_ VPWR VGND sg13g2_and3_1
XFILLER_71_678 VPWR VGND sg13g2_decap_8
X_23754__1339 VPWR VGND net1338 sg13g2_tiehi
X_12560_ _03927_ _03860_ _03926_ _03932_ VPWR VGND sg13g2_a21o_1
XFILLER_11_200 VPWR VGND sg13g2_fill_2
X_21758_ _02352_ net578 net83 VPWR VGND sg13g2_nand2_1
XFILLER_51_380 VPWR VGND sg13g2_decap_8
X_23503__1402 VPWR VGND net1401 sg13g2_tiehi
XFILLER_15_1009 VPWR VGND sg13g2_decap_8
XFILLER_8_705 VPWR VGND sg13g2_fill_1
X_20709_ _01348_ VPWR _01349_ VGND _01344_ _01345_ sg13g2_o21ai_1
X_12491_ VPWR _03866_ _03865_ VGND sg13g2_inv_1
X_21689_ VGND VPWR _02277_ _02294_ _00451_ _02295_ sg13g2_a21oi_1
X_14230_ _05538_ u_FIR.w\[4\]\[3\] u_FIR.w\[4\]\[2\] net807 VPWR VGND sg13g2_and3_1
XFILLER_11_277 VPWR VGND sg13g2_fill_1
X_23428_ net1064 VGND VPWR _00490_ u_LMS.x_r\[0\]\[3\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
XFILLER_50_53 VPWR VGND sg13g2_decap_8
X_14161_ _05471_ u_FIR.sum\[3\]\[7\] net401 VPWR VGND sg13g2_xnor2_1
XFILLER_119_0 VPWR VGND sg13g2_decap_8
X_23359_ net1242 VGND VPWR _00421_ u_LMS.w\[6\]\[15\] clknet_leaf_23_clkA sg13g2_dfrbpq_1
XFILLER_4_922 VPWR VGND sg13g2_fill_1
XFILLER_124_102 VPWR VGND sg13g2_decap_4
X_13112_ _04462_ _04460_ _04461_ VPWR VGND sg13g2_nand2_1
X_14092_ VGND VPWR _05402_ _05403_ _05404_ net411 sg13g2_a21oi_1
XFILLER_124_146 VPWR VGND sg13g2_decap_8
XFILLER_1_0 VPWR VGND sg13g2_decap_8
XFILLER_106_883 VPWR VGND sg13g2_decap_8
X_17920_ _08652_ _08662_ _08633_ _09053_ VPWR VGND sg13g2_nand3_1
X_13043_ _04377_ _04394_ _04395_ VPWR VGND sg13g2_nor2_1
XFILLER_61_1007 VPWR VGND sg13g2_decap_8
X_17851_ _08984_ _08969_ _08970_ VPWR VGND sg13g2_xnor2_1
XFILLER_66_406 VPWR VGND sg13g2_decap_8
X_16802_ _07939_ net2127 _07937_ _07958_ VPWR VGND sg13g2_a21o_1
XFILLER_93_203 VPWR VGND sg13g2_fill_2
XFILLER_121_897 VPWR VGND sg13g2_decap_8
X_17782_ net700 net223 net699 _08915_ VPWR VGND net205 sg13g2_nand4_1
X_14994_ VGND VPWR net479 _06270_ _00158_ _06271_ sg13g2_a21oi_1
Xfanout290 _03435_ net290 VPWR VGND sg13g2_buf_1
XFILLER_93_236 VPWR VGND sg13g2_fill_1
XFILLER_115_90 VPWR VGND sg13g2_decap_8
X_19521_ net424 _10584_ _10585_ VPWR VGND sg13g2_nor2_1
X_16733_ _07889_ _07887_ _07888_ VPWR VGND sg13g2_nand2_1
X_13945_ net1035 VPWR _05265_ VGND net536 u_FIR.sum\[3\]\[16\] sg13g2_o21ai_1
XFILLER_47_653 VPWR VGND sg13g2_fill_2
XFILLER_46_141 VPWR VGND sg13g2_fill_2
XFILLER_46_152 VPWR VGND sg13g2_fill_1
X_19452_ _10516_ _10475_ _10482_ VPWR VGND sg13g2_xnor2_1
XFILLER_90_921 VPWR VGND sg13g2_decap_8
X_16664_ net1030 VPWR _07839_ VGND net527 net744 sg13g2_o21ai_1
XFILLER_61_100 VPWR VGND sg13g2_decap_8
X_13876_ _05199_ _05167_ _05197_ VPWR VGND sg13g2_xnor2_1
X_18403_ _09513_ _09510_ _09512_ VPWR VGND sg13g2_nand2_1
X_15615_ _06869_ net787 net845 VPWR VGND sg13g2_nand2_1
XFILLER_90_965 VPWR VGND sg13g2_fill_2
X_19383_ _03247_ net96 _10447_ VPWR VGND sg13g2_nor2_1
X_12827_ _04189_ _04172_ _04188_ VPWR VGND sg13g2_xnor2_1
X_16595_ net1008 VPWR _07787_ VGND net506 u_FIR.w\[3\]\[6\] sg13g2_o21ai_1
XFILLER_90_998 VPWR VGND sg13g2_decap_8
X_18334_ _09442_ net1656 _09444_ VPWR VGND sg13g2_xor2_1
X_15546_ _06802_ _06796_ _06800_ VPWR VGND sg13g2_xnor2_1
X_12758_ _04121_ _04091_ _04122_ VPWR VGND sg13g2_xor2_1
XFILLER_42_391 VPWR VGND sg13g2_fill_2
X_18265_ _09375_ _09360_ _09374_ VPWR VGND sg13g2_nand2_1
X_15477_ VGND VPWR _06738_ _06706_ _06587_ sg13g2_or2_1
X_12689_ _04040_ VPWR _04054_ VGND _04035_ _04038_ sg13g2_o21ai_1
X_17216_ _08372_ _08371_ _08368_ VPWR VGND sg13g2_nand2b_1
X_14428_ _05730_ _05714_ _05728_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_430 VPWR VGND sg13g2_decap_8
X_18196_ _09271_ _09305_ _09306_ VPWR VGND sg13g2_xor2_1
XFILLER_129_986 VPWR VGND sg13g2_decap_8
XFILLER_128_463 VPWR VGND sg13g2_decap_8
X_17147_ _08303_ net712 net231 VPWR VGND sg13g2_nand2_1
XFILLER_128_474 VPWR VGND sg13g2_fill_1
X_14359_ net1006 VPWR _05664_ VGND net513 u_FIR.sum\[4\]\[12\] sg13g2_o21ai_1
Xfanout9 _02845_ net9 VPWR VGND sg13g2_buf_1
XFILLER_6_281 VPWR VGND sg13g2_decap_8
X_17078_ _08230_ _08233_ _08234_ VPWR VGND sg13g2_nor2_1
X_16029_ _07268_ _07269_ _07270_ VPWR VGND sg13g2_nor2b_1
XFILLER_130_105 VPWR VGND sg13g2_decap_8
XFILLER_69_222 VPWR VGND sg13g2_fill_2
X_23113__1620 VPWR VGND net1619 sg13g2_tiehi
XFILLER_29_119 VPWR VGND sg13g2_fill_2
X_19719_ _10765_ VPWR _10783_ VGND _10780_ _10781_ sg13g2_o21ai_1
X_20991_ _01631_ _01630_ _01575_ VPWR VGND sg13g2_nand2b_1
XFILLER_38_664 VPWR VGND sg13g2_decap_4
XFILLER_93_770 VPWR VGND sg13g2_fill_1
XFILLER_66_984 VPWR VGND sg13g2_fill_1
XFILLER_81_921 VPWR VGND sg13g2_fill_1
X_22730_ u_debug_unit.mon_w1_sync\[2\] net330 _03083_ VPWR VGND sg13g2_nor2_1
XFILLER_26_837 VPWR VGND sg13g2_decap_4
XFILLER_1_91 VPWR VGND sg13g2_decap_8
XFILLER_52_122 VPWR VGND sg13g2_decap_8
XFILLER_77_1058 VPWR VGND sg13g2_fill_2
XFILLER_52_133 VPWR VGND sg13g2_fill_2
XFILLER_41_807 VPWR VGND sg13g2_decap_8
X_22661_ coeff_force_packed\[33\] net463 _03065_ _00653_ VPWR VGND sg13g2_mux2_1
XFILLER_52_155 VPWR VGND sg13g2_fill_2
X_21612_ VPWR _02229_ net2164 VGND sg13g2_inv_1
X_22592_ _03058_ net429 net286 VPWR VGND sg13g2_nand2_1
X_21543_ _02160_ _02137_ _02138_ VPWR VGND sg13g2_xnor2_1
XFILLER_21_575 VPWR VGND sg13g2_decap_4
X_21474_ _02091_ _02082_ _02086_ VPWR VGND sg13g2_xnor2_1
X_20425_ _01085_ net316 u_LMS.w\[5\]\[15\] coeff_force_packed\[38\] net566 VPWR VGND
+ sg13g2_a22oi_1
X_23213_ net1457 VGND VPWR _00275_ u_FIR.w\[8\]\[2\] clknet_leaf_23_clkA sg13g2_dfrbpq_1
XFILLER_112_7 VPWR VGND sg13g2_fill_2
X_20356_ _00995_ u_LMS.w\[5\]\[7\] _01018_ _01019_ VPWR VGND sg13g2_a21o_1
X_23144_ net1573 VGND VPWR _00206_ u_FIR.sum\[8\]\[16\] clknet_leaf_44_clkA sg13g2_dfrbpq_1
X_23075_ net1093 VGND VPWR _00137_ u_FIR.sum\[4\]\[18\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
X_20287_ _00950_ _11122_ _11089_ VPWR VGND sg13g2_nand2b_1
XFILLER_1_947 VPWR VGND sg13g2_decap_8
XFILLER_0_424 VPWR VGND sg13g2_decap_8
X_22026_ _02551_ VPWR _02620_ VGND _03225_ net140 sg13g2_o21ai_1
XFILLER_103_853 VPWR VGND sg13g2_fill_2
XFILLER_49_918 VPWR VGND sg13g2_decap_8
XFILLER_48_406 VPWR VGND sg13g2_decap_8
XFILLER_48_417 VPWR VGND sg13g2_fill_1
XFILLER_103_897 VPWR VGND sg13g2_decap_4
XFILLER_76_737 VPWR VGND sg13g2_decap_8
X_22967__1631 VPWR net1630 clknet_3_5__leaf_spi_sclk VGND sg13g2_inv_1
X_11991_ spi_addr\[0\] net474 _03408_ VPWR VGND sg13g2_nor2_1
XFILLER_56_461 VPWR VGND sg13g2_fill_1
XFILLER_17_815 VPWR VGND sg13g2_fill_2
X_13730_ VGND VPWR net826 _05055_ _05057_ _05054_ sg13g2_a21oi_1
X_22928_ spi_addr\[1\] net325 _03193_ VPWR VGND sg13g2_nor2_1
XFILLER_45_53 VPWR VGND sg13g2_decap_8
XFILLER_71_442 VPWR VGND sg13g2_decap_8
X_13661_ _04990_ _04985_ _04988_ VPWR VGND sg13g2_xnor2_1
X_22859_ VGND VPWR net300 _03151_ _00764_ _03152_ sg13g2_a21oi_1
X_15400_ VGND VPWR _06637_ _06657_ _06665_ _06656_ sg13g2_a21oi_1
XFILLER_71_486 VPWR VGND sg13g2_decap_8
X_12612_ _03980_ _03979_ _03975_ VPWR VGND sg13g2_nand2b_1
X_16380_ _07612_ u_FIR.sum\[7\]\[14\] net387 VPWR VGND sg13g2_nand2_1
X_13592_ VGND VPWR net532 _04921_ _00105_ _04922_ sg13g2_a21oi_1
X_15331_ _06597_ _06570_ _06599_ VPWR VGND sg13g2_xor2_1
X_12543_ _03898_ VPWR _03916_ VGND _03832_ _03900_ sg13g2_o21ai_1
XFILLER_61_63 VPWR VGND sg13g2_decap_4
X_23181__1514 VPWR VGND net1513 sg13g2_tiehi
XFILLER_129_238 VPWR VGND sg13g2_decap_8
X_18050_ _09164_ _09024_ _09026_ VPWR VGND sg13g2_xnor2_1
X_15262_ _06525_ _06528_ _06531_ VPWR VGND sg13g2_nor2_1
X_12474_ _03848_ _03790_ _03850_ VPWR VGND sg13g2_xor2_1
X_17001_ _08157_ _08152_ _08155_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_14 VPWR VGND sg13g2_decap_8
X_14213_ VGND VPWR _05520_ _05521_ _05522_ net411 sg13g2_a21oi_1
X_15193_ _06464_ u_FIR.w\[2\]\[1\] net804 VPWR VGND sg13g2_nand2_1
X_14144_ _05452_ _05453_ _05454_ VPWR VGND sg13g2_and2_1
XFILLER_126_978 VPWR VGND sg13g2_fill_2
XFILLER_3_251 VPWR VGND sg13g2_fill_2
XFILLER_125_488 VPWR VGND sg13g2_decap_8
X_18952_ VGND VPWR _10039_ _10038_ _10037_ sg13g2_or2_1
X_14075_ _05387_ _05351_ _05385_ VPWR VGND sg13g2_xnor2_1
XFILLER_112_127 VPWR VGND sg13g2_fill_1
X_23447__1591 VPWR VGND net1590 sg13g2_tiehi
XFILLER_3_295 VPWR VGND sg13g2_fill_1
XFILLER_112_149 VPWR VGND sg13g2_decap_8
X_17903_ _08994_ VPWR _09036_ VGND _09033_ _09034_ sg13g2_o21ai_1
X_13026_ _04379_ net909 net744 net896 net745 VPWR VGND sg13g2_a22oi_1
XFILLER_117_1030 VPWR VGND sg13g2_decap_8
X_18883_ _09936_ _09930_ _09970_ VPWR VGND sg13g2_xor2_1
Xfanout1030 net1031 net1030 VPWR VGND sg13g2_buf_1
XFILLER_67_715 VPWR VGND sg13g2_fill_1
XFILLER_6_1018 VPWR VGND sg13g2_decap_8
Xfanout1041 net1042 net1041 VPWR VGND sg13g2_buf_1
XFILLER_67_737 VPWR VGND sg13g2_decap_8
X_17834_ _08965_ _08966_ _08963_ _08967_ VPWR VGND sg13g2_nand3_1
XFILLER_120_160 VPWR VGND sg13g2_fill_2
XFILLER_67_748 VPWR VGND sg13g2_fill_2
XFILLER_94_556 VPWR VGND sg13g2_fill_2
XFILLER_82_707 VPWR VGND sg13g2_decap_4
XFILLER_66_258 VPWR VGND sg13g2_fill_1
X_17765_ _08898_ _08867_ _08875_ VPWR VGND sg13g2_xnor2_1
X_14977_ _06257_ _06252_ _06256_ VPWR VGND sg13g2_xnor2_1
XFILLER_47_450 VPWR VGND sg13g2_decap_8
XFILLER_48_984 VPWR VGND sg13g2_decap_8
X_19504_ _03244_ _03245_ net237 net252 _10568_ VPWR VGND sg13g2_nor4_1
X_16716_ VGND VPWR net529 _07876_ _00274_ _07877_ sg13g2_a21oi_1
X_13928_ _05243_ _05245_ _05248_ VPWR VGND sg13g2_nor2_1
X_17696_ _08794_ _08828_ _08829_ VPWR VGND sg13g2_nor2_1
XFILLER_35_656 VPWR VGND sg13g2_decap_4
X_19435_ _10499_ _10490_ _10495_ VPWR VGND sg13g2_xnor2_1
X_16647_ VGND VPWR net534 _07824_ _00257_ _07825_ sg13g2_a21oi_1
X_13859_ _05177_ _05179_ _05182_ VPWR VGND sg13g2_nor2_1
XFILLER_63_987 VPWR VGND sg13g2_fill_1
XFILLER_23_818 VPWR VGND sg13g2_fill_1
XFILLER_35_689 VPWR VGND sg13g2_fill_2
X_19366_ _10430_ _10415_ _10428_ VPWR VGND sg13g2_xnor2_1
X_16578_ net993 VPWR _07776_ VGND net491 net773 sg13g2_o21ai_1
XFILLER_37_1053 VPWR VGND sg13g2_decap_8
XFILLER_124_1012 VPWR VGND sg13g2_decap_8
X_18317_ _09427_ net675 net200 VPWR VGND sg13g2_nand2_1
X_15529_ _06786_ _06778_ _06785_ VPWR VGND sg13g2_nand2_1
X_19297_ _10361_ net646 net153 VPWR VGND sg13g2_nand2_1
X_18248_ _09358_ net674 net182 VPWR VGND sg13g2_nand2_1
XFILLER_30_383 VPWR VGND sg13g2_fill_2
XFILLER_117_901 VPWR VGND sg13g2_decap_8
X_18179_ _09286_ _09285_ _09289_ VPWR VGND sg13g2_xor2_1
X_23013__1187 VPWR VGND net1186 sg13g2_tiehi
XFILLER_116_422 VPWR VGND sg13g2_decap_8
X_20210_ _00873_ _00869_ _00871_ VPWR VGND sg13g2_xnor2_1
XFILLER_117_956 VPWR VGND sg13g2_decap_8
X_21190_ _01807_ _01787_ _01805_ VPWR VGND sg13g2_xnor2_1
Xrebuffer2202 _07972_ net2201 VPWR VGND sg13g2_buf_1
X_23702__1503 VPWR VGND net1502 sg13g2_tiehi
Xrebuffer2213 _01923_ net2212 VPWR VGND sg13g2_buf_1
XFILLER_132_926 VPWR VGND sg13g2_decap_8
X_20141_ _11147_ _11146_ _11182_ VPWR VGND sg13g2_xor2_1
XFILLER_106_26 VPWR VGND sg13g2_decap_8
X_23028__1165 VPWR VGND net1164 sg13g2_tiehi
XFILLER_106_37 VPWR VGND sg13g2_fill_2
X_20072_ _03241_ net95 _11113_ VPWR VGND sg13g2_nor2_1
XFILLER_98_884 VPWR VGND sg13g2_decap_8
XFILLER_98_895 VPWR VGND sg13g2_fill_1
XFILLER_57_203 VPWR VGND sg13g2_decap_4
XFILLER_131_1016 VPWR VGND sg13g2_decap_8
X_23474__1505 VPWR VGND net1504 sg13g2_tiehi
XFILLER_85_567 VPWR VGND sg13g2_decap_8
XFILLER_39_962 VPWR VGND sg13g2_fill_2
XFILLER_122_14 VPWR VGND sg13g2_decap_8
XFILLER_39_984 VPWR VGND sg13g2_fill_2
X_23762_ net984 VGND VPWR _00009_ u_spi_slave.rx_shift\[4\] clknet_3_0__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_54_943 VPWR VGND sg13g2_fill_2
X_20974_ _01614_ _01613_ _01588_ VPWR VGND sg13g2_nand2b_1
X_22713_ VGND VPWR _07715_ net338 _00696_ _03074_ sg13g2_a21oi_1
XFILLER_53_453 VPWR VGND sg13g2_fill_2
XFILLER_14_818 VPWR VGND sg13g2_fill_1
X_23693_ net1011 VGND VPWR _00755_ u_debug_unit.mon_w8_sync\[3\] clknet_leaf_38_clkA
+ sg13g2_dfrbpq_1
XFILLER_54_998 VPWR VGND sg13g2_fill_1
XFILLER_81_784 VPWR VGND sg13g2_fill_2
XFILLER_41_615 VPWR VGND sg13g2_fill_2
XFILLER_15_23 VPWR VGND sg13g2_fill_2
X_22644_ coeff_force_packed\[20\] net460 _03063_ _00638_ VPWR VGND sg13g2_mux2_1
X_22575_ _03048_ net950 _03047_ VPWR VGND sg13g2_nand2_1
X_21526_ VGND VPWR _01791_ _01822_ _02143_ _02142_ sg13g2_a21oi_1
X_21457_ _02072_ _02059_ _02074_ VPWR VGND sg13g2_xor2_1
XFILLER_107_433 VPWR VGND sg13g2_decap_8
X_20408_ net322 net52 _01071_ VPWR VGND sg13g2_and2_1
X_12190_ _03578_ net323 _00018_ VPWR VGND sg13g2_nor2b_1
X_21388_ _02005_ net2162 _02003_ VPWR VGND sg13g2_xnor2_1
X_23127_ net1598 VGND VPWR _00189_ u_FIR.sum\[7\]\[13\] clknet_leaf_44_clkA sg13g2_dfrbpq_1
X_20339_ VGND VPWR _00911_ _01001_ _01002_ _00920_ sg13g2_a21oi_1
XFILLER_1_744 VPWR VGND sg13g2_decap_4
XFILLER_89_862 VPWR VGND sg13g2_fill_1
X_23058_ net1119 VGND VPWR _00120_ u_FIR.sum\[4\]\[1\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
XFILLER_103_661 VPWR VGND sg13g2_fill_1
X_14900_ _06184_ u_FIR.sum\[4\]\[14\] net396 VPWR VGND sg13g2_xnor2_1
XFILLER_89_895 VPWR VGND sg13g2_fill_1
XFILLER_131_981 VPWR VGND sg13g2_decap_8
X_22009_ _02601_ _02596_ _02603_ VPWR VGND sg13g2_xor2_1
X_15880_ _07122_ _07124_ _07127_ VPWR VGND sg13g2_nor2_1
XFILLER_0_298 VPWR VGND sg13g2_decap_4
X_14831_ VGND VPWR net511 _06116_ _00149_ _06117_ sg13g2_a21oi_1
XFILLER_76_578 VPWR VGND sg13g2_fill_1
XFILLER_5_1051 VPWR VGND sg13g2_decap_8
XFILLER_91_526 VPWR VGND sg13g2_decap_4
X_17550_ _08683_ _08680_ _08681_ VPWR VGND sg13g2_xnor2_1
X_14762_ VGND VPWR _06010_ _06027_ _06050_ _06036_ sg13g2_a21oi_1
X_11974_ _03393_ _03387_ _03389_ VPWR VGND sg13g2_nand2_1
X_16501_ VGND VPWR net480 _07717_ _00218_ _07718_ sg13g2_a21oi_1
X_13713_ VGND VPWR net535 _05039_ _00108_ _05040_ sg13g2_a21oi_1
X_17481_ net109 _08612_ net686 _08614_ VPWR VGND sg13g2_nand3_1
X_14693_ _05980_ _05981_ _05982_ _05983_ VPWR VGND sg13g2_nor3_1
XFILLER_45_987 VPWR VGND sg13g2_fill_2
XFILLER_17_689 VPWR VGND sg13g2_fill_1
X_19220_ _10298_ _10246_ _10299_ VPWR VGND sg13g2_xor2_1
X_16432_ _07662_ _07661_ _07660_ VPWR VGND sg13g2_nand2b_1
XFILLER_112_91 VPWR VGND sg13g2_fill_1
X_13644_ _04973_ _04967_ _04971_ VPWR VGND sg13g2_xnor2_1
X_19151_ VPWR VGND _10234_ _10180_ _10235_ u_LMS.w\[3\]\[15\] _10238_ _10177_ sg13g2_a221oi_1
X_16363_ _07595_ net271 _07596_ VPWR VGND sg13g2_xor2_1
X_13575_ net840 u_FIR.sum\[2\]\[5\] net756 _04906_ VPWR VGND sg13g2_nand3_1
X_18102_ _09212_ _09200_ _09211_ VPWR VGND sg13g2_xnor2_1
XFILLER_12_361 VPWR VGND sg13g2_decap_4
X_15314_ _06582_ _06574_ _06581_ VPWR VGND sg13g2_nand2_1
XFILLER_40_681 VPWR VGND sg13g2_fill_1
X_19082_ _10169_ u_LMS.w\[3\]\[19\] net68 VPWR VGND sg13g2_xnor2_1
X_12526_ VPWR _03900_ _03899_ VGND sg13g2_inv_1
XFILLER_12_383 VPWR VGND sg13g2_fill_1
X_16294_ _07529_ _07521_ _07528_ VPWR VGND sg13g2_nand2_1
XFILLER_75_7 VPWR VGND sg13g2_decap_8
X_18033_ _09152_ net57 _09151_ VPWR VGND sg13g2_nand2_1
X_15245_ _06515_ u_FIR.sum\[5\]\[9\] net395 VPWR VGND sg13g2_nand2_1
X_12457_ _03833_ _03797_ _03800_ VPWR VGND sg13g2_nand2_1
XFILLER_126_720 VPWR VGND sg13g2_decap_8
XFILLER_126_731 VPWR VGND sg13g2_fill_1
XFILLER_126_753 VPWR VGND sg13g2_fill_1
X_15176_ _06411_ _06447_ _06448_ VPWR VGND sg13g2_nor2b_1
X_12388_ _03766_ _03758_ _03765_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_252 VPWR VGND sg13g2_decap_8
X_14127_ _05406_ _05437_ _05438_ VPWR VGND sg13g2_nor2_1
XFILLER_125_285 VPWR VGND sg13g2_fill_2
X_19984_ _11025_ _11022_ _11024_ VPWR VGND sg13g2_nand2_1
XFILLER_98_158 VPWR VGND sg13g2_fill_1
XFILLER_101_609 VPWR VGND sg13g2_decap_4
X_18935_ _09989_ _09982_ _10022_ VPWR VGND sg13g2_xor2_1
X_14058_ _05363_ VPWR _05370_ VGND _05334_ _05361_ sg13g2_o21ai_1
XFILLER_100_119 VPWR VGND sg13g2_decap_8
X_13009_ net908 u_FIR.sum\[1\]\[0\] net746 _04364_ VPWR VGND sg13g2_nand3_1
XFILLER_79_383 VPWR VGND sg13g2_fill_1
X_18866_ net128 _09952_ net662 _09953_ VPWR VGND sg13g2_nand3_1
XFILLER_95_854 VPWR VGND sg13g2_fill_2
XFILLER_39_247 VPWR VGND sg13g2_decap_8
X_23024__1171 VPWR VGND net1170 sg13g2_tiehi
X_23431__1056 VPWR VGND net1055 sg13g2_tiehi
X_17817_ _08905_ _08948_ _08950_ VPWR VGND sg13g2_nor2_1
XFILLER_94_353 VPWR VGND sg13g2_decap_8
XFILLER_95_887 VPWR VGND sg13g2_fill_2
XFILLER_39_269 VPWR VGND sg13g2_decap_8
X_18797_ _09884_ _09883_ _09879_ VPWR VGND sg13g2_nand2b_1
Xclkbuf_leaf_31_clkA clknet_4_15_0_clkA clknet_leaf_31_clkA VPWR VGND sg13g2_buf_8
XFILLER_94_386 VPWR VGND sg13g2_decap_8
XFILLER_130_1060 VPWR VGND sg13g2_fill_1
X_17748_ _08878_ _08877_ _08881_ VPWR VGND sg13g2_xor2_1
XFILLER_47_280 VPWR VGND sg13g2_fill_2
X_17679_ _03274_ net126 net2198 _08812_ VGND VPWR net123 sg13g2_nor4_2
XFILLER_23_615 VPWR VGND sg13g2_fill_1
XFILLER_35_486 VPWR VGND sg13g2_fill_1
X_19418_ _10482_ _10476_ _10481_ VPWR VGND sg13g2_xnor2_1
X_20690_ _01295_ _01292_ _01330_ VPWR VGND sg13g2_xor2_1
X_19349_ _10413_ _10393_ _10411_ VPWR VGND sg13g2_xnor2_1
XFILLER_31_670 VPWR VGND sg13g2_fill_2
X_22360_ VGND VPWR net454 _03289_ _00488_ _02929_ sg13g2_a21oi_1
XFILLER_108_208 VPWR VGND sg13g2_fill_2
X_21311_ _01928_ net598 net226 VPWR VGND sg13g2_nand2_1
X_22291_ net2166 u_LMS.w\[8\]\[20\] _02877_ VPWR VGND sg13g2_xor2_1
X_22966__1630 VPWR net1629 clknet_3_5__leaf_spi_sclk VGND sg13g2_inv_1
X_23295__1308 VPWR VGND net1307 sg13g2_tiehi
X_21242_ _01807_ _01782_ _01859_ VPWR VGND sg13g2_xor2_1
XFILLER_11_1045 VPWR VGND sg13g2_decap_8
XFILLER_117_14 VPWR VGND sg13g2_fill_1
XFILLER_132_723 VPWR VGND sg13g2_decap_8
XFILLER_117_797 VPWR VGND sg13g2_fill_2
X_21173_ VPWR _01790_ _01789_ VGND sg13g2_inv_1
XFILLER_105_959 VPWR VGND sg13g2_decap_8
XFILLER_132_734 VPWR VGND sg13g2_fill_1
XFILLER_131_222 VPWR VGND sg13g2_decap_8
XFILLER_116_296 VPWR VGND sg13g2_decap_8
X_20124_ _11157_ _11164_ _11165_ VPWR VGND sg13g2_nor2b_1
Xrebuffer2065 _01567_ net2064 VPWR VGND sg13g2_buf_2
Xfanout801 net802 net801 VPWR VGND sg13g2_buf_1
XFILLER_89_147 VPWR VGND sg13g2_decap_4
Xrebuffer2076 _01422_ net2075 VPWR VGND sg13g2_buf_1
Xfanout812 net816 net812 VPWR VGND sg13g2_buf_1
Xfanout823 net824 net823 VPWR VGND sg13g2_buf_1
Xrebuffer2087 _10238_ net2086 VPWR VGND sg13g2_buf_1
Xfanout834 net837 net834 VPWR VGND sg13g2_buf_1
Xrebuffer2098 net2098 net2097 VPWR VGND sg13g2_buf_1
Xfanout845 net846 net845 VPWR VGND sg13g2_buf_1
X_20055_ _11096_ _11093_ _11095_ VPWR VGND sg13g2_nand2_1
Xfanout856 net857 net856 VPWR VGND sg13g2_buf_1
Xfanout867 net869 net867 VPWR VGND sg13g2_buf_1
Xfanout878 net880 net878 VPWR VGND sg13g2_buf_1
XFILLER_97_180 VPWR VGND sg13g2_fill_1
XFILLER_85_331 VPWR VGND sg13g2_decap_8
Xfanout889 net891 net889 VPWR VGND sg13g2_buf_1
XFILLER_86_898 VPWR VGND sg13g2_decap_8
XFILLER_93_28 VPWR VGND sg13g2_decap_8
X_23745_ net988 VGND VPWR _00807_ spi_wdata\[4\] clknet_3_1__leaf_spi_sclk sg13g2_dfrbpq_1
X_20957_ u_LMS.w\[6\]\[2\] net262 net621 _01597_ VPWR VGND sg13g2_nand3_1
XFILLER_41_401 VPWR VGND sg13g2_fill_1
XFILLER_54_795 VPWR VGND sg13g2_decap_8
XFILLER_42_957 VPWR VGND sg13g2_fill_1
X_23676_ net1024 VGND VPWR _00738_ u_debug_unit.mon_w6_sync\[0\] clknet_leaf_21_clkA
+ sg13g2_dfrbpq_1
XFILLER_53_294 VPWR VGND sg13g2_fill_1
X_20888_ VGND VPWR _01343_ _01364_ _01528_ _01363_ sg13g2_a21oi_1
XFILLER_42_979 VPWR VGND sg13g2_fill_1
X_22627_ u_debug_unit.force_w0\[7\] net458 _03061_ _00623_ VPWR VGND sg13g2_mux2_1
XFILLER_107_1051 VPWR VGND sg13g2_decap_8
XFILLER_10_832 VPWR VGND sg13g2_decap_4
X_13360_ _04674_ _04703_ _04704_ VPWR VGND sg13g2_nor2b_1
X_22558_ _03037_ u_LMS.count\[20\] _03035_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_803 VPWR VGND sg13g2_fill_2
XFILLER_127_517 VPWR VGND sg13g2_decap_8
X_12311_ _03689_ _03658_ _03691_ VPWR VGND sg13g2_xor2_1
X_21509_ _02126_ _02122_ _02123_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_825 VPWR VGND sg13g2_decap_4
X_13291_ _04621_ VPWR _04636_ VGND _04617_ _04619_ sg13g2_o21ai_1
X_22489_ net958 VPWR _02994_ VGND net445 net583 sg13g2_o21ai_1
XFILLER_6_847 VPWR VGND sg13g2_decap_8
XFILLER_5_324 VPWR VGND sg13g2_fill_1
X_15030_ _06306_ _06285_ _06305_ VPWR VGND sg13g2_nand2_1
X_12242_ _03624_ net725 net866 VPWR VGND sg13g2_nand2_1
XFILLER_101_0 VPWR VGND sg13g2_decap_4
XFILLER_123_712 VPWR VGND sg13g2_decap_4
XFILLER_108_797 VPWR VGND sg13g2_decap_8
X_12173_ net943 u_spi_slave.rx_shift\[3\] _00009_ VPWR VGND sg13g2_nor2b_1
XFILLER_122_211 VPWR VGND sg13g2_decap_8
X_16981_ _08137_ _08134_ _08136_ VPWR VGND sg13g2_nand2_1
XFILLER_110_428 VPWR VGND sg13g2_fill_2
Xclkbuf_leaf_54_clkA clknet_4_3_0_clkA clknet_leaf_54_clkA VPWR VGND sg13g2_buf_8
X_18720_ net119 _09806_ _09807_ VPWR VGND sg13g2_nor2b_1
X_15932_ _07177_ _07175_ _07176_ VPWR VGND sg13g2_nand2_1
XFILLER_67_73 VPWR VGND sg13g2_decap_4
X_18651_ _09742_ _09743_ _00343_ VPWR VGND sg13g2_nor2_1
X_15863_ _07111_ _07087_ _07110_ VPWR VGND sg13g2_xnor2_1
XFILLER_36_206 VPWR VGND sg13g2_fill_2
XFILLER_18_910 VPWR VGND sg13g2_decap_8
XFILLER_92_835 VPWR VGND sg13g2_fill_1
X_23148__1568 VPWR VGND net1567 sg13g2_tiehi
X_17602_ _08735_ net689 net220 VPWR VGND sg13g2_nand2_1
X_14814_ _06101_ _06089_ _06100_ VPWR VGND sg13g2_xnor2_1
X_18582_ _09690_ net304 u_LMS.w\[2\]\[14\] coeff_force_packed\[16\] net559 VPWR VGND
+ sg13g2_a22oi_1
X_15794_ _07018_ _07043_ _07044_ VPWR VGND sg13g2_nor2b_1
XFILLER_29_291 VPWR VGND sg13g2_fill_2
XFILLER_18_954 VPWR VGND sg13g2_fill_2
X_17533_ _08666_ _08651_ _08664_ VPWR VGND sg13g2_xnor2_1
X_14745_ _06034_ _06033_ _05992_ VPWR VGND sg13g2_nand2b_1
XFILLER_51_209 VPWR VGND sg13g2_fill_2
XFILLER_17_453 VPWR VGND sg13g2_fill_1
X_11957_ VPWR _03378_ net2207 VGND sg13g2_inv_1
XFILLER_17_464 VPWR VGND sg13g2_fill_1
XFILLER_33_935 VPWR VGND sg13g2_decap_8
X_17464_ _08597_ net696 net147 VPWR VGND sg13g2_nand2_1
X_14676_ VGND VPWR net505 _05965_ _00145_ _05966_ sg13g2_a21oi_1
X_11888_ VPWR _03309_ u_LMS.w\[6\]\[23\] VGND sg13g2_inv_1
X_19203_ _10175_ _10239_ _10240_ _10285_ VPWR VGND sg13g2_or3_1
X_16415_ _07646_ _07627_ _07644_ VPWR VGND sg13g2_xnor2_1
X_13627_ _04957_ _04917_ _04920_ _04956_ VPWR VGND sg13g2_and3_1
X_17395_ net45 VPWR _08541_ VGND net43 _08540_ sg13g2_o21ai_1
XFILLER_34_1012 VPWR VGND sg13g2_fill_2
XFILLER_34_1034 VPWR VGND sg13g2_fill_1
X_19134_ u_LMS.w\[3\]\[9\] _10189_ _10221_ VPWR VGND sg13g2_nor2_1
X_16346_ _07578_ _07579_ _00202_ VPWR VGND sg13g2_nor2_1
X_13558_ _04889_ net749 net898 VPWR VGND sg13g2_nand2_1
XFILLER_12_191 VPWR VGND sg13g2_fill_1
X_19065_ VGND VPWR _09845_ _10151_ _10152_ _09844_ sg13g2_a21oi_1
X_12509_ _03882_ _03857_ _03884_ VPWR VGND sg13g2_xor2_1
X_16277_ _07511_ VPWR _07513_ VGND _07475_ _07477_ sg13g2_o21ai_1
X_13489_ VGND VPWR _04823_ _04822_ _04814_ sg13g2_or2_1
XFILLER_8_173 VPWR VGND sg13g2_fill_2
XFILLER_121_1059 VPWR VGND sg13g2_fill_2
X_18016_ VGND VPWR u_LMS.w\[1\]\[22\] net303 _09139_ _09122_ sg13g2_a21oi_1
X_15228_ net848 _06497_ net775 _06498_ VPWR VGND sg13g2_nand3_1
XFILLER_114_712 VPWR VGND sg13g2_fill_1
X_15159_ _06431_ _06424_ _06429_ VPWR VGND sg13g2_xnor2_1
XFILLER_113_211 VPWR VGND sg13g2_fill_1
X_23291__1314 VPWR VGND net1313 sg13g2_tiehi
Xfanout108 net108 net109 VPWR VGND sg13g2_buf_4
XFILLER_87_618 VPWR VGND sg13g2_fill_2
X_19967_ _11008_ net624 net154 VPWR VGND sg13g2_nand2_1
Xfanout119 _09799_ net119 VPWR VGND sg13g2_buf_1
XFILLER_80_1032 VPWR VGND sg13g2_fill_1
X_18918_ _10004_ _09999_ _10005_ VPWR VGND sg13g2_xor2_1
XFILLER_67_320 VPWR VGND sg13g2_decap_8
X_19898_ _10936_ _10938_ _10939_ VPWR VGND sg13g2_nor2_1
X_18849_ _09936_ _09931_ _09934_ VPWR VGND sg13g2_xnor2_1
XFILLER_55_504 VPWR VGND sg13g2_decap_8
XFILLER_83_824 VPWR VGND sg13g2_decap_8
XFILLER_28_729 VPWR VGND sg13g2_fill_2
XFILLER_94_161 VPWR VGND sg13g2_fill_1
XFILLER_94_183 VPWR VGND sg13g2_fill_1
X_21860_ _02446_ _02453_ _02454_ VPWR VGND sg13g2_nor2b_1
X_20811_ _01443_ _01439_ _01450_ _01451_ VPWR VGND sg13g2_a21o_1
X_21791_ VPWR _02385_ _02384_ VGND sg13g2_inv_1
XFILLER_70_529 VPWR VGND sg13g2_decap_4
X_23530_ net987 VGND VPWR _00592_ u_debug_unit.sw_reset\[0\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
X_20742_ _01380_ _01379_ _01382_ VPWR VGND sg13g2_xor2_1
XFILLER_35_294 VPWR VGND sg13g2_fill_2
XFILLER_23_445 VPWR VGND sg13g2_decap_8
X_23461_ net1548 VGND VPWR _00523_ u_LMS.x_r\[4\]\[4\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
X_20673_ _01313_ net614 net171 VPWR VGND sg13g2_nand2_1
XFILLER_10_106 VPWR VGND sg13g2_decap_8
XFILLER_50_286 VPWR VGND sg13g2_fill_1
X_22412_ VGND VPWR net433 _03263_ _00514_ _02955_ sg13g2_a21oi_1
XFILLER_50_297 VPWR VGND sg13g2_fill_1
X_22994__1216 VPWR VGND net1215 sg13g2_tiehi
X_23392_ net1172 VGND VPWR _00454_ u_LMS.w\[7\]\[2\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
XFILLER_12_24 VPWR VGND sg13g2_fill_2
X_22343_ net357 VPWR _02918_ VGND u_LMS.w\[8\]\[8\] net374 sg13g2_o21ai_1
X_23226__1435 VPWR VGND net1434 sg13g2_tiehi
XFILLER_128_35 VPWR VGND sg13g2_decap_8
X_22274_ _02864_ net308 u_LMS.w\[8\]\[16\] coeff_force_packed\[60\] net561 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_105_701 VPWR VGND sg13g2_fill_2
XFILLER_105_712 VPWR VGND sg13g2_fill_2
XFILLER_88_28 VPWR VGND sg13g2_decap_4
XFILLER_2_305 VPWR VGND sg13g2_fill_2
XFILLER_104_200 VPWR VGND sg13g2_decap_4
X_21225_ _03222_ net93 _01842_ VPWR VGND sg13g2_nor2_1
XFILLER_5_7 VPWR VGND sg13g2_decap_8
XFILLER_105_756 VPWR VGND sg13g2_fill_1
X_21156_ VGND VPWR net591 net110 _01773_ _01770_ sg13g2_a21oi_1
XFILLER_132_564 VPWR VGND sg13g2_decap_8
X_23267__1360 VPWR VGND net1359 sg13g2_tiehi
Xfanout620 u_LMS.x_r\[6\]\[0\] net620 VPWR VGND sg13g2_buf_1
Xfanout631 u_LMS.x_r\[5\]\[2\] net631 VPWR VGND sg13g2_buf_1
X_20107_ VPWR _11148_ _11147_ VGND sg13g2_inv_1
Xfanout642 u_LMS.x_r\[4\]\[6\] net642 VPWR VGND sg13g2_buf_1
X_21087_ _01712_ _01713_ _00431_ VPWR VGND sg13g2_nor2_1
Xfanout653 u_LMS.x_r\[3\]\[7\] net653 VPWR VGND sg13g2_buf_1
XFILLER_120_759 VPWR VGND sg13g2_fill_2
Xfanout664 net666 net664 VPWR VGND sg13g2_buf_1
Xfanout675 u_LMS.x_r\[2\]\[4\] net675 VPWR VGND sg13g2_buf_1
X_20038_ VGND VPWR _11071_ _11073_ _11079_ _10976_ sg13g2_a21oi_1
Xfanout686 net687 net686 VPWR VGND sg13g2_buf_1
XFILLER_86_662 VPWR VGND sg13g2_decap_8
XFILLER_100_450 VPWR VGND sg13g2_fill_1
Xfanout697 u_LMS.x_r\[1\]\[2\] net697 VPWR VGND sg13g2_buf_1
XFILLER_92_109 VPWR VGND sg13g2_fill_2
XFILLER_58_375 VPWR VGND sg13g2_fill_2
XFILLER_46_526 VPWR VGND sg13g2_fill_1
XFILLER_74_846 VPWR VGND sg13g2_fill_1
XFILLER_73_323 VPWR VGND sg13g2_fill_1
X_12860_ net844 _04220_ net729 _04221_ VPWR VGND sg13g2_nand3_1
XFILLER_18_239 VPWR VGND sg13g2_decap_8
X_11811_ VPWR _03232_ net616 VGND sg13g2_inv_1
XFILLER_37_98 VPWR VGND sg13g2_decap_4
X_12791_ VPWR _04154_ _04153_ VGND sg13g2_inv_1
X_21989_ _02582_ _02576_ _02583_ VPWR VGND sg13g2_xor2_1
XFILLER_26_261 VPWR VGND sg13g2_fill_1
X_23144__1574 VPWR VGND net1573 sg13g2_tiehi
X_14530_ VGND VPWR net490 _05823_ _00141_ _05824_ sg13g2_a21oi_1
X_23728_ net1319 VGND VPWR _00790_ u_s2p_input.reg_cnt\[2\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
XFILLER_42_743 VPWR VGND sg13g2_decap_8
XFILLER_14_445 VPWR VGND sg13g2_fill_2
XFILLER_30_905 VPWR VGND sg13g2_fill_1
XFILLER_42_776 VPWR VGND sg13g2_decap_8
X_14461_ _05752_ _05760_ _05761_ VPWR VGND sg13g2_nor2b_1
XFILLER_14_478 VPWR VGND sg13g2_decap_4
X_23659_ net986 VGND VPWR _00721_ u_debug_unit.mon_w3_sync\[4\] clknet_leaf_53_clkA
+ sg13g2_dfrbpq_1
XFILLER_53_97 VPWR VGND sg13g2_fill_2
X_16200_ _07401_ _07437_ _07438_ VPWR VGND sg13g2_nor2b_1
X_13412_ _04748_ _04753_ _04754_ VPWR VGND sg13g2_nor2b_1
X_17180_ _08336_ _08335_ net198 _08334_ _08307_ VPWR VGND sg13g2_a22oi_1
X_14392_ VGND VPWR _05667_ _05687_ _05695_ _05686_ sg13g2_a21oi_1
X_16131_ net873 _07369_ net793 _07370_ VPWR VGND sg13g2_nand3_1
X_13343_ _04687_ _04679_ _04686_ VPWR VGND sg13g2_nand2_1
X_16062_ _07303_ _07302_ _07298_ VPWR VGND sg13g2_nand2b_1
X_13274_ _04620_ _04616_ _04619_ VPWR VGND sg13g2_xnor2_1
X_15013_ net859 net783 u_FIR.sum\[5\]\[3\] _06289_ VPWR VGND sg13g2_a21o_1
X_12225_ _03608_ net727 net870 VPWR VGND sg13g2_nand2_1
X_19821_ net562 coeff_force_packed\[34\] _10879_ VPWR VGND sg13g2_and2_1
XFILLER_123_553 VPWR VGND sg13g2_decap_4
X_12156_ _03558_ _03563_ _03556_ _03565_ VPWR VGND _03564_ sg13g2_nand4_1
XFILLER_123_575 VPWR VGND sg13g2_decap_8
XFILLER_96_415 VPWR VGND sg13g2_decap_8
XFILLER_123_586 VPWR VGND sg13g2_fill_2
XFILLER_2_894 VPWR VGND sg13g2_fill_2
X_19752_ _10816_ net640 net158 VPWR VGND sg13g2_nand2_1
XFILLER_68_139 VPWR VGND sg13g2_decap_8
X_16964_ _08120_ _08077_ _08083_ VPWR VGND sg13g2_xnor2_1
X_12087_ _03491_ _03499_ _03500_ VPWR VGND sg13g2_nor2_1
X_18703_ net106 _09788_ net654 _09790_ VPWR VGND sg13g2_nand3_1
X_15915_ _07159_ _07147_ _07161_ VPWR VGND sg13g2_xor2_1
X_19683_ u_LMS.w\[4\]\[15\] _10746_ _10747_ VPWR VGND sg13g2_and2_1
X_16895_ net703 net155 net702 _08051_ VPWR VGND net95 sg13g2_nand4_1
XFILLER_65_824 VPWR VGND sg13g2_fill_1
X_18634_ net354 VPWR _09731_ VGND u_LMS.w\[2\]\[2\] net370 sg13g2_o21ai_1
X_15846_ _07094_ _07091_ _07092_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_120 VPWR VGND sg13g2_fill_2
XFILLER_76_194 VPWR VGND sg13g2_fill_2
XFILLER_40_1060 VPWR VGND sg13g2_fill_1
XFILLER_80_816 VPWR VGND sg13g2_fill_2
XFILLER_64_367 VPWR VGND sg13g2_fill_1
X_18565_ _09668_ _09669_ _09674_ _09675_ VPWR VGND sg13g2_or3_1
XFILLER_64_378 VPWR VGND sg13g2_fill_1
X_15777_ net834 net784 _07025_ _07027_ VPWR VGND sg13g2_a21o_1
X_12989_ _04346_ _04345_ _04321_ VPWR VGND sg13g2_nand2b_1
XFILLER_91_186 VPWR VGND sg13g2_decap_8
X_17516_ _08649_ _08629_ _08647_ VPWR VGND sg13g2_xnor2_1
XFILLER_17_283 VPWR VGND sg13g2_decap_4
X_14728_ _06017_ _06016_ _06012_ VPWR VGND sg13g2_nand2b_1
X_18496_ _09606_ _09541_ net2115 VPWR VGND sg13g2_xnor2_1
X_17447_ VGND VPWR net58 _08580_ _08581_ net42 sg13g2_a21oi_1
X_14659_ _05911_ u_FIR.w\[3\]\[6\] _05909_ _05950_ VPWR VGND sg13g2_a21o_1
XFILLER_60_595 VPWR VGND sg13g2_fill_2
X_17378_ _08527_ _08396_ _08526_ VPWR VGND sg13g2_xnor2_1
X_19117_ u_LMS.w\[3\]\[3\] _10201_ _10204_ VPWR VGND sg13g2_nor2_1
X_16329_ _07563_ net272 _07561_ VPWR VGND sg13g2_xnor2_1
XFILLER_64_0 VPWR VGND sg13g2_fill_2
X_22990__1222 VPWR VGND net1221 sg13g2_tiehi
X_19048_ _10086_ VPWR _10135_ VGND _10132_ _10133_ sg13g2_o21ai_1
XFILLER_114_542 VPWR VGND sg13g2_fill_1
X_21010_ _01650_ u_LMS.w\[6\]\[22\] net74 VPWR VGND sg13g2_nand2_1
XFILLER_99_253 VPWR VGND sg13g2_fill_1
XFILLER_114_564 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_6_clkA clknet_4_8_0_clkA clknet_leaf_6_clkA VPWR VGND sg13g2_buf_8
XFILLER_4_91 VPWR VGND sg13g2_decap_8
XFILLER_101_236 VPWR VGND sg13g2_fill_1
XFILLER_87_459 VPWR VGND sg13g2_fill_1
XFILLER_68_651 VPWR VGND sg13g2_fill_1
X_22961_ _07706_ VPWR _00818_ VGND _03283_ net526 sg13g2_o21ai_1
XFILLER_67_150 VPWR VGND sg13g2_fill_2
XFILLER_56_813 VPWR VGND sg13g2_decap_8
XFILLER_56_824 VPWR VGND sg13g2_fill_1
XFILLER_68_695 VPWR VGND sg13g2_decap_4
XFILLER_110_792 VPWR VGND sg13g2_fill_1
X_21912_ _02506_ _02466_ _02472_ VPWR VGND sg13g2_xnor2_1
XFILLER_55_334 VPWR VGND sg13g2_decap_8
X_22892_ VPWR _00775_ _03174_ VGND sg13g2_inv_1
XFILLER_55_367 VPWR VGND sg13g2_decap_8
X_21843_ _02437_ net579 net110 VPWR VGND sg13g2_nand2_1
XFILLER_70_304 VPWR VGND sg13g2_decap_8
XFILLER_43_529 VPWR VGND sg13g2_fill_1
XFILLER_130_14 VPWR VGND sg13g2_decap_8
XFILLER_82_197 VPWR VGND sg13g2_fill_1
X_21774_ VGND VPWR net573 net110 _02368_ _02365_ sg13g2_a21oi_1
XFILLER_70_359 VPWR VGND sg13g2_decap_8
XFILLER_51_551 VPWR VGND sg13g2_fill_1
X_23513_ net1364 VGND VPWR _00575_ u_LMS.count\[16\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
X_20725_ _01365_ _01343_ _01364_ VPWR VGND sg13g2_xnor2_1
XFILLER_24_798 VPWR VGND sg13g2_fill_2
X_23140__1580 VPWR VGND net1579 sg13g2_tiehi
X_23444_ net1599 VGND VPWR _00506_ u_LMS.x_r\[2\]\[3\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
X_20656_ _01291_ VPWR _01296_ VGND _01292_ _01295_ sg13g2_o21ai_1
XFILLER_104_1021 VPWR VGND sg13g2_decap_8
XFILLER_20_960 VPWR VGND sg13g2_fill_2
X_23375_ net1223 VGND VPWR _00437_ u_LMS.w\[6\]\[8\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
X_20587_ _01176_ _01226_ _01227_ VPWR VGND sg13g2_and2_1
XFILLER_99_27 VPWR VGND sg13g2_fill_1
X_22326_ VGND VPWR net47 _02904_ _02905_ net6 sg13g2_a21oi_1
X_22257_ VGND VPWR _02849_ _02850_ _00464_ net924 sg13g2_a21oi_1
X_12010_ _03427_ spi_addr\[4\] _03426_ VPWR VGND sg13g2_nand2_1
X_21208_ _01825_ _01810_ _01824_ VPWR VGND sg13g2_nand2_1
X_22188_ _02782_ net584 net255 VPWR VGND sg13g2_nand2_1
XFILLER_78_437 VPWR VGND sg13g2_decap_4
X_21139_ net598 net150 net596 _01756_ VPWR VGND sg13g2_nand3_1
Xfanout450 net451 net450 VPWR VGND sg13g2_buf_1
Xfanout461 spi_wdata\[6\] net461 VPWR VGND sg13g2_buf_1
Xfanout472 spi_wdata\[0\] net472 VPWR VGND sg13g2_buf_1
X_13961_ _05280_ _05279_ _05278_ VPWR VGND sg13g2_nand2b_1
XFILLER_87_982 VPWR VGND sg13g2_fill_1
Xfanout483 net486 net483 VPWR VGND sg13g2_buf_1
XFILLER_48_86 VPWR VGND sg13g2_fill_2
Xfanout494 net550 net494 VPWR VGND sg13g2_buf_1
XFILLER_24_1055 VPWR VGND sg13g2_decap_4
XFILLER_74_621 VPWR VGND sg13g2_decap_4
XFILLER_58_172 VPWR VGND sg13g2_fill_2
XFILLER_48_97 VPWR VGND sg13g2_decap_8
X_15700_ _06949_ _06950_ _06951_ _06952_ VPWR VGND sg13g2_nor3_1
X_12912_ _04272_ _04264_ _04270_ VPWR VGND sg13g2_xnor2_1
X_16680_ u_LMS.w\[7\]\[24\] u_LMS.w\[7\]\[23\] u_LMS.w\[7\]\[22\] u_LMS.w\[7\]\[21\]
+ _07850_ VPWR VGND sg13g2_nor4_1
XFILLER_46_334 VPWR VGND sg13g2_decap_4
X_13892_ u_FIR.sum\[2\]\[14\] net402 _05214_ VPWR VGND sg13g2_and2_1
XFILLER_0_49 VPWR VGND sg13g2_decap_8
XFILLER_104_81 VPWR VGND sg13g2_fill_1
X_23490__1448 VPWR VGND net1447 sg13g2_tiehi
X_15631_ _06885_ _06876_ _06884_ VPWR VGND sg13g2_nand2_1
X_12843_ _04164_ _04166_ _04204_ _04205_ VPWR VGND sg13g2_nor3_1
XFILLER_62_838 VPWR VGND sg13g2_decap_8
XFILLER_73_197 VPWR VGND sg13g2_decap_8
XFILLER_27_592 VPWR VGND sg13g2_fill_1
XFILLER_15_732 VPWR VGND sg13g2_decap_8
X_18350_ _09460_ _09455_ _09458_ VPWR VGND sg13g2_xnor2_1
X_15562_ _06818_ _06789_ _06816_ VPWR VGND sg13g2_xnor2_1
X_12774_ _03360_ net885 _04137_ VPWR VGND sg13g2_nor2_1
XFILLER_14_220 VPWR VGND sg13g2_decap_8
XFILLER_14_231 VPWR VGND sg13g2_decap_8
X_17301_ u_LMS.w\[0\]\[11\] _08415_ _08457_ VPWR VGND sg13g2_nor2_1
X_14513_ _05806_ _05795_ _05808_ VPWR VGND sg13g2_xor2_1
XFILLER_9_14 VPWR VGND sg13g2_decap_8
XFILLER_30_702 VPWR VGND sg13g2_decap_4
X_18281_ net420 _03261_ net235 net251 _09391_ VPWR VGND sg13g2_nor4_1
X_15493_ _06752_ _06751_ _06745_ VPWR VGND sg13g2_nand2b_1
XFILLER_70_882 VPWR VGND sg13g2_decap_8
XFILLER_70_1020 VPWR VGND sg13g2_fill_1
X_17232_ _08054_ _08387_ _08051_ _08388_ VPWR VGND sg13g2_nand3_1
X_14444_ _05743_ _05742_ _05745_ VPWR VGND sg13g2_xor2_1
Xfanout90 net91 net90 VPWR VGND sg13g2_buf_2
X_17163_ _08317_ _08316_ _08319_ VPWR VGND sg13g2_xor2_1
X_14375_ _05679_ u_FIR.sum\[3\]\[13\] net399 VPWR VGND sg13g2_nand2_1
XFILLER_127_122 VPWR VGND sg13g2_fill_1
XFILLER_31_1048 VPWR VGND sg13g2_decap_8
XFILLER_10_481 VPWR VGND sg13g2_decap_8
X_16114_ _07354_ _07344_ _07352_ VPWR VGND sg13g2_xnor2_1
XFILLER_31_1059 VPWR VGND sg13g2_fill_2
XFILLER_128_667 VPWR VGND sg13g2_decap_8
XFILLER_116_807 VPWR VGND sg13g2_decap_8
X_13326_ _04634_ _04670_ _04671_ VPWR VGND sg13g2_nor2b_1
X_17094_ _08250_ _08236_ _08249_ VPWR VGND sg13g2_nand2_1
XFILLER_127_155 VPWR VGND sg13g2_fill_2
XFILLER_115_306 VPWR VGND sg13g2_decap_8
X_16045_ VGND VPWR _07279_ _07285_ _07286_ _07280_ sg13g2_a21oi_1
X_13257_ net856 net739 _04601_ _04603_ VPWR VGND sg13g2_a21o_1
XFILLER_127_199 VPWR VGND sg13g2_decap_4
XFILLER_108_391 VPWR VGND sg13g2_decap_4
XFILLER_89_82 VPWR VGND sg13g2_decap_8
X_12208_ VGND VPWR net527 _03592_ _00050_ _03593_ sg13g2_a21oi_1
X_13188_ _04536_ _04519_ _04535_ VPWR VGND sg13g2_nand2_1
XFILLER_69_415 VPWR VGND sg13g2_fill_1
XFILLER_123_361 VPWR VGND sg13g2_fill_2
X_19804_ _10865_ _10748_ _10747_ VPWR VGND sg13g2_nand2b_1
XFILLER_69_437 VPWR VGND sg13g2_fill_2
X_12139_ _03549_ _03437_ coeff_force_packed\[57\] _03405_ u_debug_unit.mon_w5_sync\[1\]
+ VPWR VGND sg13g2_a22oi_1
X_17996_ VGND VPWR u_LMS.w\[1\]\[18\] net301 _09123_ _09122_ sg13g2_a21oi_1
XFILLER_84_407 VPWR VGND sg13g2_fill_1
X_19735_ _10799_ _03328_ _10753_ VPWR VGND sg13g2_nand2_1
X_16947_ _03275_ _03276_ _08068_ net214 _08103_ VPWR VGND sg13g2_nor4_1
XFILLER_49_172 VPWR VGND sg13g2_fill_2
XFILLER_49_183 VPWR VGND sg13g2_fill_2
X_19666_ _10730_ _10499_ _10529_ VPWR VGND sg13g2_xnor2_1
X_16878_ _08034_ net86 net703 net103 net702 VPWR VGND sg13g2_a22oi_1
XFILLER_65_654 VPWR VGND sg13g2_decap_8
XFILLER_37_356 VPWR VGND sg13g2_fill_2
X_18617_ _09717_ _09670_ _09672_ VPWR VGND sg13g2_xnor2_1
X_15829_ _07078_ _07055_ _07076_ VPWR VGND sg13g2_xnor2_1
X_19597_ _10653_ _10660_ _10661_ VPWR VGND sg13g2_nor2b_1
XFILLER_46_890 VPWR VGND sg13g2_decap_4
X_18548_ _09588_ VPWR _09658_ VGND _09657_ _09656_ sg13g2_o21ai_1
XFILLER_100_39 VPWR VGND sg13g2_fill_1
X_18479_ _09589_ net2090 _09293_ VPWR VGND sg13g2_xnor2_1
XFILLER_33_584 VPWR VGND sg13g2_fill_2
X_20510_ net426 _03228_ net190 net160 _01150_ VPWR VGND sg13g2_nor4_1
X_21490_ _02107_ _02037_ _02036_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_612 VPWR VGND sg13g2_decap_4
XFILLER_20_267 VPWR VGND sg13g2_fill_2
X_20441_ _01097_ _00972_ _01096_ VPWR VGND sg13g2_xnor2_1
X_23160_ net1549 VGND VPWR _00222_ u_FIR.w\[0\]\[5\] clknet_leaf_47_clkA sg13g2_dfrbpq_1
XFILLER_109_37 VPWR VGND sg13g2_fill_2
X_20372_ _01035_ net2130 u_LMS.w\[5\]\[13\] VPWR VGND sg13g2_xnor2_1
XFILLER_106_317 VPWR VGND sg13g2_decap_4
X_22111_ _02606_ _02590_ _02705_ VPWR VGND sg13g2_xor2_1
X_23091_ net1069 VGND VPWR _00153_ u_FIR.sum\[5\]\[15\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
XFILLER_47_1000 VPWR VGND sg13g2_decap_8
XFILLER_0_606 VPWR VGND sg13g2_fill_1
X_22042_ _02636_ net578 net255 VPWR VGND sg13g2_nand2_1
XFILLER_114_350 VPWR VGND sg13g2_fill_1
XFILLER_125_14 VPWR VGND sg13g2_decap_8
XFILLER_47_1055 VPWR VGND sg13g2_decap_4
XFILLER_114_383 VPWR VGND sg13g2_fill_2
XFILLER_102_556 VPWR VGND sg13g2_fill_1
XFILLER_75_407 VPWR VGND sg13g2_fill_2
XFILLER_69_971 VPWR VGND sg13g2_fill_1
XFILLER_130_887 VPWR VGND sg13g2_fill_2
XFILLER_96_790 VPWR VGND sg13g2_decap_8
XFILLER_84_930 VPWR VGND sg13g2_fill_2
XFILLER_18_34 VPWR VGND sg13g2_decap_8
X_22944_ _03204_ net323 u_spi_slave.rx_shift\[5\] u_spi_slave.rx_shift\[13\] net428
+ VPWR VGND sg13g2_a22oi_1
XFILLER_29_857 VPWR VGND sg13g2_fill_2
X_22875_ _03138_ _03139_ net951 _03165_ VPWR VGND sg13g2_nand3_1
XFILLER_70_101 VPWR VGND sg13g2_fill_2
X_21826_ _02420_ _02385_ _02419_ VPWR VGND sg13g2_xnor2_1
X_23442__1606 VPWR VGND net1605 sg13g2_tiehi
XFILLER_54_1015 VPWR VGND sg13g2_fill_1
X_21757_ net581 net150 net578 _02351_ VPWR VGND sg13g2_nand3_1
XFILLER_34_88 VPWR VGND sg13g2_decap_4
X_20708_ net209 _01347_ net610 _01348_ VPWR VGND sg13g2_nand3_1
X_12490_ _03865_ u_FIR.w\[8\]\[4\] net811 VPWR VGND sg13g2_nand2_1
X_21688_ net967 VPWR _02295_ VGND u_LMS.w\[7\]\[22\] _08501_ sg13g2_o21ai_1
XFILLER_8_739 VPWR VGND sg13g2_fill_2
X_23427_ net1067 VGND VPWR _00489_ u_LMS.x_r\[0\]\[2\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
XFILLER_50_21 VPWR VGND sg13g2_fill_2
X_20639_ _01279_ _01277_ _01278_ VPWR VGND sg13g2_nand2_1
XFILLER_50_32 VPWR VGND sg13g2_decap_8
XFILLER_109_133 VPWR VGND sg13g2_decap_4
X_14160_ _05470_ u_FIR.sum\[3\]\[7\] net401 VPWR VGND sg13g2_nand2_1
X_23358_ net1243 VGND VPWR _00420_ u_LMS.w\[6\]\[14\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
X_13111_ net842 net747 u_FIR.sum\[1\]\[5\] _04461_ VPWR VGND sg13g2_a21o_1
X_22309_ net8 VPWR _02892_ VGND net7 _02891_ sg13g2_o21ai_1
XFILLER_124_125 VPWR VGND sg13g2_decap_8
X_14091_ _05367_ _05365_ _05401_ _05403_ VPWR VGND sg13g2_a21o_1
X_23289_ net1316 VGND VPWR _00351_ u_LMS.w\[3\]\[14\] clknet_leaf_52_clkA sg13g2_dfrbpq_1
XFILLER_124_136 VPWR VGND sg13g2_fill_1
XFILLER_4_967 VPWR VGND sg13g2_decap_8
X_13042_ _04394_ _04392_ _04393_ VPWR VGND sg13g2_nand2_1
XFILLER_3_499 VPWR VGND sg13g2_decap_4
X_17850_ _08983_ u_LMS.w\[1\]\[16\] _08981_ VPWR VGND sg13g2_xnor2_1
XFILLER_79_779 VPWR VGND sg13g2_decap_4
X_16801_ VGND VPWR _07937_ _07957_ _07939_ _07938_ sg13g2_a21oi_2
X_17781_ _08914_ net701 net206 VPWR VGND sg13g2_nand2_1
Xfanout280 _05134_ net280 VPWR VGND sg13g2_buf_1
X_14993_ net975 VPWR _06271_ VGND net479 u_FIR.sum\[6\]\[1\] sg13g2_o21ai_1
XFILLER_120_386 VPWR VGND sg13g2_decap_8
Xfanout291 _03431_ net291 VPWR VGND sg13g2_buf_1
X_19520_ _10584_ _10582_ _10583_ VPWR VGND sg13g2_xnor2_1
XFILLER_75_40 VPWR VGND sg13g2_fill_1
X_16732_ u_FIR.sum\[8\]\[18\] u_FIR.sum\[8\]\[17\] u_FIR.sum\[8\]\[16\] _07888_ VGND
+ VPWR u_FIR.sum\[8\]\[15\] sg13g2_nor4_2
XFILLER_75_952 VPWR VGND sg13g2_fill_2
X_13944_ _05264_ _05248_ _05262_ VPWR VGND sg13g2_xnor2_1
XFILLER_19_345 VPWR VGND sg13g2_fill_2
XFILLER_75_974 VPWR VGND sg13g2_decap_4
X_19451_ _10507_ VPWR _10515_ VGND _10513_ _10514_ sg13g2_o21ai_1
XFILLER_35_827 VPWR VGND sg13g2_fill_1
X_16663_ VGND VPWR u_LMS.w\[6\]\[14\] _07832_ _07838_ _07833_ sg13g2_a21oi_1
X_13875_ _05198_ _05197_ _05167_ VPWR VGND sg13g2_nand2b_1
XFILLER_90_944 VPWR VGND sg13g2_decap_8
XFILLER_62_635 VPWR VGND sg13g2_decap_4
X_18402_ _09483_ _09511_ _09512_ VPWR VGND sg13g2_and2_1
X_15614_ _06868_ net789 net832 VPWR VGND sg13g2_nand2_1
X_12826_ _04188_ _04181_ _04186_ VPWR VGND sg13g2_xnor2_1
XFILLER_34_348 VPWR VGND sg13g2_fill_2
X_19382_ _03246_ net101 _10446_ VPWR VGND sg13g2_nor2_1
XFILLER_34_359 VPWR VGND sg13g2_decap_8
X_16594_ VGND VPWR net493 _07785_ _00243_ _07786_ sg13g2_a21oi_1
XFILLER_61_145 VPWR VGND sg13g2_fill_2
XFILLER_15_551 VPWR VGND sg13g2_fill_1
XFILLER_15_562 VPWR VGND sg13g2_fill_1
X_18333_ net1656 _09442_ _09443_ VPWR VGND sg13g2_nor2_1
X_15545_ _06801_ _06800_ _06796_ VPWR VGND sg13g2_nand2b_1
X_12757_ _04120_ _04112_ _04121_ VPWR VGND sg13g2_xor2_1
XFILLER_91_61 VPWR VGND sg13g2_decap_4
XFILLER_15_573 VPWR VGND sg13g2_fill_1
XFILLER_61_189 VPWR VGND sg13g2_decap_8
XFILLER_91_94 VPWR VGND sg13g2_decap_4
X_18264_ net127 net678 _09359_ _09374_ VPWR VGND sg13g2_a21o_1
X_15476_ _06737_ _06706_ _06724_ VPWR VGND sg13g2_nand2_1
X_12688_ VGND VPWR _04018_ _04045_ _04053_ _04044_ sg13g2_a21oi_1
XFILLER_129_932 VPWR VGND sg13g2_decap_8
X_17215_ _08371_ _08362_ _08367_ VPWR VGND sg13g2_nand2_1
X_14427_ _05714_ _05728_ _05729_ VPWR VGND sg13g2_nor2b_1
X_18195_ _09305_ net674 net127 VPWR VGND sg13g2_nand2_1
XFILLER_30_598 VPWR VGND sg13g2_decap_8
X_17146_ _08302_ _08296_ _08297_ VPWR VGND sg13g2_xnor2_1
X_14358_ _05661_ _05633_ _05663_ VPWR VGND sg13g2_xor2_1
XFILLER_7_783 VPWR VGND sg13g2_decap_4
X_13309_ _04654_ _04645_ _04652_ VPWR VGND sg13g2_xnor2_1
X_17077_ _08231_ _08232_ _08233_ VPWR VGND sg13g2_nor2b_1
X_14289_ _05594_ _05564_ _05596_ VPWR VGND sg13g2_xor2_1
X_16028_ _07269_ _07248_ _07267_ VPWR VGND sg13g2_nand2_1
XFILLER_41_2 VPWR VGND sg13g2_fill_1
XFILLER_58_919 VPWR VGND sg13g2_fill_1
XFILLER_27_0 VPWR VGND sg13g2_decap_8
X_17979_ net41 VPWR _09109_ VGND net39 _09108_ sg13g2_o21ai_1
XFILLER_97_598 VPWR VGND sg13g2_decap_4
XFILLER_69_289 VPWR VGND sg13g2_fill_2
XFILLER_66_930 VPWR VGND sg13g2_decap_4
X_19718_ _10764_ u_LMS.w\[4\]\[6\] _10782_ VPWR VGND sg13g2_xor2_1
XFILLER_84_248 VPWR VGND sg13g2_decap_8
XFILLER_38_643 VPWR VGND sg13g2_fill_2
X_20990_ VGND VPWR _01630_ _01574_ u_LMS.w\[6\]\[14\] sg13g2_or2_1
XFILLER_66_963 VPWR VGND sg13g2_decap_8
XFILLER_65_462 VPWR VGND sg13g2_decap_4
XFILLER_1_70 VPWR VGND sg13g2_decap_8
X_19649_ _10713_ _10703_ _10712_ VPWR VGND sg13g2_nand2_1
XFILLER_92_270 VPWR VGND sg13g2_decap_4
XFILLER_111_27 VPWR VGND sg13g2_fill_1
X_22660_ coeff_force_packed\[32\] net465 _03065_ _00652_ VPWR VGND sg13g2_mux2_1
X_21611_ _02227_ VPWR _02228_ VGND _02226_ _02161_ sg13g2_o21ai_1
X_22591_ u_LMS.toggle net457 _00591_ VPWR VGND sg13g2_xor2_1
XFILLER_61_690 VPWR VGND sg13g2_fill_1
X_21542_ _02159_ u_LMS.w\[7\]\[17\] _02158_ VPWR VGND sg13g2_nand2b_1
X_21473_ _02088_ _02080_ _02090_ VPWR VGND sg13g2_xor2_1
XFILLER_119_431 VPWR VGND sg13g2_decap_4
X_23212_ net1459 VGND VPWR _00274_ u_FIR.w\[8\]\[1\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
X_20424_ net22 VPWR _01084_ VGND net20 _01083_ sg13g2_o21ai_1
XFILLER_107_637 VPWR VGND sg13g2_fill_2
XFILLER_119_497 VPWR VGND sg13g2_fill_2
X_23143_ net1574 VGND VPWR _00205_ u_FIR.sum\[8\]\[15\] clknet_leaf_44_clkA sg13g2_dfrbpq_1
X_20355_ _01017_ _01016_ _01018_ VPWR VGND sg13g2_nor2b_1
X_23074_ net1095 VGND VPWR _00136_ u_FIR.sum\[4\]\[17\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
XFILLER_1_926 VPWR VGND sg13g2_decap_8
X_20286_ VGND VPWR _00947_ _00948_ _00949_ _11122_ sg13g2_a21oi_1
XFILLER_103_832 VPWR VGND sg13g2_fill_1
X_22025_ _02613_ VPWR _02619_ VGND _02525_ _02610_ sg13g2_o21ai_1
XFILLER_88_587 VPWR VGND sg13g2_decap_4
XFILLER_102_375 VPWR VGND sg13g2_decap_8
XFILLER_48_429 VPWR VGND sg13g2_decap_8
XFILLER_75_248 VPWR VGND sg13g2_fill_2
X_11990_ net327 _03406_ _03407_ VPWR VGND sg13g2_nor2_1
XFILLER_75_259 VPWR VGND sg13g2_fill_2
XFILLER_21_1025 VPWR VGND sg13g2_fill_1
XFILLER_21_1047 VPWR VGND sg13g2_decap_8
X_22927_ VGND VPWR net325 _03192_ _00796_ _03191_ sg13g2_a21oi_1
XFILLER_83_270 VPWR VGND sg13g2_decap_8
X_13660_ _04988_ _04985_ _04989_ VPWR VGND sg13g2_nor2b_1
X_22858_ net950 VPWR _03152_ VGND u_p2s_output.reg_sh\[3\] net300 sg13g2_o21ai_1
X_12611_ _03977_ _03952_ _03979_ VPWR VGND sg13g2_xor2_1
XFILLER_45_98 VPWR VGND sg13g2_decap_8
X_21809_ _02403_ _02377_ _02402_ VPWR VGND sg13g2_nand2_1
X_13591_ net1033 VPWR _04922_ VGND net532 u_FIR.sum\[3\]\[5\] sg13g2_o21ai_1
X_22789_ VGND VPWR _07820_ net348 _00734_ _03112_ sg13g2_a21oi_1
X_15330_ _06570_ _06597_ _06598_ VPWR VGND sg13g2_nor2_1
XFILLER_40_841 VPWR VGND sg13g2_fill_2
X_12542_ _03902_ VPWR _03915_ VGND _03862_ _03903_ sg13g2_o21ai_1
X_15261_ net929 _06530_ _00166_ VPWR VGND sg13g2_nor2_1
XFILLER_40_896 VPWR VGND sg13g2_decap_4
X_12473_ VPWR _03849_ _03848_ VGND sg13g2_inv_1
X_17000_ _08156_ _08152_ _08155_ VPWR VGND sg13g2_nand2_1
X_14212_ _05519_ VPWR _05521_ VGND _05479_ _05481_ sg13g2_o21ai_1
X_15192_ _06463_ _06455_ _06462_ VPWR VGND sg13g2_xnor2_1
X_14143_ net878 net757 _05451_ _05453_ VPWR VGND sg13g2_a21o_1
XFILLER_125_467 VPWR VGND sg13g2_decap_8
X_18951_ _10038_ _10009_ _10010_ VPWR VGND sg13g2_xnor2_1
X_14074_ _05386_ _05385_ _05351_ VPWR VGND sg13g2_nand2b_1
XFILLER_112_139 VPWR VGND sg13g2_decap_4
X_17902_ _08993_ u_LMS.w\[1\]\[11\] _09035_ VPWR VGND sg13g2_xor2_1
X_13025_ VPWR _04378_ _04377_ VGND sg13g2_inv_1
X_18882_ VGND VPWR _09961_ _09968_ _09969_ _09960_ sg13g2_a21oi_1
Xfanout1020 net1021 net1020 VPWR VGND sg13g2_buf_1
Xfanout1031 net1032 net1031 VPWR VGND sg13g2_buf_1
XFILLER_94_502 VPWR VGND sg13g2_decap_8
Xfanout1042 net1043 net1042 VPWR VGND sg13g2_buf_1
X_17833_ _08966_ _08829_ _08962_ VPWR VGND sg13g2_nand2_1
XFILLER_20_7 VPWR VGND sg13g2_decap_4
XFILLER_121_673 VPWR VGND sg13g2_decap_4
XFILLER_0_992 VPWR VGND sg13g2_decap_8
XFILLER_94_546 VPWR VGND sg13g2_fill_1
X_17764_ _08897_ _08895_ _08896_ VPWR VGND sg13g2_nand2_1
X_14976_ _06256_ _06254_ _06255_ VPWR VGND sg13g2_xnor2_1
X_23093__1067 VPWR VGND net1066 sg13g2_tiehi
XFILLER_75_760 VPWR VGND sg13g2_decap_8
X_19503_ _10567_ net644 net257 VPWR VGND sg13g2_nand2_1
XFILLER_47_462 VPWR VGND sg13g2_fill_1
X_16715_ net1030 VPWR _07877_ VGND net529 net725 sg13g2_o21ai_1
X_13927_ VGND VPWR net536 _05246_ _00115_ _05247_ sg13g2_a21oi_1
X_17695_ VGND VPWR _08826_ _08827_ _08828_ _08825_ sg13g2_a21oi_1
XFILLER_34_101 VPWR VGND sg13g2_fill_1
XFILLER_35_646 VPWR VGND sg13g2_decap_4
X_19434_ _10467_ VPWR _10498_ VGND _10494_ _10496_ sg13g2_o21ai_1
X_16646_ net1034 VPWR _07825_ VGND net534 net749 sg13g2_o21ai_1
X_13858_ VGND VPWR net537 _05180_ _00112_ _05181_ sg13g2_a21oi_1
XFILLER_16_860 VPWR VGND sg13g2_decap_4
X_19365_ _10429_ _10415_ _10428_ VPWR VGND sg13g2_nand2_1
X_12809_ VGND VPWR _04152_ _04159_ _04171_ _04151_ sg13g2_a21oi_1
X_16577_ VGND VPWR u_LMS.w\[3\]\[12\] _07773_ _07775_ _07774_ sg13g2_a21oi_1
X_13789_ _05113_ _05080_ _05115_ VPWR VGND sg13g2_xor2_1
XFILLER_15_381 VPWR VGND sg13g2_fill_1
X_18316_ _09426_ net677 net200 VPWR VGND sg13g2_nand2_1
X_15528_ _06785_ _06779_ _06783_ VPWR VGND sg13g2_xnor2_1
X_19296_ _10360_ net647 net153 VPWR VGND sg13g2_nand2_1
X_18247_ _03263_ net176 _09357_ VPWR VGND sg13g2_nor2_1
XFILLER_31_896 VPWR VGND sg13g2_fill_2
X_15459_ VGND VPWR _06690_ _06720_ _06721_ _06712_ sg13g2_a21oi_1
X_18178_ VPWR _09288_ _09287_ VGND sg13g2_inv_1
XFILLER_116_401 VPWR VGND sg13g2_fill_2
XFILLER_128_272 VPWR VGND sg13g2_decap_8
X_17129_ _08284_ _08255_ _08285_ VPWR VGND sg13g2_xor2_1
Xrebuffer2203 _08203_ net2202 VPWR VGND sg13g2_buf_1
XFILLER_116_445 VPWR VGND sg13g2_fill_1
XFILLER_132_905 VPWR VGND sg13g2_decap_8
Xrebuffer2214 net2215 net2213 VPWR VGND sg13g2_buf_1
X_20140_ VGND VPWR _11169_ _11180_ _11181_ _11168_ sg13g2_a21oi_1
XFILLER_116_478 VPWR VGND sg13g2_fill_1
X_20071_ net638 net156 net635 _11112_ VPWR VGND net95 sg13g2_nand4_1
XFILLER_44_1025 VPWR VGND sg13g2_decap_4
XFILLER_112_662 VPWR VGND sg13g2_decap_4
XFILLER_85_502 VPWR VGND sg13g2_decap_4
XFILLER_100_868 VPWR VGND sg13g2_fill_1
X_23761_ net983 VGND VPWR _00008_ u_spi_slave.rx_shift\[3\] clknet_3_0__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_20973_ _01613_ _03304_ _01587_ VPWR VGND sg13g2_nand2_1
X_22712_ u_debug_unit.mon_w0_sync\[0\] net338 _03074_ VPWR VGND sg13g2_nor2_1
X_23302__1300 VPWR VGND net1299 sg13g2_tiehi
XFILLER_81_752 VPWR VGND sg13g2_fill_2
X_23692_ net1010 VGND VPWR _00754_ u_debug_unit.mon_w8_sync\[2\] clknet_leaf_17_clkA
+ sg13g2_dfrbpq_1
XFILLER_25_167 VPWR VGND sg13g2_decap_8
XFILLER_80_262 VPWR VGND sg13g2_fill_2
X_22643_ coeff_force_packed\[19\] net462 _03063_ _00637_ VPWR VGND sg13g2_mux2_1
XFILLER_80_273 VPWR VGND sg13g2_fill_2
XFILLER_90_1012 VPWR VGND sg13g2_fill_1
X_22574_ u_LMS.count\[25\] _03044_ u_LMS.count\[26\] _03047_ VPWR VGND sg13g2_nand3_1
X_21525_ _01791_ _01811_ _01821_ _02142_ VPWR VGND sg13g2_nor3_1
XFILLER_21_373 VPWR VGND sg13g2_decap_8
X_23335__1267 VPWR VGND net1266 sg13g2_tiehi
XFILLER_21_395 VPWR VGND sg13g2_fill_1
X_21456_ _02059_ _02072_ _02073_ VPWR VGND sg13g2_nor2_1
X_20407_ _01069_ _01066_ _01070_ VPWR VGND _01067_ sg13g2_nand3b_1
X_21387_ net2162 _02003_ _02004_ VPWR VGND sg13g2_and2_1
XFILLER_103_4 VPWR VGND sg13g2_fill_1
X_23126_ net1600 VGND VPWR _00188_ u_FIR.sum\[7\]\[12\] clknet_leaf_44_clkA sg13g2_dfrbpq_1
X_20338_ _01001_ net634 net264 VPWR VGND sg13g2_nand2_1
XFILLER_0_211 VPWR VGND sg13g2_decap_4
X_23057_ net1120 VGND VPWR _00119_ u_FIR.sum\[4\]\[0\] clknet_leaf_38_clkA sg13g2_dfrbpq_1
X_20269_ _00884_ _00883_ _00932_ VPWR VGND sg13g2_nor2b_1
XFILLER_49_705 VPWR VGND sg13g2_fill_2
XFILLER_131_960 VPWR VGND sg13g2_decap_4
X_22008_ VPWR _02602_ _02601_ VGND sg13g2_inv_1
XFILLER_0_277 VPWR VGND sg13g2_decap_8
XFILLER_49_738 VPWR VGND sg13g2_decap_8
XFILLER_49_749 VPWR VGND sg13g2_fill_2
XFILLER_130_492 VPWR VGND sg13g2_decap_8
X_14830_ net1007 VPWR _06117_ VGND net511 u_FIR.sum\[5\]\[11\] sg13g2_o21ai_1
XFILLER_5_1030 VPWR VGND sg13g2_decap_8
XFILLER_56_31 VPWR VGND sg13g2_fill_1
XFILLER_64_719 VPWR VGND sg13g2_decap_8
XFILLER_17_613 VPWR VGND sg13g2_fill_1
X_14761_ _06034_ VPWR _06049_ VGND _06030_ _06032_ sg13g2_o21ai_1
X_11973_ _03387_ _03389_ _03392_ VPWR VGND sg13g2_and2_1
XFILLER_17_635 VPWR VGND sg13g2_decap_4
XFILLER_44_421 VPWR VGND sg13g2_fill_1
X_16500_ net975 VPWR _07718_ VGND net479 net800 sg13g2_o21ai_1
XFILLER_16_123 VPWR VGND sg13g2_decap_4
X_13712_ net1033 VPWR _05040_ VGND net532 u_FIR.sum\[3\]\[8\] sg13g2_o21ai_1
X_17480_ net419 _03268_ net129 net99 _08613_ VPWR VGND sg13g2_nor4_1
X_14692_ _05982_ net836 net770 net823 net771 VPWR VGND sg13g2_a22oi_1
XFILLER_44_465 VPWR VGND sg13g2_decap_4
X_16431_ _07659_ VPWR _07661_ VGND _07643_ _07645_ sg13g2_o21ai_1
XFILLER_31_104 VPWR VGND sg13g2_fill_2
X_13643_ _04972_ _04971_ _04967_ VPWR VGND sg13g2_nand2b_1
XFILLER_60_969 VPWR VGND sg13g2_fill_2
X_19150_ VGND VPWR net2088 _10235_ _10237_ _10180_ sg13g2_a21oi_1
XFILLER_31_148 VPWR VGND sg13g2_decap_8
XFILLER_13_852 VPWR VGND sg13g2_decap_4
X_16362_ _07595_ u_FIR.sum\[7\]\[13\] net387 VPWR VGND sg13g2_xnor2_1
X_13574_ _04864_ _04866_ _04905_ VPWR VGND sg13g2_and2_1
XFILLER_12_351 VPWR VGND sg13g2_decap_8
X_18101_ _09209_ _09202_ _09211_ VPWR VGND sg13g2_xor2_1
XFILLER_13_885 VPWR VGND sg13g2_decap_8
X_15313_ _06581_ _06575_ _06580_ VPWR VGND sg13g2_xnor2_1
X_12525_ _03897_ _03892_ _03899_ VPWR VGND sg13g2_xor2_1
X_19081_ _10152_ _10167_ _10168_ VPWR VGND sg13g2_xor2_1
X_16293_ _07528_ _07522_ _07527_ VPWR VGND sg13g2_xnor2_1
X_18032_ _09151_ _09009_ _09011_ VPWR VGND sg13g2_xnor2_1
X_15244_ VPWR _06514_ _06513_ VGND sg13g2_inv_1
X_12456_ _03830_ _03767_ _03831_ _03832_ VPWR VGND sg13g2_a21o_1
X_15175_ _06445_ _06412_ _06447_ VPWR VGND sg13g2_xor2_1
X_12387_ _03765_ _03759_ _03763_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_231 VPWR VGND sg13g2_decap_8
XFILLER_99_616 VPWR VGND sg13g2_decap_8
X_14126_ _05437_ _05407_ _05436_ VPWR VGND sg13g2_xnor2_1
X_19983_ VPWR _11024_ _11023_ VGND sg13g2_inv_1
X_18934_ _10021_ _10020_ _10018_ VPWR VGND sg13g2_nand2b_1
X_14057_ VGND VPWR net493 _05368_ _00123_ _05369_ sg13g2_a21oi_1
X_13008_ VGND VPWR net545 _04362_ _00080_ _04363_ sg13g2_a21oi_1
XFILLER_39_204 VPWR VGND sg13g2_decap_4
X_18865_ _09951_ _09921_ _09952_ VPWR VGND sg13g2_xor2_1
X_17816_ _08948_ _08905_ _08949_ VPWR VGND sg13g2_xor2_1
X_18796_ _09883_ _09882_ _09880_ VPWR VGND sg13g2_nand2b_1
XFILLER_94_365 VPWR VGND sg13g2_decap_4
XFILLER_48_760 VPWR VGND sg13g2_fill_1
X_17747_ _08873_ VPWR _08880_ VGND _08869_ _08874_ sg13g2_o21ai_1
X_14959_ _06240_ u_FIR.sum\[4\]\[17\] net397 VPWR VGND sg13g2_xnor2_1
XFILLER_35_421 VPWR VGND sg13g2_decap_8
XFILLER_51_903 VPWR VGND sg13g2_fill_1
X_17678_ _08809_ _08808_ _08811_ VPWR VGND sg13g2_xor2_1
XFILLER_63_763 VPWR VGND sg13g2_fill_1
XFILLER_35_454 VPWR VGND sg13g2_decap_8
XFILLER_63_774 VPWR VGND sg13g2_decap_4
XFILLER_36_999 VPWR VGND sg13g2_decap_4
XFILLER_35_476 VPWR VGND sg13g2_fill_1
X_19417_ VGND VPWR _10446_ _10477_ _10481_ _10480_ sg13g2_a21oi_1
X_16629_ u_LMS.w\[5\]\[24\] _07812_ _07813_ VPWR VGND sg13g2_nor2_1
XFILLER_94_0 VPWR VGND sg13g2_decap_4
X_19348_ _10412_ _10411_ _10393_ VPWR VGND sg13g2_nand2b_1
XFILLER_50_468 VPWR VGND sg13g2_decap_4
X_19279_ _10344_ _10263_ _10343_ VPWR VGND sg13g2_nand2_1
X_21310_ _01927_ net596 net226 VPWR VGND sg13g2_nand2_1
XFILLER_50_1040 VPWR VGND sg13g2_fill_1
XFILLER_50_1051 VPWR VGND sg13g2_decap_8
X_22290_ VGND VPWR _02875_ _02876_ _00471_ net925 sg13g2_a21oi_1
XFILLER_11_1024 VPWR VGND sg13g2_decap_8
X_21241_ _01850_ _01857_ _01858_ VPWR VGND sg13g2_nor2b_1
XFILLER_7_91 VPWR VGND sg13g2_fill_2
XFILLER_132_702 VPWR VGND sg13g2_decap_8
XFILLER_104_404 VPWR VGND sg13g2_fill_1
X_21172_ net116 _01788_ _01789_ VPWR VGND sg13g2_nor2b_1
XFILLER_131_201 VPWR VGND sg13g2_decap_8
XFILLER_104_437 VPWR VGND sg13g2_decap_4
XFILLER_117_59 VPWR VGND sg13g2_decap_4
X_20123_ _11163_ _11158_ _11164_ VPWR VGND sg13g2_xor2_1
Xrebuffer2066 _07950_ net2065 VPWR VGND sg13g2_buf_1
Xfanout802 u_FIR.w\[0\]\[0\] net802 VPWR VGND sg13g2_buf_1
Xrebuffer2077 _01523_ net2076 VPWR VGND sg13g2_buf_1
Xfanout813 net815 net813 VPWR VGND sg13g2_buf_1
XFILLER_132_779 VPWR VGND sg13g2_decap_8
Xfanout824 u_FIR.x_reg\[6\] net824 VPWR VGND sg13g2_buf_1
Xrebuffer2088 _10229_ net2087 VPWR VGND sg13g2_buf_1
XFILLER_98_660 VPWR VGND sg13g2_decap_4
Xfanout835 net837 net835 VPWR VGND sg13g2_buf_1
Xrebuffer2099 _07901_ net2098 VPWR VGND sg13g2_buf_2
Xfanout846 net850 net846 VPWR VGND sg13g2_buf_1
X_20054_ _11092_ VPWR _11095_ VGND _03236_ net197 sg13g2_o21ai_1
Xfanout857 u_FIR.x_reg\[4\] net857 VPWR VGND sg13g2_buf_1
XFILLER_131_289 VPWR VGND sg13g2_decap_8
XFILLER_58_524 VPWR VGND sg13g2_decap_8
XFILLER_112_481 VPWR VGND sg13g2_decap_8
Xfanout868 net869 net868 VPWR VGND sg13g2_buf_1
XFILLER_112_492 VPWR VGND sg13g2_fill_1
Xfanout879 net880 net879 VPWR VGND sg13g2_buf_1
XFILLER_86_888 VPWR VGND sg13g2_fill_2
XFILLER_27_900 VPWR VGND sg13g2_fill_2
XFILLER_27_922 VPWR VGND sg13g2_decap_8
XFILLER_38_270 VPWR VGND sg13g2_fill_1
X_23744_ net988 VGND VPWR _00806_ spi_wdata\[3\] clknet_3_0__leaf_spi_sclk sg13g2_dfrbpq_1
X_20956_ _01596_ u_LMS.w\[6\]\[3\] _01595_ VPWR VGND sg13g2_nand2_1
XFILLER_54_774 VPWR VGND sg13g2_decap_8
XFILLER_41_413 VPWR VGND sg13g2_fill_2
X_23675_ net1017 VGND VPWR _00737_ u_debug_unit.mon_w5_sync\[6\] clknet_leaf_20_clkA
+ sg13g2_dfrbpq_1
XFILLER_13_115 VPWR VGND sg13g2_fill_1
X_20887_ _01429_ VPWR _01527_ VGND _01526_ _01524_ sg13g2_o21ai_1
X_22626_ coeff_force_packed\[6\] net461 _03061_ _00622_ VPWR VGND sg13g2_mux2_1
XFILLER_41_468 VPWR VGND sg13g2_fill_1
X_22557_ _03035_ _03036_ _00578_ VPWR VGND sg13g2_nor2_1
X_12310_ VGND VPWR _03690_ _03688_ _03659_ sg13g2_or2_1
XFILLER_21_192 VPWR VGND sg13g2_decap_8
X_21508_ _02122_ _02123_ _02125_ VPWR VGND sg13g2_nor2b_1
X_23066__1108 VPWR VGND net1107 sg13g2_tiehi
X_13290_ VGND VPWR _04596_ _04626_ _04635_ _04625_ sg13g2_a21oi_1
X_22488_ VGND VPWR net441 _03224_ _00552_ _02993_ sg13g2_a21oi_1
X_12241_ _03623_ net721 net907 VPWR VGND sg13g2_nand2_1
X_21439_ VGND VPWR _02054_ net2152 _02056_ _02053_ sg13g2_a21oi_1
XFILLER_5_358 VPWR VGND sg13g2_fill_2
XFILLER_107_253 VPWR VGND sg13g2_fill_2
XFILLER_108_776 VPWR VGND sg13g2_fill_1
X_12172_ net943 u_spi_slave.rx_shift\[2\] _00008_ VPWR VGND sg13g2_nor2b_1
X_23109_ net1627 VGND VPWR _00171_ u_FIR.sum\[6\]\[14\] clknet_leaf_42_clkA sg13g2_dfrbpq_1
X_16980_ _08133_ VPWR _08136_ VGND _03276_ net198 sg13g2_o21ai_1
XFILLER_96_619 VPWR VGND sg13g2_fill_1
XFILLER_122_256 VPWR VGND sg13g2_fill_2
XFILLER_3_49 VPWR VGND sg13g2_decap_8
X_15931_ _07153_ VPWR _07176_ VGND net273 _07151_ sg13g2_o21ai_1
XFILLER_103_470 VPWR VGND sg13g2_decap_8
XFILLER_76_332 VPWR VGND sg13g2_decap_8
X_18650_ net354 VPWR _09743_ VGND u_LMS.w\[2\]\[6\] net370 sg13g2_o21ai_1
X_15862_ _07110_ _07088_ _07108_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_877 VPWR VGND sg13g2_fill_2
XFILLER_77_899 VPWR VGND sg13g2_decap_8
X_17601_ net688 net235 net684 _08734_ VPWR VGND net205 sg13g2_nand4_1
X_14813_ _06099_ net269 _06100_ VPWR VGND sg13g2_xor2_1
X_18581_ _09688_ net33 net35 _09689_ VPWR VGND sg13g2_a21o_1
XFILLER_92_847 VPWR VGND sg13g2_decap_8
X_15793_ _07043_ _07034_ _07041_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_858 VPWR VGND sg13g2_fill_1
X_17532_ _08665_ _08651_ _08664_ VPWR VGND sg13g2_nand2_1
X_14744_ _06033_ _06029_ _06032_ VPWR VGND sg13g2_xnor2_1
XFILLER_83_51 VPWR VGND sg13g2_decap_8
X_11956_ VPWR _03377_ net817 VGND sg13g2_inv_1
XFILLER_44_240 VPWR VGND sg13g2_fill_2
XFILLER_44_251 VPWR VGND sg13g2_fill_2
XFILLER_32_413 VPWR VGND sg13g2_decap_8
X_17463_ VPWR _08596_ _08595_ VGND sg13g2_inv_1
X_14675_ net1005 VPWR _05966_ VGND net505 u_FIR.sum\[5\]\[7\] sg13g2_o21ai_1
X_11887_ VPWR _03308_ u_LMS.w\[6\]\[24\] VGND sg13g2_inv_1
XFILLER_32_435 VPWR VGND sg13g2_fill_2
X_19202_ VGND VPWR _10283_ _10284_ _00353_ net927 sg13g2_a21oi_1
X_16414_ _07627_ _07644_ _07645_ VPWR VGND sg13g2_and2_1
X_13626_ _04956_ _04923_ _04954_ VPWR VGND sg13g2_xnor2_1
X_17394_ _08540_ _08482_ _08484_ VPWR VGND sg13g2_xnor2_1
XFILLER_41_980 VPWR VGND sg13g2_fill_1
X_19133_ VGND VPWR _10217_ _10218_ _10220_ _10192_ sg13g2_a21oi_1
X_16345_ net1003 VPWR _07579_ VGND net496 u_FIR.sum\[8\]\[12\] sg13g2_o21ai_1
X_13557_ _04875_ VPWR _04888_ VGND _04870_ _04873_ sg13g2_o21ai_1
XFILLER_34_1057 VPWR VGND sg13g2_decap_4
XFILLER_9_675 VPWR VGND sg13g2_decap_4
X_19064_ _09877_ VPWR _10151_ VGND _09875_ _10149_ sg13g2_o21ai_1
X_12508_ _03883_ _03857_ _03882_ VPWR VGND sg13g2_nand2_1
XFILLER_121_1038 VPWR VGND sg13g2_decap_8
X_16276_ _07475_ _07477_ _07511_ _07512_ VPWR VGND sg13g2_nor3_1
X_13488_ _04822_ net752 net892 VPWR VGND sg13g2_nand2_1
XFILLER_8_163 VPWR VGND sg13g2_fill_2
X_18015_ net40 VPWR _09138_ VGND net38 _09137_ sg13g2_o21ai_1
X_15227_ _03370_ net861 _06497_ VPWR VGND sg13g2_nor2_1
X_12439_ _03816_ _03787_ _03815_ VPWR VGND sg13g2_nand2_1
X_15158_ _06424_ _06429_ _06430_ VPWR VGND sg13g2_nor2b_1
XFILLER_114_735 VPWR VGND sg13g2_decap_4
X_14109_ _05420_ _05378_ _05418_ VPWR VGND sg13g2_xnor2_1
X_19966_ _11007_ net622 net94 VPWR VGND sg13g2_nand2_1
Xfanout109 net109 net1647 VPWR VGND sg13g2_buf_4
X_15089_ _06363_ _06354_ _06361_ VPWR VGND sg13g2_xnor2_1
X_18917_ _10004_ _10000_ _10002_ VPWR VGND sg13g2_xnor2_1
X_19897_ _10938_ net173 net624 net179 net622 VPWR VGND sg13g2_a22oi_1
XFILLER_110_941 VPWR VGND sg13g2_decap_8
XFILLER_80_1055 VPWR VGND sg13g2_decap_4
XFILLER_79_192 VPWR VGND sg13g2_decap_8
X_18848_ _09935_ _09931_ _09934_ VPWR VGND sg13g2_nand2_1
XFILLER_67_354 VPWR VGND sg13g2_decap_8
XFILLER_28_708 VPWR VGND sg13g2_decap_8
XFILLER_95_674 VPWR VGND sg13g2_decap_8
XFILLER_67_365 VPWR VGND sg13g2_fill_2
XFILLER_82_302 VPWR VGND sg13g2_fill_1
XFILLER_82_313 VPWR VGND sg13g2_fill_1
XFILLER_67_387 VPWR VGND sg13g2_fill_2
XFILLER_27_218 VPWR VGND sg13g2_decap_4
X_18779_ _09866_ net119 _09864_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_195 VPWR VGND sg13g2_decap_4
XFILLER_83_869 VPWR VGND sg13g2_decap_4
X_20810_ _01441_ _01442_ _01450_ VPWR VGND sg13g2_nor2b_1
XFILLER_70_508 VPWR VGND sg13g2_decap_4
X_21790_ net115 _02383_ _02384_ VPWR VGND sg13g2_nor2b_1
XFILLER_36_763 VPWR VGND sg13g2_decap_4
XFILLER_23_413 VPWR VGND sg13g2_fill_1
X_20741_ _01379_ _01380_ _01381_ VPWR VGND sg13g2_nor2_1
XFILLER_50_210 VPWR VGND sg13g2_decap_8
XFILLER_24_958 VPWR VGND sg13g2_decap_4
XFILLER_90_390 VPWR VGND sg13g2_decap_4
X_23460_ net1551 VGND VPWR _00522_ u_LMS.x_r\[4\]\[3\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
X_20672_ _03232_ net102 _01312_ VPWR VGND sg13g2_nor2_1
X_22411_ net948 VPWR _02955_ VGND net433 net660 sg13g2_o21ai_1
XFILLER_32_980 VPWR VGND sg13g2_decap_8
XFILLER_32_991 VPWR VGND sg13g2_fill_2
X_23391_ net1175 VGND VPWR _00453_ u_LMS.w\[7\]\[24\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
X_22342_ VGND VPWR net47 _02916_ _02917_ net6 sg13g2_a21oi_1
XFILLER_128_14 VPWR VGND sg13g2_decap_8
X_22273_ net9 VPWR _02863_ VGND _02848_ _02862_ sg13g2_o21ai_1
XFILLER_3_807 VPWR VGND sg13g2_fill_2
X_21224_ _03221_ net100 _01841_ VPWR VGND sg13g2_nor2_2
X_23062__1114 VPWR VGND net1113 sg13g2_tiehi
XFILLER_117_584 VPWR VGND sg13g2_fill_2
XFILLER_132_543 VPWR VGND sg13g2_decap_8
XFILLER_104_245 VPWR VGND sg13g2_decap_8
X_21155_ net110 _01770_ net591 _01772_ VPWR VGND sg13g2_nand3_1
Xfanout610 net611 net610 VPWR VGND sg13g2_buf_1
XFILLER_104_267 VPWR VGND sg13g2_fill_2
Xfanout621 u_LMS.x_r\[6\]\[0\] net621 VPWR VGND sg13g2_buf_1
XFILLER_99_980 VPWR VGND sg13g2_fill_2
X_20106_ _11147_ _11129_ _11130_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_118 VPWR VGND sg13g2_decap_4
XFILLER_120_727 VPWR VGND sg13g2_fill_1
Xfanout632 u_LMS.x_r\[5\]\[2\] net632 VPWR VGND sg13g2_buf_1
X_21086_ net361 VPWR _01713_ VGND u_LMS.w\[6\]\[2\] net378 sg13g2_o21ai_1
Xfanout643 net644 net643 VPWR VGND sg13g2_buf_1
Xfanout654 u_LMS.x_r\[3\]\[6\] net654 VPWR VGND sg13g2_buf_1
Xfanout665 net666 net665 VPWR VGND sg13g2_buf_1
Xfanout676 u_LMS.x_r\[2\]\[3\] net676 VPWR VGND sg13g2_buf_1
X_20037_ _11078_ _11076_ _11077_ VPWR VGND sg13g2_nand2_1
XFILLER_19_708 VPWR VGND sg13g2_fill_2
Xfanout687 net688 net687 VPWR VGND sg13g2_buf_1
Xfanout698 u_LMS.x_r\[1\]\[1\] net698 VPWR VGND sg13g2_buf_1
XFILLER_100_462 VPWR VGND sg13g2_fill_1
XFILLER_101_985 VPWR VGND sg13g2_fill_2
XFILLER_74_825 VPWR VGND sg13g2_decap_8
XFILLER_101_996 VPWR VGND sg13g2_fill_2
XFILLER_46_538 VPWR VGND sg13g2_decap_4
XFILLER_73_335 VPWR VGND sg13g2_fill_1
X_11810_ VPWR _03231_ net614 VGND sg13g2_inv_1
XFILLER_2_1055 VPWR VGND sg13g2_decap_4
X_12790_ _04105_ VPWR _04153_ VGND _04102_ _04106_ sg13g2_o21ai_1
XFILLER_73_368 VPWR VGND sg13g2_decap_8
X_21988_ _02582_ _02577_ _02580_ VPWR VGND sg13g2_xnor2_1
XFILLER_42_700 VPWR VGND sg13g2_decap_8
X_20939_ _01579_ _01402_ _01527_ VPWR VGND sg13g2_xnor2_1
X_23727_ net1326 VGND VPWR _00789_ u_s2p_input.reg_cnt\[1\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
XFILLER_53_54 VPWR VGND sg13g2_decap_4
XFILLER_18_1019 VPWR VGND sg13g2_fill_1
XFILLER_42_766 VPWR VGND sg13g2_fill_2
X_14460_ _05760_ _05751_ _05759_ VPWR VGND sg13g2_xnor2_1
X_23658_ net985 VGND VPWR _00720_ u_debug_unit.mon_w3_sync\[3\] clknet_leaf_53_clkA
+ sg13g2_dfrbpq_1
XFILLER_30_928 VPWR VGND sg13g2_fill_2
X_13411_ _04753_ _04723_ _04751_ VPWR VGND sg13g2_xnor2_1
X_22609_ net458 debug_load_bus\[7\] _03059_ _00607_ VPWR VGND sg13g2_mux2_1
X_14391_ _05689_ _05691_ _05694_ VPWR VGND sg13g2_nor2_1
X_23589_ net963 VGND VPWR _00651_ coeff_force_packed\[31\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
XFILLER_128_827 VPWR VGND sg13g2_fill_1
X_16130_ _03375_ net889 _07369_ VPWR VGND sg13g2_nor2_1
X_13342_ _04686_ _04680_ _04685_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_634 VPWR VGND sg13g2_fill_2
Xclkbuf_leaf_21_clkA clknet_4_14_0_clkA clknet_leaf_21_clkA VPWR VGND sg13g2_buf_8
X_16061_ _07300_ _07258_ _07302_ VPWR VGND sg13g2_xor2_1
X_13273_ _04619_ u_FIR.sum\[1\]\[9\] net405 VPWR VGND sg13g2_xnor2_1
XFILLER_6_678 VPWR VGND sg13g2_fill_1
X_15012_ net859 u_FIR.sum\[5\]\[3\] net782 _06288_ VPWR VGND sg13g2_nand3_1
X_12224_ VGND VPWR net531 _03606_ _00052_ _03607_ sg13g2_a21oi_1
XFILLER_5_166 VPWR VGND sg13g2_decap_8
XFILLER_5_177 VPWR VGND sg13g2_fill_1
XFILLER_5_199 VPWR VGND sg13g2_decap_8
X_19820_ _10851_ VPWR _10878_ VGND _10855_ _10877_ sg13g2_o21ai_1
X_12155_ _03564_ net285 net556 net296 coeff_force_packed\[7\] VPWR VGND sg13g2_a22oi_1
XFILLER_97_917 VPWR VGND sg13g2_fill_1
XFILLER_2_851 VPWR VGND sg13g2_decap_4
XFILLER_68_107 VPWR VGND sg13g2_fill_1
XFILLER_2_873 VPWR VGND sg13g2_decap_8
X_19751_ net644 net157 net642 _10815_ VPWR VGND sg13g2_nand3_1
X_16963_ _08110_ VPWR _08119_ VGND _08111_ _08118_ sg13g2_o21ai_1
X_12086_ _03492_ _03493_ _03485_ _03499_ VPWR VGND _03498_ sg13g2_nand4_1
XFILLER_1_372 VPWR VGND sg13g2_decap_8
XFILLER_1_383 VPWR VGND sg13g2_fill_1
XFILLER_110_237 VPWR VGND sg13g2_decap_8
X_18702_ net423 _03252_ net128 net98 _09789_ VPWR VGND sg13g2_nor4_1
X_15914_ _07147_ _07159_ _07160_ VPWR VGND sg13g2_nor2_1
X_19682_ _10746_ _10731_ _10732_ VPWR VGND sg13g2_xnor2_1
X_16894_ _08050_ net703 net155 VPWR VGND sg13g2_nand2_1
X_18633_ VGND VPWR net56 _09729_ _09730_ net32 sg13g2_a21oi_1
X_15845_ _07093_ _07092_ _07091_ VPWR VGND sg13g2_nand2b_1
XFILLER_65_869 VPWR VGND sg13g2_decap_8
X_18564_ _09674_ _09672_ _09673_ VPWR VGND sg13g2_nand2_1
XFILLER_91_154 VPWR VGND sg13g2_fill_1
X_15776_ net834 _07025_ net784 _07026_ VPWR VGND sg13g2_nand3_1
XFILLER_18_774 VPWR VGND sg13g2_fill_1
X_12988_ _04345_ net284 _04344_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_699 VPWR VGND sg13g2_decap_8
XFILLER_45_560 VPWR VGND sg13g2_decap_4
XFILLER_91_176 VPWR VGND sg13g2_fill_2
XFILLER_45_571 VPWR VGND sg13g2_decap_8
X_23330__1272 VPWR VGND net1271 sg13g2_tiehi
X_17515_ _08648_ _08647_ _08629_ VPWR VGND sg13g2_nand2b_1
XFILLER_17_273 VPWR VGND sg13g2_decap_4
X_14727_ _06014_ _06015_ _06016_ VPWR VGND sg13g2_and2_1
XFILLER_33_733 VPWR VGND sg13g2_decap_8
X_18495_ _09605_ u_LMS.w\[2\]\[9\] _09604_ VPWR VGND sg13g2_nand2_1
X_11939_ VPWR _03360_ u_FIR.w\[7\]\[6\] VGND sg13g2_inv_1
X_17446_ _08580_ _08456_ _08458_ VPWR VGND sg13g2_xnor2_1
X_14658_ _05949_ _05931_ _05947_ VPWR VGND sg13g2_xnor2_1
XFILLER_14_991 VPWR VGND sg13g2_decap_4
X_13609_ _04939_ _04932_ _04938_ VPWR VGND sg13g2_nand2_1
X_17377_ net2194 VPWR _08526_ VGND _03355_ _08395_ sg13g2_o21ai_1
XFILLER_119_805 VPWR VGND sg13g2_fill_2
X_14589_ _05882_ _05854_ _05881_ VPWR VGND sg13g2_xnor2_1
X_19116_ u_LMS.w\[3\]\[2\] net253 net668 _10203_ VPWR VGND sg13g2_nand3_1
X_16328_ VPWR _07562_ _07561_ VGND sg13g2_inv_1
XFILLER_118_348 VPWR VGND sg13g2_fill_1
X_19047_ _10085_ _10084_ _10134_ VPWR VGND sg13g2_xor2_1
X_16259_ _07495_ _07487_ _07494_ VPWR VGND sg13g2_nand2_1
XFILLER_57_0 VPWR VGND sg13g2_fill_2
X_23222__1442 VPWR VGND net1441 sg13g2_tiehi
XFILLER_102_727 VPWR VGND sg13g2_fill_2
XFILLER_59_118 VPWR VGND sg13g2_decap_4
XFILLER_4_70 VPWR VGND sg13g2_decap_8
X_19949_ _10990_ net626 net154 VPWR VGND sg13g2_nand2_1
XFILLER_87_449 VPWR VGND sg13g2_fill_2
X_22960_ _07704_ VPWR _00817_ VGND _03284_ net524 sg13g2_o21ai_1
X_23229__1429 VPWR VGND net1428 sg13g2_tiehi
XFILLER_68_663 VPWR VGND sg13g2_decap_8
XFILLER_110_760 VPWR VGND sg13g2_decap_8
XFILLER_96_994 VPWR VGND sg13g2_fill_2
X_21911_ _02497_ VPWR _02505_ VGND _02503_ _02504_ sg13g2_o21ai_1
XFILLER_28_527 VPWR VGND sg13g2_decap_4
X_22891_ _03174_ net297 u_FIR.x\[2\] net298 u_s2p_input.reg_sh\[1\] VPWR VGND sg13g2_a22oi_1
X_23478__1491 VPWR VGND net1490 sg13g2_tiehi
X_21842_ _02436_ net581 net108 VPWR VGND sg13g2_nand2_1
XFILLER_83_677 VPWR VGND sg13g2_fill_1
XFILLER_82_187 VPWR VGND sg13g2_decap_4
X_21773_ net110 _02365_ net572 _02367_ VPWR VGND sg13g2_nand3_1
X_20724_ _01364_ _01361_ _01362_ VPWR VGND sg13g2_xnor2_1
X_23512_ net1368 VGND VPWR _00574_ u_LMS.count\[15\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
XFILLER_23_24 VPWR VGND sg13g2_fill_2
X_23443_ net1602 VGND VPWR _00505_ u_LMS.x_r\[2\]\[2\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
XFILLER_23_35 VPWR VGND sg13g2_fill_2
XFILLER_17_1041 VPWR VGND sg13g2_decap_8
X_20655_ _01293_ net117 _01295_ VPWR VGND sg13g2_xor2_1
Xclkbuf_leaf_44_clkA clknet_4_5_0_clkA clknet_leaf_44_clkA VPWR VGND sg13g2_buf_8
XFILLER_11_449 VPWR VGND sg13g2_fill_2
X_23374_ net1226 VGND VPWR _00436_ u_LMS.w\[6\]\[7\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
X_20586_ VGND VPWR _01226_ _01206_ _01204_ sg13g2_or2_1
X_22325_ _02904_ _02788_ _02789_ VPWR VGND sg13g2_xnor2_1
XFILLER_3_604 VPWR VGND sg13g2_decap_8
XFILLER_3_615 VPWR VGND sg13g2_fill_2
X_22256_ _02850_ net308 u_LMS.w\[8\]\[12\] coeff_force_packed\[56\] net561 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_105_543 VPWR VGND sg13g2_fill_1
X_21207_ _01823_ _01791_ _01824_ VPWR VGND sg13g2_xor2_1
XFILLER_79_906 VPWR VGND sg13g2_fill_1
XFILLER_2_147 VPWR VGND sg13g2_decap_8
XFILLER_105_565 VPWR VGND sg13g2_decap_4
X_22187_ _02781_ _02658_ _02689_ VPWR VGND sg13g2_xnor2_1
XFILLER_79_939 VPWR VGND sg13g2_decap_8
XFILLER_78_416 VPWR VGND sg13g2_decap_8
X_21138_ _01755_ net600 net150 VPWR VGND sg13g2_nand2_1
XFILLER_132_384 VPWR VGND sg13g2_decap_8
X_23415__1104 VPWR VGND net1103 sg13g2_tiehi
Xfanout440 net457 net440 VPWR VGND sg13g2_buf_1
Xfanout451 net457 net451 VPWR VGND sg13g2_buf_1
Xfanout462 spi_wdata\[5\] net462 VPWR VGND sg13g2_buf_1
X_21069_ VGND VPWR _01685_ _01698_ _00427_ _01699_ sg13g2_a21oi_1
Xfanout473 spi_wdata\[0\] net473 VPWR VGND sg13g2_buf_1
X_13960_ _05277_ VPWR _05279_ VGND _05261_ _05263_ sg13g2_o21ai_1
XFILLER_47_803 VPWR VGND sg13g2_fill_2
Xfanout484 net486 net484 VPWR VGND sg13g2_buf_1
Xfanout495 net496 net495 VPWR VGND sg13g2_buf_1
X_12911_ _04264_ _04270_ _04271_ VPWR VGND sg13g2_nor2b_1
XFILLER_0_28 VPWR VGND sg13g2_decap_8
X_13891_ VGND VPWR _05186_ _05193_ _05213_ _05200_ sg13g2_a21oi_1
XFILLER_73_121 VPWR VGND sg13g2_decap_8
XFILLER_47_869 VPWR VGND sg13g2_fill_2
X_15630_ _06884_ _06841_ _06882_ VPWR VGND sg13g2_xnor2_1
X_12842_ VPWR _04204_ _04203_ VGND sg13g2_inv_1
XFILLER_64_42 VPWR VGND sg13g2_fill_2
XFILLER_15_711 VPWR VGND sg13g2_decap_8
X_15561_ _06817_ _06789_ _06816_ VPWR VGND sg13g2_nand2_1
X_12773_ _04136_ net731 net856 VPWR VGND sg13g2_nand2_1
XFILLER_61_349 VPWR VGND sg13g2_decap_8
XFILLER_42_530 VPWR VGND sg13g2_decap_4
X_17300_ VGND VPWR _08453_ _08454_ _08456_ _08418_ sg13g2_a21oi_1
X_14512_ _05795_ _05806_ _05807_ VPWR VGND sg13g2_nor2_1
X_18280_ _09390_ net673 net254 VPWR VGND sg13g2_nand2_1
X_15492_ _06749_ _06750_ _06751_ VPWR VGND sg13g2_nor2_1
X_17231_ _08050_ _08386_ _08032_ _08387_ VPWR VGND sg13g2_nand3_1
XFILLER_120_81 VPWR VGND sg13g2_fill_1
X_14443_ _05744_ _05742_ _05743_ VPWR VGND sg13g2_nand2_1
XFILLER_30_747 VPWR VGND sg13g2_decap_8
Xfanout80 net81 net80 VPWR VGND sg13g2_buf_2
Xfanout91 net92 net91 VPWR VGND sg13g2_buf_2
X_17162_ _08316_ _08317_ _08318_ VPWR VGND sg13g2_nor2_1
X_14374_ _05678_ _05669_ _05677_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_932 VPWR VGND sg13g2_decap_8
XFILLER_7_943 VPWR VGND sg13g2_fill_1
X_16113_ _07353_ _07344_ _07352_ VPWR VGND sg13g2_nand2_1
X_13325_ _04668_ _04635_ _04670_ VPWR VGND sg13g2_xor2_1
X_17093_ _08248_ _08237_ _08249_ VPWR VGND sg13g2_xor2_1
XFILLER_7_998 VPWR VGND sg13g2_decap_4
XFILLER_127_178 VPWR VGND sg13g2_decap_4
X_16044_ VGND VPWR _07285_ _07284_ _07283_ sg13g2_or2_1
XFILLER_50_7 VPWR VGND sg13g2_decap_4
X_13256_ net856 _04601_ net739 _04602_ VPWR VGND sg13g2_nand3_1
X_12207_ net1031 VPWR _03593_ VGND net527 u_FIR.sum\[0\]\[0\] sg13g2_o21ai_1
X_13187_ _04535_ _04528_ _04533_ VPWR VGND sg13g2_xnor2_1
X_23348__1254 VPWR VGND net1253 sg13g2_tiehi
X_19803_ net962 _10864_ _00374_ VPWR VGND sg13g2_and2_1
X_12138_ VPWR VGND coeff_force_packed\[43\] _03540_ net291 debug_load_bus\[1\] _03548_
+ net294 sg13g2_a221oi_1
X_17995_ net557 coeff_force_packed\[13\] _09122_ VPWR VGND sg13g2_and2_1
XFILLER_96_257 VPWR VGND sg13g2_decap_8
X_19734_ _10756_ VPWR _10798_ VGND _10795_ _10796_ sg13g2_o21ai_1
X_16946_ _08102_ _07910_ _07924_ VPWR VGND sg13g2_xnor2_1
X_12069_ _00019_ VPWR _03483_ VGND u_spi_slave.tx_shift\[12\] net328 sg13g2_o21ai_1
XFILLER_84_419 VPWR VGND sg13g2_decap_8
XFILLER_78_983 VPWR VGND sg13g2_decap_4
XFILLER_65_611 VPWR VGND sg13g2_fill_1
XFILLER_38_836 VPWR VGND sg13g2_fill_2
X_19665_ VGND VPWR _10563_ _10729_ _10727_ _10564_ sg13g2_a21oi_2
XFILLER_65_633 VPWR VGND sg13g2_fill_1
X_16877_ net418 _03276_ net112 net95 _08033_ VPWR VGND sg13g2_nor4_1
XFILLER_49_195 VPWR VGND sg13g2_fill_1
XFILLER_93_964 VPWR VGND sg13g2_fill_2
X_18616_ VGND VPWR _09715_ _09716_ _00335_ net919 sg13g2_a21oi_1
XFILLER_93_975 VPWR VGND sg13g2_decap_8
X_15828_ _07055_ _07076_ _07077_ VPWR VGND sg13g2_nor2b_1
X_19596_ _10659_ _10657_ _10660_ VPWR VGND sg13g2_xor2_1
X_18547_ _09657_ u_LMS.w\[2\]\[17\] _09587_ VPWR VGND sg13g2_xnor2_1
X_15759_ _07008_ _06976_ _07010_ VPWR VGND sg13g2_xor2_1
XFILLER_52_349 VPWR VGND sg13g2_fill_2
X_18478_ _09588_ u_LMS.w\[2\]\[17\] _09587_ VPWR VGND sg13g2_nand2_1
XFILLER_61_883 VPWR VGND sg13g2_fill_1
XFILLER_127_1044 VPWR VGND sg13g2_decap_8
X_17429_ _08566_ _08567_ _00297_ VPWR VGND sg13g2_nor2_1
X_20440_ VGND VPWR net2126 net2124 _01096_ _01048_ sg13g2_a21oi_1
XFILLER_118_123 VPWR VGND sg13g2_decap_4
X_20371_ VGND VPWR net1667 _01032_ _01034_ _00986_ sg13g2_a21oi_1
X_22110_ VGND VPWR _02702_ _02703_ _02704_ _02633_ sg13g2_a21oi_1
Xclkload50 clkload50/Y clknet_leaf_27_clkA VPWR VGND sg13g2_inv_2
X_23090_ net1071 VGND VPWR _00152_ u_FIR.sum\[5\]\[14\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
X_22041_ net586 net584 net185 _02635_ VPWR VGND net221 sg13g2_nand4_1
XFILLER_115_863 VPWR VGND sg13g2_fill_1
XFILLER_87_268 VPWR VGND sg13g2_fill_2
XFILLER_130_877 VPWR VGND sg13g2_fill_2
XFILLER_56_600 VPWR VGND sg13g2_fill_1
XFILLER_56_611 VPWR VGND sg13g2_decap_8
X_22943_ spi_addr\[6\] net324 _03203_ VPWR VGND sg13g2_nor2_1
XFILLER_28_357 VPWR VGND sg13g2_fill_1
X_22874_ u_p2s_output.reg_cnt\[0\] net552 _03164_ VPWR VGND sg13g2_and2_1
XFILLER_44_839 VPWR VGND sg13g2_decap_4
XFILLER_43_316 VPWR VGND sg13g2_decap_4
XFILLER_55_198 VPWR VGND sg13g2_fill_2
X_21825_ _02419_ _02404_ _02417_ VPWR VGND sg13g2_xnor2_1
XFILLER_93_1054 VPWR VGND sg13g2_decap_8
XFILLER_52_861 VPWR VGND sg13g2_fill_2
X_21756_ _02350_ net580 net150 VPWR VGND sg13g2_nand2_1
XFILLER_51_371 VPWR VGND sg13g2_decap_4
X_20707_ _01345_ _01344_ _01347_ VPWR VGND sg13g2_xor2_1
X_21687_ net12 VPWR _02294_ VGND net11 _02293_ sg13g2_o21ai_1
Xclkload0 clknet_4_1_0_clkA clkload0/X VPWR VGND sg13g2_buf_8
X_20638_ _01278_ _01241_ _01243_ VPWR VGND sg13g2_xnor2_1
X_23426_ net1070 VGND VPWR _00488_ u_LMS.x_r\[0\]\[1\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
XFILLER_50_11 VPWR VGND sg13g2_fill_2
XFILLER_109_112 VPWR VGND sg13g2_fill_2
XFILLER_109_123 VPWR VGND sg13g2_fill_1
X_23357_ net1244 VGND VPWR _00419_ u_LMS.w\[6\]\[13\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
X_20569_ _01209_ _01202_ _01208_ VPWR VGND sg13g2_nand2_1
XFILLER_109_167 VPWR VGND sg13g2_decap_4
X_22308_ _02890_ _02839_ _02891_ VPWR VGND sg13g2_xor2_1
X_13110_ net842 u_FIR.sum\[1\]\[5\] net747 _04460_ VPWR VGND sg13g2_nand3_1
X_14090_ _05367_ _05401_ _05365_ _05402_ VPWR VGND sg13g2_nand3_1
XFILLER_3_412 VPWR VGND sg13g2_fill_1
XFILLER_106_830 VPWR VGND sg13g2_decap_8
X_23288_ net1318 VGND VPWR _00350_ u_LMS.w\[3\]\[13\] clknet_leaf_52_clkA sg13g2_dfrbpq_1
X_13041_ net867 net747 u_FIR.sum\[1\]\[3\] _04393_ VPWR VGND sg13g2_a21o_1
X_22239_ _02832_ VPWR _02833_ VGND _02753_ _02827_ sg13g2_o21ai_1
XFILLER_59_42 VPWR VGND sg13g2_fill_2
XFILLER_121_833 VPWR VGND sg13g2_decap_8
XFILLER_121_844 VPWR VGND sg13g2_fill_2
XFILLER_132_192 VPWR VGND sg13g2_decap_8
XFILLER_120_332 VPWR VGND sg13g2_decap_8
X_16800_ _07956_ net2118 _07951_ VPWR VGND sg13g2_nand2b_1
X_17780_ _08913_ _08909_ _08911_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_728 VPWR VGND sg13g2_fill_1
XFILLER_120_365 VPWR VGND sg13g2_decap_8
X_14992_ _06270_ _06268_ _06269_ VPWR VGND sg13g2_xnor2_1
Xfanout270 net271 net270 VPWR VGND sg13g2_buf_1
Xfanout281 _05134_ net281 VPWR VGND sg13g2_buf_1
Xfanout292 _03430_ net292 VPWR VGND sg13g2_buf_1
X_16731_ u_FIR.sum\[8\]\[14\] u_FIR.sum\[8\]\[13\] u_FIR.sum\[8\]\[12\] _07887_ VPWR
+ VGND sg13g2_nor3_1
X_13943_ _05248_ _05262_ _05263_ VPWR VGND sg13g2_nor2_1
XFILLER_46_110 VPWR VGND sg13g2_decap_4
XFILLER_47_655 VPWR VGND sg13g2_fill_1
X_19450_ _10506_ _10505_ _10514_ VPWR VGND sg13g2_xor2_1
XFILLER_74_452 VPWR VGND sg13g2_decap_4
X_16662_ VGND VPWR net530 _07836_ _00260_ _07837_ sg13g2_a21oi_1
X_13874_ _05196_ net280 _05197_ VPWR VGND sg13g2_xor2_1
X_18401_ net200 net679 _09482_ _09511_ VPWR VGND sg13g2_a21o_1
X_15613_ _06867_ _06825_ _06866_ VPWR VGND sg13g2_xnor2_1
X_19381_ _10445_ _10444_ _10443_ VPWR VGND sg13g2_nand2b_1
X_12825_ _04181_ _04186_ _04187_ VPWR VGND sg13g2_nor2b_1
X_16593_ net997 VPWR _07786_ VGND net493 net768 sg13g2_o21ai_1
X_18332_ _09440_ _09439_ _09442_ VPWR VGND sg13g2_xor2_1
X_15544_ _06798_ _06780_ _06800_ VPWR VGND sg13g2_xor2_1
X_12756_ _04120_ _04113_ _04119_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_73 VPWR VGND sg13g2_decap_8
X_18263_ _09330_ _09328_ _09373_ VPWR VGND sg13g2_xor2_1
X_15475_ _06734_ _06735_ _06736_ VPWR VGND sg13g2_nor2_1
XFILLER_129_900 VPWR VGND sg13g2_fill_1
X_12687_ VGND VPWR _04048_ _04049_ _04052_ _04047_ sg13g2_a21oi_1
X_17214_ _08354_ _08364_ _08369_ _08370_ VPWR VGND sg13g2_nor3_2
X_14426_ _05726_ _05725_ _05728_ VPWR VGND sg13g2_xor2_1
XFILLER_30_577 VPWR VGND sg13g2_decap_8
X_18194_ _09304_ net676 net127 VPWR VGND sg13g2_nand2_1
XFILLER_129_966 VPWR VGND sg13g2_fill_2
X_17145_ _08299_ _08300_ _08301_ VPWR VGND sg13g2_nor2b_1
X_23254__1386 VPWR VGND net1385 sg13g2_tiehi
X_14357_ _05633_ _05661_ _05662_ VPWR VGND sg13g2_nor2b_1
X_13308_ _04653_ _04645_ _04652_ VPWR VGND sg13g2_nand2_1
X_17076_ _08229_ _08208_ _08232_ VPWR VGND sg13g2_xor2_1
X_14288_ _05564_ _05594_ _05595_ VPWR VGND sg13g2_nor2_1
X_16027_ _07248_ _07267_ _07268_ VPWR VGND sg13g2_nor2_1
X_13239_ _04586_ _04557_ _04585_ VPWR VGND sg13g2_nand2b_1
XFILLER_97_511 VPWR VGND sg13g2_decap_8
XFILLER_124_682 VPWR VGND sg13g2_fill_2
XFILLER_97_522 VPWR VGND sg13g2_decap_8
X_23107__1046 VPWR VGND net1045 sg13g2_tiehi
XFILLER_69_224 VPWR VGND sg13g2_fill_1
X_17978_ _09108_ _09044_ _09107_ VPWR VGND sg13g2_xnor2_1
XFILLER_111_387 VPWR VGND sg13g2_decap_8
XFILLER_38_622 VPWR VGND sg13g2_fill_2
X_19717_ u_LMS.w\[4\]\[6\] _10764_ _10781_ VPWR VGND sg13g2_nor2_1
X_16929_ VGND VPWR _08075_ _08076_ _08085_ _08084_ sg13g2_a21oi_1
XFILLER_66_953 VPWR VGND sg13g2_fill_2
XFILLER_37_132 VPWR VGND sg13g2_decap_8
X_19648_ _10712_ _10704_ _10711_ VPWR VGND sg13g2_nand2_1
XFILLER_66_997 VPWR VGND sg13g2_decap_8
XFILLER_37_165 VPWR VGND sg13g2_fill_2
XFILLER_26_828 VPWR VGND sg13g2_decap_4
XFILLER_77_1027 VPWR VGND sg13g2_decap_8
XFILLER_53_625 VPWR VGND sg13g2_fill_2
XFILLER_53_636 VPWR VGND sg13g2_fill_1
XFILLER_52_113 VPWR VGND sg13g2_fill_1
X_19579_ VGND VPWR _10627_ _10634_ _10643_ _10642_ sg13g2_a21oi_1
XFILLER_52_135 VPWR VGND sg13g2_fill_1
XFILLER_34_850 VPWR VGND sg13g2_decap_8
X_21610_ _02227_ u_LMS.w\[7\]\[17\] _02158_ VPWR VGND sg13g2_xnor2_1
X_22590_ VGND VPWR _03212_ _03055_ _00590_ _03057_ sg13g2_a21oi_1
XFILLER_34_883 VPWR VGND sg13g2_decap_8
XFILLER_34_894 VPWR VGND sg13g2_fill_2
X_21541_ _02158_ _02139_ _02157_ VPWR VGND sg13g2_xnor2_1
XFILLER_14_1000 VPWR VGND sg13g2_decap_8
XFILLER_53_1060 VPWR VGND sg13g2_fill_1
X_21472_ _02089_ _02088_ _02080_ VPWR VGND sg13g2_nand2b_1
X_23211_ net1461 VGND VPWR _00273_ u_FIR.w\[8\]\[0\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
X_20423_ _01083_ _01039_ _01041_ VPWR VGND sg13g2_xnor2_1
XFILLER_14_1055 VPWR VGND sg13g2_decap_4
XFILLER_119_465 VPWR VGND sg13g2_decap_4
XFILLER_112_9 VPWR VGND sg13g2_fill_1
X_23142_ net1576 VGND VPWR _00204_ u_FIR.sum\[8\]\[14\] clknet_leaf_44_clkA sg13g2_dfrbpq_1
XFILLER_101_1058 VPWR VGND sg13g2_fill_2
X_20354_ _01017_ u_LMS.w\[5\]\[7\] _00995_ VPWR VGND sg13g2_xnor2_1
X_23073_ net1096 VGND VPWR _00135_ u_FIR.sum\[4\]\[16\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
X_20285_ _00948_ _11091_ _11121_ VPWR VGND sg13g2_xnor2_1
XFILLER_103_811 VPWR VGND sg13g2_fill_2
X_22024_ net587 net585 net185 _02618_ VPWR VGND net167 sg13g2_nand4_1
XFILLER_88_522 VPWR VGND sg13g2_fill_2
XFILLER_102_321 VPWR VGND sg13g2_fill_2
XFILLER_103_855 VPWR VGND sg13g2_fill_1
XFILLER_76_706 VPWR VGND sg13g2_decap_4
XFILLER_102_365 VPWR VGND sg13g2_decap_4
XFILLER_60_1042 VPWR VGND sg13g2_fill_2
XFILLER_56_452 VPWR VGND sg13g2_decap_8
XFILLER_17_817 VPWR VGND sg13g2_fill_1
X_22926_ _03192_ net323 net2 u_spi_slave.rx_shift\[7\] net428 VPWR VGND sg13g2_a22oi_1
XFILLER_28_154 VPWR VGND sg13g2_fill_2
XFILLER_84_794 VPWR VGND sg13g2_fill_2
X_22857_ _03151_ _07902_ _03137_ net551 u_p2s_output.reg_sh\[2\] VPWR VGND sg13g2_a22oi_1
X_12610_ VGND VPWR _03978_ _03977_ _03952_ sg13g2_or2_1
X_21808_ _02402_ _02382_ _02400_ VPWR VGND sg13g2_xnor2_1
X_13590_ _04921_ _04919_ _04920_ VPWR VGND sg13g2_nand2_1
XFILLER_24_360 VPWR VGND sg13g2_decap_8
X_22788_ u_debug_unit.mon_w5_sync\[3\] net348 _03112_ VPWR VGND sg13g2_nor2_1
XFILLER_101_61 VPWR VGND sg13g2_fill_1
X_12541_ _03905_ VPWR _03914_ VGND _03859_ _03906_ sg13g2_o21ai_1
X_21739_ net366 VPWR _02334_ VGND u_LMS.w\[7\]\[11\] net377 sg13g2_o21ai_1
XFILLER_101_94 VPWR VGND sg13g2_decap_4
XFILLER_129_207 VPWR VGND sg13g2_fill_1
X_15260_ _06529_ VPWR _06530_ VGND net496 u_FIR.sum\[6\]\[9\] sg13g2_o21ai_1
X_12472_ _03846_ _03823_ _03848_ VPWR VGND sg13g2_xor2_1
XFILLER_12_588 VPWR VGND sg13g2_decap_8
XFILLER_12_599 VPWR VGND sg13g2_fill_2
X_14211_ _05479_ _05481_ _05519_ _05520_ VPWR VGND sg13g2_or3_1
XFILLER_124_0 VPWR VGND sg13g2_decap_8
X_23409_ net1121 VGND VPWR _00471_ u_LMS.w\[8\]\[19\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
X_15191_ _06462_ _06456_ _06460_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_49 VPWR VGND sg13g2_decap_8
X_14142_ net878 _05451_ net757 _05452_ VPWR VGND sg13g2_nand3_1
XFILLER_125_424 VPWR VGND sg13g2_fill_1
XFILLER_126_958 VPWR VGND sg13g2_fill_2
XFILLER_3_220 VPWR VGND sg13g2_fill_1
XFILLER_98_308 VPWR VGND sg13g2_fill_1
X_18950_ VGND VPWR _10035_ _10036_ _10037_ _10033_ sg13g2_a21oi_1
X_14073_ _05383_ _05376_ _05385_ VPWR VGND sg13g2_xor2_1
XFILLER_3_253 VPWR VGND sg13g2_fill_1
XFILLER_4_798 VPWR VGND sg13g2_decap_8
X_17901_ u_LMS.w\[1\]\[11\] _08993_ _09034_ VPWR VGND sg13g2_nor2_1
X_13024_ VGND VPWR _04377_ _04376_ _04368_ sg13g2_or2_1
XFILLER_3_286 VPWR VGND sg13g2_decap_8
X_18881_ VPWR _09968_ _09967_ VGND sg13g2_inv_1
XFILLER_79_533 VPWR VGND sg13g2_decap_8
XFILLER_105_181 VPWR VGND sg13g2_fill_1
Xfanout1010 net1011 net1010 VPWR VGND sg13g2_buf_1
X_23239__1412 VPWR VGND net1411 sg13g2_tiehi
Xfanout1021 net1026 net1021 VPWR VGND sg13g2_buf_1
XFILLER_67_706 VPWR VGND sg13g2_decap_4
X_17832_ _08959_ _08964_ _08830_ _08965_ VPWR VGND sg13g2_nand3_1
XFILLER_39_408 VPWR VGND sg13g2_fill_2
Xfanout1032 net1043 net1032 VPWR VGND sg13g2_buf_1
XFILLER_0_971 VPWR VGND sg13g2_decap_8
Xfanout1043 net1 net1043 VPWR VGND sg13g2_buf_1
XFILLER_120_162 VPWR VGND sg13g2_fill_1
X_23103__1052 VPWR VGND net1051 sg13g2_tiehi
X_17763_ _08896_ _08795_ _08865_ VPWR VGND sg13g2_xnor2_1
XFILLER_48_942 VPWR VGND sg13g2_decap_4
XFILLER_13_7 VPWR VGND sg13g2_decap_8
X_14975_ _06239_ u_FIR.sum\[4\]\[18\] _06255_ VPWR VGND sg13g2_xor2_1
XFILLER_66_249 VPWR VGND sg13g2_fill_1
XFILLER_48_953 VPWR VGND sg13g2_fill_1
XFILLER_94_569 VPWR VGND sg13g2_decap_8
XFILLER_47_441 VPWR VGND sg13g2_decap_4
X_19502_ _10566_ _10533_ _10534_ VPWR VGND sg13g2_xnor2_1
X_16714_ VGND VPWR u_LMS.w\[8\]\[13\] _07872_ _07876_ _07873_ sg13g2_a21oi_1
X_13926_ net1035 VPWR _05247_ VGND net536 u_FIR.sum\[3\]\[15\] sg13g2_o21ai_1
X_17694_ _08824_ _08823_ _08827_ VPWR VGND sg13g2_xor2_1
XFILLER_62_400 VPWR VGND sg13g2_fill_1
XFILLER_62_411 VPWR VGND sg13g2_fill_1
X_19433_ _10467_ _10494_ _10496_ _10497_ VPWR VGND sg13g2_nor3_1
XFILLER_90_731 VPWR VGND sg13g2_decap_4
X_16645_ VGND VPWR u_LMS.w\[5\]\[17\] _07812_ _07824_ _07813_ sg13g2_a21oi_1
X_13857_ net1035 VPWR _05181_ VGND net537 u_FIR.sum\[3\]\[12\] sg13g2_o21ai_1
XFILLER_35_669 VPWR VGND sg13g2_fill_2
XFILLER_34_146 VPWR VGND sg13g2_decap_4
XFILLER_23_809 VPWR VGND sg13g2_decap_8
X_19364_ _10428_ _10397_ _10427_ VPWR VGND sg13g2_xnor2_1
X_12808_ _04158_ VPWR _04170_ VGND _04154_ _04156_ sg13g2_o21ai_1
X_16576_ u_LMS.w\[3\]\[24\] _07773_ _07774_ VPWR VGND sg13g2_nor2_1
XFILLER_22_319 VPWR VGND sg13g2_decap_4
X_13788_ _05080_ _05113_ _05114_ VPWR VGND sg13g2_nor2b_1
X_18315_ _03264_ net176 _09425_ VPWR VGND sg13g2_nor2_1
X_15527_ _06784_ _06783_ _06779_ VPWR VGND sg13g2_nand2b_1
X_19295_ VPWR _10359_ _10358_ VGND sg13g2_inv_1
X_12739_ _04103_ net732 net843 VPWR VGND sg13g2_nand2_1
X_18246_ VGND VPWR _09353_ _09355_ _09356_ _09325_ sg13g2_a21oi_1
XFILLER_124_1047 VPWR VGND sg13g2_decap_8
X_15458_ _06644_ _06710_ _06720_ VPWR VGND sg13g2_nor2_1
XFILLER_30_385 VPWR VGND sg13g2_fill_1
X_14409_ net1006 VPWR _05712_ VGND net512 u_FIR.sum\[4\]\[14\] sg13g2_o21ai_1
X_18177_ _09285_ _09286_ _09287_ VPWR VGND sg13g2_nor2_1
X_15389_ _06655_ _06648_ _06653_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_251 VPWR VGND sg13g2_decap_8
X_17128_ _08284_ net707 net263 VPWR VGND sg13g2_nand2_1
Xrebuffer2204 _02000_ net2203 VPWR VGND sg13g2_buf_1
Xrebuffer2215 _01882_ net2214 VPWR VGND sg13g2_buf_1
X_17059_ _08137_ _08135_ _08215_ VPWR VGND sg13g2_xor2_1
XFILLER_131_416 VPWR VGND sg13g2_fill_1
XFILLER_83_1031 VPWR VGND sg13g2_fill_2
XFILLER_98_831 VPWR VGND sg13g2_decap_8
X_20070_ _11104_ VPWR _11111_ VGND _11069_ _11102_ sg13g2_o21ai_1
XFILLER_97_352 VPWR VGND sg13g2_fill_2
X_23520__1337 VPWR VGND net1336 sg13g2_tiehi
XFILLER_58_739 VPWR VGND sg13g2_fill_1
XFILLER_57_216 VPWR VGND sg13g2_decap_8
XFILLER_111_173 VPWR VGND sg13g2_decap_4
XFILLER_57_227 VPWR VGND sg13g2_decap_8
XFILLER_38_452 VPWR VGND sg13g2_fill_2
XFILLER_72_208 VPWR VGND sg13g2_fill_2
XFILLER_39_986 VPWR VGND sg13g2_fill_1
X_20972_ _01611_ VPWR _01612_ VGND _03305_ _01589_ sg13g2_o21ai_1
X_23760_ net983 VGND VPWR _00007_ u_spi_slave.rx_shift\[2\] clknet_3_0__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_54_923 VPWR VGND sg13g2_fill_2
XFILLER_39_997 VPWR VGND sg13g2_decap_8
XFILLER_93_580 VPWR VGND sg13g2_decap_4
XFILLER_93_591 VPWR VGND sg13g2_decap_4
XFILLER_54_945 VPWR VGND sg13g2_fill_1
X_22711_ _03071_ u_debug_unit.error_signal_sync\[7\] _03073_ _00695_ VPWR VGND sg13g2_a21o_1
XFILLER_25_135 VPWR VGND sg13g2_decap_8
X_23691_ net1013 VGND VPWR _00753_ u_debug_unit.mon_w8_sync\[1\] clknet_leaf_36_clkA
+ sg13g2_dfrbpq_1
XFILLER_41_617 VPWR VGND sg13g2_fill_1
X_22642_ coeff_force_packed\[18\] net464 _03063_ _00636_ VPWR VGND sg13g2_mux2_1
XFILLER_13_319 VPWR VGND sg13g2_decap_8
X_22573_ VGND VPWR u_LMS.count\[25\] _03044_ _03046_ u_LMS.count\[26\] sg13g2_a21oi_1
X_21524_ _01825_ VPWR _02141_ VGND _01790_ _01826_ sg13g2_o21ai_1
XFILLER_22_897 VPWR VGND sg13g2_decap_8
X_21455_ _02072_ _02069_ _02071_ VPWR VGND sg13g2_nand2_1
XFILLER_119_240 VPWR VGND sg13g2_decap_8
XFILLER_119_251 VPWR VGND sg13g2_fill_2
XFILLER_31_57 VPWR VGND sg13g2_decap_8
X_20406_ _03315_ net76 _01069_ VPWR VGND sg13g2_nor2_1
X_21386_ _02002_ _02001_ _02003_ VPWR VGND sg13g2_xor2_1
XFILLER_107_479 VPWR VGND sg13g2_fill_2
X_20337_ _01000_ _00890_ _00923_ VPWR VGND sg13g2_xnor2_1
X_23125_ net1601 VGND VPWR _00187_ u_FIR.sum\[7\]\[11\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
X_23056_ net1122 VGND VPWR _00118_ u_FIR.sum\[3\]\[18\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
XFILLER_0_223 VPWR VGND sg13g2_fill_1
X_20268_ VGND VPWR _00929_ _00930_ _00931_ _00906_ sg13g2_a21oi_1
X_23184__1509 VPWR VGND net1508 sg13g2_tiehi
X_22007_ _02601_ _02578_ _02600_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_256 VPWR VGND sg13g2_decap_8
XFILLER_89_886 VPWR VGND sg13g2_decap_8
XFILLER_131_972 VPWR VGND sg13g2_decap_4
X_20199_ _00852_ VPWR _00862_ VGND _00853_ net2122 sg13g2_o21ai_1
XFILLER_130_471 VPWR VGND sg13g2_fill_1
XFILLER_48_227 VPWR VGND sg13g2_fill_1
XFILLER_76_569 VPWR VGND sg13g2_decap_8
XFILLER_91_506 VPWR VGND sg13g2_fill_1
X_14760_ VGND VPWR _06008_ _06039_ _06048_ _06038_ sg13g2_a21oi_1
X_11972_ VPWR _00794_ _03391_ VGND sg13g2_inv_1
XFILLER_44_400 VPWR VGND sg13g2_fill_2
XFILLER_16_102 VPWR VGND sg13g2_decap_4
XFILLER_45_945 VPWR VGND sg13g2_fill_1
XFILLER_29_496 VPWR VGND sg13g2_fill_2
X_13711_ _05039_ _05038_ _05037_ VPWR VGND sg13g2_nand2b_1
XFILLER_56_98 VPWR VGND sg13g2_decap_8
X_22909_ net1028 VPWR _03183_ VGND net554 u_s2p_input.reg_sh\[3\] sg13g2_o21ai_1
X_14691_ _03368_ net410 _05941_ _05981_ VPWR VGND sg13g2_nor3_1
XFILLER_72_753 VPWR VGND sg13g2_decap_4
XFILLER_60_904 VPWR VGND sg13g2_fill_2
X_16430_ _07643_ _07645_ _07659_ _07660_ VPWR VGND sg13g2_nor3_1
XFILLER_32_617 VPWR VGND sg13g2_decap_8
X_13642_ _04969_ _04970_ _04971_ VPWR VGND sg13g2_and2_1
XFILLER_60_948 VPWR VGND sg13g2_fill_2
XFILLER_31_116 VPWR VGND sg13g2_fill_2
XFILLER_72_64 VPWR VGND sg13g2_decap_8
X_16361_ _07594_ u_FIR.sum\[7\]\[13\] net387 VPWR VGND sg13g2_nand2_1
X_13573_ _04904_ _04868_ _04902_ VPWR VGND sg13g2_xnor2_1
XFILLER_72_86 VPWR VGND sg13g2_decap_8
XFILLER_12_330 VPWR VGND sg13g2_decap_8
XFILLER_9_813 VPWR VGND sg13g2_decap_8
X_18100_ _09202_ _09209_ _09210_ VPWR VGND sg13g2_and2_1
XFILLER_9_824 VPWR VGND sg13g2_fill_2
X_15312_ _06580_ _06579_ _06578_ VPWR VGND sg13g2_nand2b_1
X_19080_ _10167_ _10165_ _10166_ VPWR VGND sg13g2_xnor2_1
X_12524_ _03898_ _03892_ _03897_ VPWR VGND sg13g2_nand2_1
XFILLER_8_312 VPWR VGND sg13g2_decap_4
XFILLER_40_672 VPWR VGND sg13g2_fill_2
X_16292_ _07527_ _07526_ _07525_ VPWR VGND sg13g2_nand2b_1
X_18031_ VGND VPWR net37 _09149_ _00316_ _09150_ sg13g2_a21oi_1
X_15243_ VGND VPWR _06513_ _06467_ _06465_ sg13g2_or2_1
X_12455_ _03359_ _03830_ _03831_ VPWR VGND sg13g2_nor2_1
X_15174_ _06412_ _06445_ _06446_ VPWR VGND sg13g2_nor2_1
X_12386_ _03764_ _03763_ _03759_ VPWR VGND sg13g2_nand2b_1
X_14125_ _05434_ _05408_ _05436_ VPWR VGND sg13g2_xor2_1
X_19982_ _11003_ _11021_ _11023_ VPWR VGND sg13g2_nor2_1
XFILLER_114_939 VPWR VGND sg13g2_decap_4
XFILLER_125_287 VPWR VGND sg13g2_fill_1
X_18933_ _09981_ _10019_ _10020_ VPWR VGND sg13g2_nor2_1
X_14056_ net997 VPWR _05369_ VGND net493 u_FIR.sum\[4\]\[4\] sg13g2_o21ai_1
X_13007_ net1040 VPWR _04363_ VGND net545 u_FIR.sum\[1\]\[15\] sg13g2_o21ai_1
XFILLER_95_812 VPWR VGND sg13g2_fill_2
X_18864_ _09951_ net658 net182 VPWR VGND sg13g2_nand2_1
XFILLER_95_834 VPWR VGND sg13g2_decap_8
XFILLER_121_482 VPWR VGND sg13g2_decap_8
XFILLER_95_856 VPWR VGND sg13g2_fill_1
X_17815_ VGND VPWR _08921_ _08923_ _08948_ _08920_ sg13g2_a21oi_1
X_18795_ _09879_ _09881_ _09882_ VPWR VGND sg13g2_nor2_1
XFILLER_67_558 VPWR VGND sg13g2_fill_1
XFILLER_95_889 VPWR VGND sg13g2_fill_1
X_17746_ _08877_ _08878_ _08879_ VPWR VGND sg13g2_nor2_1
X_14958_ u_FIR.sum\[4\]\[17\] net396 _06239_ VPWR VGND sg13g2_nor2b_1
X_13909_ VGND VPWR _05212_ _05222_ _05230_ _05221_ sg13g2_a21oi_1
X_17677_ _08808_ _08809_ _08810_ VPWR VGND sg13g2_nor2_1
X_14889_ _06151_ _06173_ _06174_ VPWR VGND sg13g2_nor2_1
X_19416_ _10480_ net114 net646 net133 net645 VPWR VGND sg13g2_a22oi_1
X_16628_ _07811_ VPWR _07812_ VGND _07808_ _07809_ sg13g2_o21ai_1
XFILLER_90_572 VPWR VGND sg13g2_fill_2
XFILLER_23_628 VPWR VGND sg13g2_decap_8
XFILLER_22_116 VPWR VGND sg13g2_decap_8
X_19347_ _10411_ _10397_ _10409_ VPWR VGND sg13g2_xnor2_1
X_16559_ VGND VPWR u_LMS.w\[2\]\[15\] _07753_ _07761_ _07754_ sg13g2_a21oi_1
XFILLER_87_0 VPWR VGND sg13g2_decap_4
XFILLER_31_672 VPWR VGND sg13g2_fill_1
X_19278_ _10343_ _10226_ _10228_ VPWR VGND sg13g2_xnor2_1
X_18229_ _09337_ _09334_ _09339_ VPWR VGND sg13g2_xor2_1
XFILLER_129_571 VPWR VGND sg13g2_decap_8
X_21240_ _01857_ _01854_ _01855_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_70 VPWR VGND sg13g2_decap_8
XFILLER_117_777 VPWR VGND sg13g2_decap_8
X_21171_ _01756_ VPWR _01788_ VGND _03223_ _01764_ sg13g2_o21ai_1
XFILLER_105_939 VPWR VGND sg13g2_fill_1
XFILLER_89_105 VPWR VGND sg13g2_fill_1
XFILLER_89_127 VPWR VGND sg13g2_fill_1
X_20122_ _11163_ _11161_ _11162_ VPWR VGND sg13g2_nand2_1
XFILLER_132_758 VPWR VGND sg13g2_fill_2
Xrebuffer2067 _07950_ net2066 VPWR VGND sg13g2_buf_1
Xfanout803 net804 net803 VPWR VGND sg13g2_buf_1
Xfanout814 net815 net814 VPWR VGND sg13g2_buf_1
Xrebuffer2078 net2136 net2077 VPWR VGND sg13g2_buf_1
XFILLER_113_950 VPWR VGND sg13g2_fill_1
Xfanout825 net831 net825 VPWR VGND sg13g2_buf_1
Xrebuffer2089 _10234_ net2088 VPWR VGND sg13g2_buf_1
XFILLER_131_257 VPWR VGND sg13g2_decap_8
X_20053_ _11094_ net626 net232 VPWR VGND sg13g2_nand2_1
Xfanout836 net837 net836 VPWR VGND sg13g2_buf_1
Xfanout847 net850 net847 VPWR VGND sg13g2_buf_1
XFILLER_113_983 VPWR VGND sg13g2_decap_4
Xfanout858 net859 net858 VPWR VGND sg13g2_buf_1
Xfanout869 net870 net869 VPWR VGND sg13g2_buf_1
XFILLER_85_399 VPWR VGND sg13g2_decap_4
XFILLER_73_539 VPWR VGND sg13g2_decap_4
XFILLER_38_260 VPWR VGND sg13g2_fill_2
X_23743_ net983 VGND VPWR _00805_ spi_wdata\[2\] clknet_3_0__leaf_spi_sclk sg13g2_dfrbpq_1
X_20955_ VGND VPWR _01500_ _01594_ _01595_ _01511_ sg13g2_a21oi_1
XFILLER_42_904 VPWR VGND sg13g2_fill_2
XFILLER_26_455 VPWR VGND sg13g2_decap_4
XFILLER_42_926 VPWR VGND sg13g2_decap_4
XFILLER_26_488 VPWR VGND sg13g2_decap_4
X_23674_ net1023 VGND VPWR _00736_ u_debug_unit.mon_w5_sync\[5\] clknet_leaf_20_clkA
+ sg13g2_dfrbpq_1
XFILLER_81_583 VPWR VGND sg13g2_fill_2
XFILLER_14_639 VPWR VGND sg13g2_fill_1
X_20886_ VPWR _01526_ _01525_ VGND sg13g2_inv_1
XFILLER_53_285 VPWR VGND sg13g2_fill_1
XFILLER_41_425 VPWR VGND sg13g2_decap_8
XFILLER_41_447 VPWR VGND sg13g2_decap_8
X_22625_ coeff_force_packed\[5\] net463 _03061_ _00621_ VPWR VGND sg13g2_mux2_1
XFILLER_107_1020 VPWR VGND sg13g2_fill_1
XFILLER_42_23 VPWR VGND sg13g2_fill_2
XFILLER_42_34 VPWR VGND sg13g2_fill_2
X_22556_ net950 VPWR _03036_ VGND u_LMS.count\[19\] _03034_ sg13g2_o21ai_1
XFILLER_21_171 VPWR VGND sg13g2_decap_8
XFILLER_21_182 VPWR VGND sg13g2_fill_1
X_21507_ _02124_ _02122_ _02123_ VPWR VGND sg13g2_nand2b_1
X_22487_ net958 VPWR _02993_ VGND net441 u_LMS.x_r\[8\]\[1\] sg13g2_o21ai_1
XFILLER_5_304 VPWR VGND sg13g2_decap_8
X_12240_ VGND VPWR net540 _03621_ _00053_ _03622_ sg13g2_a21oi_1
X_21438_ _02051_ _02052_ _02055_ VPWR VGND sg13g2_xor2_1
XFILLER_5_337 VPWR VGND sg13g2_decap_8
X_12171_ net943 u_spi_slave.rx_shift\[1\] _00007_ VPWR VGND sg13g2_nor2b_1
X_21369_ _01986_ _01982_ _01985_ VPWR VGND sg13g2_nand2_1
XFILLER_123_725 VPWR VGND sg13g2_fill_1
XFILLER_123_747 VPWR VGND sg13g2_decap_8
X_23108_ net1044 VGND VPWR _00170_ u_FIR.sum\[6\]\[13\] clknet_leaf_42_clkA sg13g2_dfrbpq_1
XFILLER_3_28 VPWR VGND sg13g2_decap_8
X_15930_ _07173_ _07174_ _07175_ VPWR VGND sg13g2_and2_1
X_23039_ net1147 VGND VPWR _00101_ u_FIR.sum\[3\]\[1\] clknet_leaf_35_clkA sg13g2_dfrbpq_1
XFILLER_104_994 VPWR VGND sg13g2_fill_2
XFILLER_77_834 VPWR VGND sg13g2_decap_8
X_15861_ _07088_ _07108_ _07109_ VPWR VGND sg13g2_nor2b_1
XFILLER_37_709 VPWR VGND sg13g2_decap_8
X_17600_ _08733_ net684 net235 VPWR VGND sg13g2_nand2_1
XFILLER_76_366 VPWR VGND sg13g2_fill_1
XFILLER_67_97 VPWR VGND sg13g2_fill_1
XFILLER_64_506 VPWR VGND sg13g2_fill_2
XFILLER_18_901 VPWR VGND sg13g2_fill_1
X_14812_ _06099_ _06090_ _06097_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_826 VPWR VGND sg13g2_decap_8
XFILLER_36_208 VPWR VGND sg13g2_fill_1
X_18580_ _09650_ _09648_ _09688_ VPWR VGND sg13g2_xor2_1
X_15792_ _07034_ _07041_ _07042_ VPWR VGND sg13g2_nor2b_1
X_17531_ _08663_ _08633_ _08664_ VPWR VGND sg13g2_xor2_1
X_14743_ _06032_ u_FIR.sum\[4\]\[9\] net398 VPWR VGND sg13g2_xnor2_1
XFILLER_29_293 VPWR VGND sg13g2_fill_1
X_11955_ VPWR _03376_ net796 VGND sg13g2_inv_1
XFILLER_45_753 VPWR VGND sg13g2_fill_2
XFILLER_72_550 VPWR VGND sg13g2_fill_1
X_17462_ _08593_ _08587_ _08595_ VPWR VGND sg13g2_xor2_1
XFILLER_83_85 VPWR VGND sg13g2_decap_8
XFILLER_32_403 VPWR VGND sg13g2_decap_4
X_14674_ _05963_ _05927_ _05965_ VPWR VGND sg13g2_xor2_1
XFILLER_60_723 VPWR VGND sg13g2_fill_2
X_11886_ VPWR _03307_ u_LMS.w\[6\]\[5\] VGND sg13g2_inv_1
X_19201_ _10284_ net307 u_LMS.w\[3\]\[16\] coeff_force_packed\[25\] net558 VPWR VGND
+ sg13g2_a22oi_1
X_16413_ _07644_ _07628_ _07642_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_447 VPWR VGND sg13g2_fill_1
X_13625_ _04923_ _04954_ _04955_ VPWR VGND sg13g2_nor2_1
XFILLER_73_1030 VPWR VGND sg13g2_fill_1
X_17393_ VGND VPWR _08538_ _08539_ _00289_ net933 sg13g2_a21oi_1
X_23027__1166 VPWR VGND net1165 sg13g2_tiehi
X_19132_ _10219_ _10218_ _10192_ VPWR VGND sg13g2_nand2b_1
X_16344_ VGND VPWR _07576_ _07577_ _07578_ net411 sg13g2_a21oi_1
X_13556_ _04880_ VPWR _04887_ VGND _04851_ _04878_ sg13g2_o21ai_1
XFILLER_9_632 VPWR VGND sg13g2_decap_8
XFILLER_80_7 VPWR VGND sg13g2_fill_2
XFILLER_13_694 VPWR VGND sg13g2_fill_2
XFILLER_8_131 VPWR VGND sg13g2_fill_1
X_19063_ _09875_ _09876_ _10150_ VPWR VGND sg13g2_nor2_1
X_12507_ _03881_ _03825_ _03882_ VPWR VGND sg13g2_xor2_1
X_16275_ _07510_ _07480_ _07511_ VPWR VGND sg13g2_xor2_1
X_13487_ VGND VPWR net516 _04820_ _00101_ _04821_ sg13g2_a21oi_1
X_18014_ _09137_ _09081_ _09083_ VPWR VGND sg13g2_xnor2_1
X_15226_ _06496_ net777 net835 VPWR VGND sg13g2_nand2_1
X_12438_ _03815_ _03754_ _03814_ VPWR VGND sg13g2_xnor2_1
XFILLER_126_552 VPWR VGND sg13g2_fill_2
XFILLER_5_860 VPWR VGND sg13g2_fill_1
XFILLER_59_4 VPWR VGND sg13g2_fill_1
X_15157_ _06427_ _06428_ _06429_ VPWR VGND sg13g2_and2_1
X_12369_ _03746_ VPWR _03748_ VGND _03707_ _03710_ sg13g2_o21ai_1
X_14108_ VGND VPWR _05419_ _05417_ _05379_ sg13g2_or2_1
XFILLER_99_447 VPWR VGND sg13g2_fill_1
X_19965_ _10993_ _10989_ _10991_ _11006_ VPWR VGND sg13g2_a21o_1
X_15088_ _06362_ _06354_ _06361_ VPWR VGND sg13g2_nand2_1
XFILLER_113_257 VPWR VGND sg13g2_decap_4
XFILLER_80_1012 VPWR VGND sg13g2_fill_1
X_18916_ _10003_ _10000_ _10002_ VPWR VGND sg13g2_nand2_1
X_14039_ _05352_ _05343_ _05350_ VPWR VGND sg13g2_xnor2_1
XFILLER_80_1023 VPWR VGND sg13g2_decap_8
X_19896_ _03237_ net142 _10937_ VPWR VGND sg13g2_nor2_1
XFILLER_68_856 VPWR VGND sg13g2_fill_1
X_18847_ VGND VPWR net91 _09932_ _09934_ _09799_ sg13g2_a21oi_1
XFILLER_121_290 VPWR VGND sg13g2_fill_2
X_18778_ _09865_ _09864_ net119 VPWR VGND sg13g2_nand2b_1
X_17729_ _08862_ net205 net694 net242 net692 VPWR VGND sg13g2_a22oi_1
XFILLER_82_358 VPWR VGND sg13g2_decap_8
X_20740_ _01380_ _01352_ _01353_ VPWR VGND sg13g2_xnor2_1
XFILLER_35_296 VPWR VGND sg13g2_fill_1
X_20671_ _01311_ _01309_ _01310_ VPWR VGND sg13g2_nand2b_1
XFILLER_51_778 VPWR VGND sg13g2_fill_2
XFILLER_50_266 VPWR VGND sg13g2_fill_1
X_22410_ VGND VPWR net433 _03264_ _00513_ _02954_ sg13g2_a21oi_1
X_23390_ net1178 VGND VPWR _00452_ u_LMS.w\[7\]\[23\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
X_22341_ _02801_ _02800_ _02916_ VPWR VGND sg13g2_xor2_1
X_22272_ _02821_ _02861_ _02862_ VPWR VGND sg13g2_nor2b_1
XFILLER_105_703 VPWR VGND sg13g2_fill_1
X_21223_ _01840_ _01839_ _01838_ VPWR VGND sg13g2_nand2b_1
XFILLER_2_307 VPWR VGND sg13g2_fill_1
X_23449__1585 VPWR VGND net1584 sg13g2_tiehi
XFILLER_132_522 VPWR VGND sg13g2_decap_8
X_21154_ net427 _03219_ net131 net100 _01771_ VPWR VGND sg13g2_nor4_1
Xfanout600 u_LMS.x_r\[7\]\[2\] net600 VPWR VGND sg13g2_buf_1
XFILLER_120_706 VPWR VGND sg13g2_fill_2
X_20105_ _11144_ _11143_ _11146_ VPWR VGND sg13g2_xor2_1
Xfanout611 u_LMS.x_r\[6\]\[5\] net611 VPWR VGND sg13g2_buf_1
XFILLER_120_717 VPWR VGND sg13g2_decap_4
Xfanout622 u_LMS.x_r\[5\]\[7\] net622 VPWR VGND sg13g2_buf_1
X_21085_ VGND VPWR _01657_ _01711_ _01712_ net14 sg13g2_a21oi_1
Xfanout633 net634 net633 VPWR VGND sg13g2_buf_1
Xfanout644 u_LMS.x_r\[4\]\[5\] net644 VPWR VGND sg13g2_buf_1
XFILLER_132_599 VPWR VGND sg13g2_decap_8
Xfanout655 u_LMS.x_r\[3\]\[6\] net655 VPWR VGND sg13g2_buf_1
X_20036_ _11077_ _11035_ _11041_ VPWR VGND sg13g2_xnor2_1
Xfanout666 u_LMS.x_r\[3\]\[1\] net666 VPWR VGND sg13g2_buf_1
Xfanout677 u_LMS.x_r\[2\]\[3\] net677 VPWR VGND sg13g2_buf_1
XFILLER_58_344 VPWR VGND sg13g2_fill_2
Xfanout688 u_LMS.x_r\[1\]\[6\] net688 VPWR VGND sg13g2_buf_1
XFILLER_101_975 VPWR VGND sg13g2_decap_4
Xfanout699 u_LMS.x_r\[1\]\[1\] net699 VPWR VGND sg13g2_buf_1
XFILLER_86_686 VPWR VGND sg13g2_decap_4
XFILLER_85_163 VPWR VGND sg13g2_fill_1
XFILLER_58_377 VPWR VGND sg13g2_fill_1
XFILLER_86_697 VPWR VGND sg13g2_decap_4
XFILLER_85_174 VPWR VGND sg13g2_decap_8
XFILLER_73_314 VPWR VGND sg13g2_decap_8
XFILLER_2_1034 VPWR VGND sg13g2_decap_8
XFILLER_27_753 VPWR VGND sg13g2_decap_4
XFILLER_26_230 VPWR VGND sg13g2_decap_8
X_21987_ _02581_ _02577_ _02580_ VPWR VGND sg13g2_nand2_1
XFILLER_27_775 VPWR VGND sg13g2_fill_2
XFILLER_26_252 VPWR VGND sg13g2_decap_8
XFILLER_15_915 VPWR VGND sg13g2_decap_8
X_23726_ net1334 VGND VPWR _00788_ u_s2p_input.reg_cnt\[0\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
X_20938_ _01578_ u_LMS.w\[6\]\[13\] net2057 VPWR VGND sg13g2_nand2_1
XFILLER_54_594 VPWR VGND sg13g2_decap_8
XFILLER_26_285 VPWR VGND sg13g2_decap_4
XFILLER_41_222 VPWR VGND sg13g2_fill_2
XFILLER_14_447 VPWR VGND sg13g2_fill_1
X_23657_ net983 VGND VPWR _00719_ u_debug_unit.mon_w3_sync\[2\] clknet_leaf_53_clkA
+ sg13g2_dfrbpq_1
X_20869_ _01502_ _01508_ _01509_ VPWR VGND sg13g2_nor2b_1
XFILLER_41_255 VPWR VGND sg13g2_decap_8
X_13410_ _04752_ _04751_ _04723_ VPWR VGND sg13g2_nand2b_1
X_22608_ net460 debug_load_bus\[6\] _03059_ _00606_ VPWR VGND sg13g2_mux2_1
X_14390_ VGND VPWR net513 _05692_ _00132_ _05693_ sg13g2_a21oi_1
X_23588_ net963 VGND VPWR _00650_ coeff_force_packed\[30\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
XFILLER_10_642 VPWR VGND sg13g2_fill_2
X_13341_ _04685_ _04684_ _04683_ VPWR VGND sg13g2_nand2b_1
X_22539_ u_LMS.count\[13\] _03024_ _03025_ VPWR VGND sg13g2_and2_1
XFILLER_128_839 VPWR VGND sg13g2_decap_8
X_23023__1172 VPWR VGND net1171 sg13g2_tiehi
X_16060_ VGND VPWR _07301_ _07299_ _07259_ sg13g2_or2_1
XFILLER_5_112 VPWR VGND sg13g2_decap_8
X_13272_ _04618_ u_FIR.sum\[1\]\[9\] net405 VPWR VGND sg13g2_nand2_1
X_15011_ VGND VPWR net484 _06286_ _00159_ _06287_ sg13g2_a21oi_1
X_12223_ net1031 VPWR _03607_ VGND net531 u_FIR.sum\[0\]\[2\] sg13g2_o21ai_1
X_23038__1150 VPWR VGND net1149 sg13g2_tiehi
X_12154_ _03563_ _03412_ u_debug_unit.mon_w6_sync\[0\] _03405_ u_debug_unit.mon_w5_sync\[0\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_78_52 VPWR VGND sg13g2_fill_2
XFILLER_111_717 VPWR VGND sg13g2_decap_8
X_23522__1329 VPWR VGND net1328 sg13g2_tiehi
X_19750_ _10429_ VPWR _10814_ VGND _10396_ _10430_ sg13g2_o21ai_1
X_16962_ VPWR _08118_ _08117_ VGND sg13g2_inv_1
X_12085_ VPWR VGND coeff_force_packed\[46\] _03497_ net291 coeff_force_packed\[18\]
+ _03498_ net292 sg13g2_a221oi_1
X_18701_ net423 net128 _09788_ VPWR VGND sg13g2_nor2_1
X_15913_ _07159_ _07148_ _07158_ VPWR VGND sg13g2_xnor2_1
X_19681_ _10742_ u_LMS.w\[4\]\[16\] _10745_ VPWR VGND sg13g2_xor2_1
X_16893_ VGND VPWR _08049_ _08035_ _08033_ sg13g2_or2_1
XFILLER_77_653 VPWR VGND sg13g2_fill_1
XFILLER_65_804 VPWR VGND sg13g2_decap_8
XFILLER_76_152 VPWR VGND sg13g2_fill_1
X_18632_ _09729_ u_LMS.w\[2\]\[2\] _09532_ VPWR VGND sg13g2_xnor2_1
X_15844_ _03373_ net820 _07092_ VPWR VGND sg13g2_nor2_1
XFILLER_65_837 VPWR VGND sg13g2_fill_2
XFILLER_18_742 VPWR VGND sg13g2_fill_2
XFILLER_64_358 VPWR VGND sg13g2_decap_8
X_18563_ net69 u_LMS.w\[2\]\[23\] _09673_ VPWR VGND sg13g2_xor2_1
X_15775_ _03373_ net847 _07025_ VPWR VGND sg13g2_nor2_1
X_12987_ _04344_ u_FIR.sum\[0\]\[14\] _04324_ VPWR VGND sg13g2_xnor2_1
X_17514_ _08647_ _08633_ _08645_ VPWR VGND sg13g2_xnor2_1
X_14726_ net849 net767 _06013_ _06015_ VPWR VGND sg13g2_a21o_1
X_18494_ _09604_ _09543_ _09545_ VPWR VGND sg13g2_xnor2_1
X_11938_ VPWR _03359_ net726 VGND sg13g2_inv_1
X_17445_ _08578_ _08579_ _00301_ VPWR VGND sg13g2_nor2_1
X_14657_ _05948_ _05931_ _05947_ VPWR VGND sg13g2_nand2_1
XFILLER_33_767 VPWR VGND sg13g2_fill_2
X_11869_ VPWR _03290_ u_LMS.x\[0\] VGND sg13g2_inv_1
XFILLER_32_255 VPWR VGND sg13g2_decap_4
X_13608_ _04937_ _04933_ _04938_ VPWR VGND sg13g2_xor2_1
X_17376_ VGND VPWR _08523_ _08525_ _00286_ net932 sg13g2_a21oi_1
X_14588_ _05879_ _05843_ _05881_ VPWR VGND sg13g2_xor2_1
X_19115_ _10202_ u_LMS.w\[3\]\[3\] _10201_ VPWR VGND sg13g2_nand2_1
X_16327_ _07561_ _07553_ _07559_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_451 VPWR VGND sg13g2_fill_1
X_13539_ net853 u_FIR.sum\[2\]\[4\] net756 _04871_ VPWR VGND sg13g2_nand3_1
X_19046_ _10084_ _10085_ _10133_ VPWR VGND sg13g2_and2_1
X_16258_ _07494_ _07488_ _07492_ VPWR VGND sg13g2_xnor2_1
X_15209_ _06480_ _06437_ _06478_ VPWR VGND sg13g2_xnor2_1
X_16189_ _07427_ u_FIR.sum\[7\]\[8\] net386 VPWR VGND sg13g2_nand2_1
XFILLER_126_382 VPWR VGND sg13g2_decap_4
XFILLER_114_533 VPWR VGND sg13g2_decap_8
XFILLER_59_108 VPWR VGND sg13g2_fill_2
X_19948_ _03237_ net158 _10989_ VPWR VGND sg13g2_nor2_1
XFILLER_110_750 VPWR VGND sg13g2_fill_2
X_19879_ _10924_ _10786_ _10788_ VPWR VGND sg13g2_xnor2_1
XFILLER_96_973 VPWR VGND sg13g2_decap_8
XFILLER_67_152 VPWR VGND sg13g2_fill_1
X_21910_ _02496_ _02495_ _02504_ VPWR VGND sg13g2_xor2_1
X_22890_ VPWR _00774_ _03173_ VGND sg13g2_inv_1
XFILLER_82_111 VPWR VGND sg13g2_decap_8
XFILLER_83_645 VPWR VGND sg13g2_decap_8
XFILLER_82_122 VPWR VGND sg13g2_fill_1
X_21841_ _02435_ _02434_ _02433_ VPWR VGND sg13g2_nand2b_1
XFILLER_71_829 VPWR VGND sg13g2_fill_2
XFILLER_36_550 VPWR VGND sg13g2_decap_4
XFILLER_70_317 VPWR VGND sg13g2_fill_1
X_21772_ _02366_ net572 net110 _02365_ VPWR VGND sg13g2_and3_1
XFILLER_51_520 VPWR VGND sg13g2_fill_2
XFILLER_130_49 VPWR VGND sg13g2_decap_8
X_23511_ net1372 VGND VPWR _00573_ u_LMS.count\[14\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
X_20723_ _01361_ _01362_ _01363_ VPWR VGND sg13g2_nor2b_1
X_23442_ net1605 VGND VPWR _00504_ u_LMS.x_r\[2\]\[1\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
XFILLER_11_428 VPWR VGND sg13g2_fill_2
X_20654_ _01294_ _01293_ net117 VPWR VGND sg13g2_nand2b_1
XFILLER_20_962 VPWR VGND sg13g2_fill_1
X_20585_ _01225_ _01203_ _01223_ VPWR VGND sg13g2_xnor2_1
X_23373_ net1228 VGND VPWR _00435_ u_LMS.w\[6\]\[6\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
XFILLER_109_327 VPWR VGND sg13g2_decap_8
XFILLER_128_7 VPWR VGND sg13g2_decap_8
XFILLER_99_18 VPWR VGND sg13g2_decap_8
X_22324_ _02902_ _02903_ _00478_ VPWR VGND sg13g2_nor2_1
X_23147__1569 VPWR VGND net1568 sg13g2_tiehi
XFILLER_124_308 VPWR VGND sg13g2_fill_1
XFILLER_118_872 VPWR VGND sg13g2_decap_4
X_22255_ net8 VPWR _02849_ VGND _02846_ net7 sg13g2_o21ai_1
XFILLER_105_522 VPWR VGND sg13g2_fill_2
X_23400__1149 VPWR VGND net1148 sg13g2_tiehi
XFILLER_3_638 VPWR VGND sg13g2_decap_8
XFILLER_2_126 VPWR VGND sg13g2_decap_8
X_21206_ _01823_ _01811_ _01821_ VPWR VGND sg13g2_xnor2_1
X_22186_ _03295_ _02779_ _02780_ VPWR VGND sg13g2_nor2_1
XFILLER_132_363 VPWR VGND sg13g2_decap_8
XFILLER_120_514 VPWR VGND sg13g2_decap_8
XFILLER_105_599 VPWR VGND sg13g2_fill_2
X_21137_ VPWR _01754_ _01753_ VGND sg13g2_inv_1
Xfanout430 spi_wr_en net430 VPWR VGND sg13g2_buf_1
Xfanout441 net442 net441 VPWR VGND sg13g2_buf_1
Xfanout452 net453 net452 VPWR VGND sg13g2_buf_1
XFILLER_48_44 VPWR VGND sg13g2_decap_4
X_21068_ net969 VPWR _01699_ VGND u_LMS.w\[6\]\[21\] _08501_ sg13g2_o21ai_1
Xfanout463 spi_wdata\[5\] net463 VPWR VGND sg13g2_buf_1
XFILLER_87_962 VPWR VGND sg13g2_fill_2
XFILLER_58_130 VPWR VGND sg13g2_fill_1
Xfanout474 spi_addr\[1\] net474 VPWR VGND sg13g2_buf_1
XFILLER_58_141 VPWR VGND sg13g2_fill_2
Xfanout485 net486 net485 VPWR VGND sg13g2_buf_1
XFILLER_111_1005 VPWR VGND sg13g2_fill_1
X_20019_ _11060_ net626 net193 VPWR VGND sg13g2_nand2_1
Xfanout496 net504 net496 VPWR VGND sg13g2_buf_1
X_12910_ _04270_ _04232_ _04268_ VPWR VGND sg13g2_xnor2_1
XFILLER_58_163 VPWR VGND sg13g2_fill_1
XFILLER_48_88 VPWR VGND sg13g2_fill_1
XFILLER_101_794 VPWR VGND sg13g2_decap_8
X_13890_ _05198_ VPWR _05212_ VGND net280 _05196_ sg13g2_o21ai_1
X_12841_ _04201_ _04169_ _04203_ VPWR VGND sg13g2_xor2_1
XFILLER_62_818 VPWR VGND sg13g2_fill_2
XFILLER_73_155 VPWR VGND sg13g2_decap_8
XFILLER_73_166 VPWR VGND sg13g2_fill_2
XFILLER_15_701 VPWR VGND sg13g2_fill_2
X_15560_ _06816_ _06794_ _06814_ VPWR VGND sg13g2_xnor2_1
XFILLER_27_583 VPWR VGND sg13g2_decap_8
X_12772_ _04135_ _04096_ _04099_ VPWR VGND sg13g2_nand2_1
XFILLER_42_520 VPWR VGND sg13g2_fill_1
X_14511_ _05806_ _05804_ _05805_ VPWR VGND sg13g2_nand2_1
X_23709_ net1453 VGND VPWR _00771_ u_p2s_output.reg_done clknet_leaf_47_clkA sg13g2_dfrbpq_1
X_15491_ VGND VPWR net791 net888 _06750_ u_FIR.sum\[6\]\[1\] sg13g2_a21oi_1
XFILLER_42_553 VPWR VGND sg13g2_fill_2
X_17230_ _08386_ net702 net158 VPWR VGND sg13g2_nand2_1
XFILLER_9_49 VPWR VGND sg13g2_decap_8
X_14442_ _05743_ _05723_ _05727_ VPWR VGND sg13g2_nand2_1
XFILLER_14_288 VPWR VGND sg13g2_fill_1
Xfanout70 net70 net1650 VPWR VGND sg13g2_buf_4
Xfanout81 net81 net82 VPWR VGND sg13g2_buf_4
XFILLER_80_64 VPWR VGND sg13g2_fill_1
Xfanout92 _07991_ net92 VPWR VGND sg13g2_buf_2
X_17161_ _08317_ _08292_ _08293_ VPWR VGND sg13g2_xnor2_1
X_14373_ _05677_ _05570_ _05675_ VPWR VGND sg13g2_xnor2_1
XFILLER_80_86 VPWR VGND sg13g2_fill_2
XFILLER_7_911 VPWR VGND sg13g2_fill_2
X_16112_ _07352_ _07310_ _07350_ VPWR VGND sg13g2_xnor2_1
XFILLER_31_1039 VPWR VGND sg13g2_fill_1
XFILLER_10_472 VPWR VGND sg13g2_decap_4
X_13324_ _04635_ _04668_ _04669_ VPWR VGND sg13g2_nor2_1
X_17092_ _08248_ _08241_ _08247_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_443 VPWR VGND sg13g2_decap_8
XFILLER_13_91 VPWR VGND sg13g2_decap_8
XFILLER_109_872 VPWR VGND sg13g2_decap_4
X_16043_ net899 VPWR _07284_ VGND net799 _07281_ sg13g2_o21ai_1
XFILLER_129_91 VPWR VGND sg13g2_decap_8
X_13255_ _03361_ net868 _04601_ VPWR VGND sg13g2_nor2_1
XFILLER_6_498 VPWR VGND sg13g2_fill_2
X_12206_ _03592_ net727 net906 VPWR VGND sg13g2_nand2_1
XFILLER_124_842 VPWR VGND sg13g2_decap_8
XFILLER_123_330 VPWR VGND sg13g2_decap_8
X_13186_ _04528_ _04533_ _04534_ VPWR VGND sg13g2_nor2b_1
XFILLER_43_7 VPWR VGND sg13g2_decap_8
XFILLER_123_352 VPWR VGND sg13g2_fill_1
X_19802_ _10863_ VPWR _10864_ VGND _10852_ _10862_ sg13g2_o21ai_1
XFILLER_96_203 VPWR VGND sg13g2_decap_8
X_12137_ VGND VPWR coeff_force_packed\[22\] _03436_ _03547_ _03385_ sg13g2_a21oi_1
XFILLER_69_428 VPWR VGND sg13g2_decap_4
XFILLER_69_439 VPWR VGND sg13g2_fill_1
X_17994_ net40 VPWR _09121_ VGND net38 _09120_ sg13g2_o21ai_1
XFILLER_96_236 VPWR VGND sg13g2_decap_8
X_19733_ _10755_ u_LMS.w\[4\]\[11\] _10797_ VPWR VGND sg13g2_xor2_1
X_16945_ _07924_ _07910_ _08101_ VPWR VGND sg13g2_xor2_1
X_12068_ _03475_ _03481_ _03482_ VPWR VGND sg13g2_nor2_1
X_22993__1217 VPWR VGND net1216 sg13g2_tiehi
XFILLER_93_932 VPWR VGND sg13g2_decap_8
X_19664_ _10563_ _10564_ _10728_ VPWR VGND sg13g2_nor2b_1
XFILLER_38_848 VPWR VGND sg13g2_decap_8
X_16876_ _08032_ net705 net155 VPWR VGND sg13g2_nand2_1
X_18615_ VGND VPWR u_LMS.w\[2\]\[21\] net301 _09716_ _09702_ sg13g2_a21oi_1
X_15827_ _07076_ _07068_ _07074_ VPWR VGND sg13g2_xnor2_1
X_19595_ _10636_ _10658_ _10659_ VPWR VGND sg13g2_nor2_1
X_23225__1436 VPWR VGND net1435 sg13g2_tiehi
XFILLER_65_678 VPWR VGND sg13g2_fill_1
XFILLER_52_317 VPWR VGND sg13g2_decap_4
X_18546_ VGND VPWR _09590_ _09656_ _09655_ _09653_ sg13g2_a21oi_2
X_15758_ _07008_ _06976_ _07009_ VPWR VGND sg13g2_nor2b_1
XFILLER_33_520 VPWR VGND sg13g2_fill_2
X_14709_ _05997_ _05969_ _05999_ VPWR VGND sg13g2_xor2_1
XFILLER_127_1023 VPWR VGND sg13g2_decap_8
X_18477_ _09586_ _09260_ _09587_ VPWR VGND sg13g2_xor2_1
X_15689_ _06941_ net786 net847 VPWR VGND sg13g2_nand2_1
X_23509__1381 VPWR VGND net1380 sg13g2_tiehi
X_17428_ net364 VPWR _08567_ VGND u_LMS.w\[0\]\[6\] net382 sg13g2_o21ai_1
X_17359_ _08512_ net315 u_LMS.w\[0\]\[15\] coeff_force_packed\[3\] net564 VPWR VGND
+ sg13g2_a22oi_1
X_20370_ _01033_ _01032_ _00986_ VPWR VGND sg13g2_nand2b_1
Xclkload40 clknet_leaf_13_clkA clkload40/Y VPWR VGND sg13g2_inv_4
Xclkload51 VPWR clkload51/Y clknet_leaf_29_clkA VGND sg13g2_inv_1
X_19029_ _10116_ _10115_ _10107_ VPWR VGND sg13g2_nand2b_1
X_22040_ _02634_ net586 net221 VPWR VGND sg13g2_nand2_1
XFILLER_114_330 VPWR VGND sg13g2_fill_1
X_23143__1575 VPWR VGND net1574 sg13g2_tiehi
XFILLER_0_619 VPWR VGND sg13g2_decap_4
XFILLER_114_385 VPWR VGND sg13g2_fill_1
XFILLER_69_940 VPWR VGND sg13g2_fill_2
XFILLER_125_49 VPWR VGND sg13g2_decap_8
XFILLER_87_258 VPWR VGND sg13g2_fill_2
XFILLER_75_409 VPWR VGND sg13g2_fill_1
XFILLER_96_770 VPWR VGND sg13g2_decap_4
X_23158__1553 VPWR VGND net1552 sg13g2_tiehi
X_22942_ VGND VPWR net324 _03202_ _00801_ _03201_ sg13g2_a21oi_1
XFILLER_68_494 VPWR VGND sg13g2_decap_8
X_22873_ VGND VPWR net552 _03162_ _03163_ u_p2s_output.reg_cnt\[0\] sg13g2_a21oi_1
XFILLER_83_464 VPWR VGND sg13g2_fill_1
Xclkbuf_leaf_11_clkA clknet_4_10_0_clkA clknet_leaf_11_clkA VPWR VGND sg13g2_buf_8
XFILLER_83_475 VPWR VGND sg13g2_fill_2
X_21824_ _02418_ _02404_ _02417_ VPWR VGND sg13g2_nand2_1
XFILLER_71_648 VPWR VGND sg13g2_decap_4
X_21755_ _02349_ net583 net149 VPWR VGND sg13g2_nand2_1
XFILLER_12_715 VPWR VGND sg13g2_decap_8
X_20706_ _01346_ net610 net209 VPWR VGND sg13g2_nand2_1
X_21686_ _02293_ _02240_ _02242_ VPWR VGND sg13g2_xnor2_1
XFILLER_11_236 VPWR VGND sg13g2_fill_1
XFILLER_8_719 VPWR VGND sg13g2_decap_4
X_23425_ net1073 VGND VPWR _00487_ u_LMS.x_r\[0\]\[0\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
Xclkload1 clknet_4_2_0_clkA clkload1/X VPWR VGND sg13g2_buf_8
X_20637_ _01277_ _01276_ _01272_ VPWR VGND sg13g2_nand2b_1
XFILLER_7_218 VPWR VGND sg13g2_fill_1
X_23356_ net1245 VGND VPWR _00418_ u_LMS.w\[6\]\[12\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
X_20568_ _01206_ _01207_ _01208_ VPWR VGND sg13g2_nor2b_1
X_22307_ _02836_ VPWR _02890_ VGND _02835_ _02838_ sg13g2_o21ai_1
X_23287_ net1320 VGND VPWR _00349_ u_LMS.w\[3\]\[12\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
XFILLER_4_936 VPWR VGND sg13g2_fill_1
X_20499_ VGND VPWR net52 _01141_ _01142_ net19 sg13g2_a21oi_1
X_13040_ net867 u_FIR.sum\[1\]\[3\] net746 _04392_ VPWR VGND sg13g2_nand3_1
X_22238_ _02832_ _02828_ _02830_ _02831_ VPWR VGND sg13g2_and3_1
XFILLER_79_715 VPWR VGND sg13g2_fill_1
XFILLER_59_54 VPWR VGND sg13g2_fill_2
X_22169_ u_LMS.w\[8\]\[14\] _02762_ _02763_ VPWR VGND sg13g2_and2_1
XFILLER_132_171 VPWR VGND sg13g2_decap_8
XFILLER_120_322 VPWR VGND sg13g2_fill_2
XFILLER_121_867 VPWR VGND sg13g2_decap_8
XFILLER_8_1040 VPWR VGND sg13g2_decap_8
X_14991_ _06269_ net781 net900 VPWR VGND sg13g2_nand2_1
XFILLER_78_269 VPWR VGND sg13g2_fill_2
Xfanout260 _07922_ net260 VPWR VGND sg13g2_buf_2
XFILLER_59_450 VPWR VGND sg13g2_decap_8
Xfanout271 _07533_ net271 VPWR VGND sg13g2_buf_1
Xfanout282 _05087_ net282 VPWR VGND sg13g2_buf_1
X_16730_ VGND VPWR _03296_ net528 _00279_ _07886_ sg13g2_a21oi_1
X_13942_ _05260_ _05249_ _05262_ VPWR VGND sg13g2_xor2_1
XFILLER_59_483 VPWR VGND sg13g2_decap_8
Xfanout293 _03429_ net293 VPWR VGND sg13g2_buf_1
XFILLER_19_325 VPWR VGND sg13g2_decap_8
XFILLER_75_954 VPWR VGND sg13g2_fill_1
XFILLER_19_347 VPWR VGND sg13g2_fill_1
X_16661_ net1030 VPWR _07837_ VGND net530 net745 sg13g2_o21ai_1
X_13873_ _05196_ u_FIR.sum\[2\]\[13\] net403 VPWR VGND sg13g2_xnor2_1
X_18400_ _09509_ _09502_ _09510_ VPWR VGND sg13g2_xor2_1
X_15612_ _06864_ _06861_ _06866_ VPWR VGND sg13g2_xor2_1
XFILLER_28_881 VPWR VGND sg13g2_decap_4
X_12824_ _04186_ _04144_ _04185_ VPWR VGND sg13g2_xnor2_1
X_19380_ VGND VPWR _10444_ _10442_ _10441_ sg13g2_or2_1
X_16592_ VGND VPWR u_LMS.w\[3\]\[17\] _07773_ _07785_ _07774_ sg13g2_a21oi_1
XFILLER_131_81 VPWR VGND sg13g2_decap_8
X_18331_ _09440_ _09439_ _09441_ VPWR VGND sg13g2_nor2b_1
X_15543_ VGND VPWR _06799_ _06797_ _06763_ sg13g2_or2_1
X_12755_ _04119_ _04114_ _04117_ VPWR VGND sg13g2_xnor2_1
X_18262_ _09371_ VPWR _09372_ VGND _09367_ _09368_ sg13g2_o21ai_1
X_15474_ _06720_ _06726_ _06722_ _06735_ VPWR VGND sg13g2_mux2_1
X_12686_ VGND VPWR net541 _04050_ _00070_ _04051_ sg13g2_a21oi_1
X_17213_ _08366_ _08365_ _08369_ VPWR VGND sg13g2_xor2_1
X_14425_ _05727_ _05725_ _05726_ VPWR VGND sg13g2_nand2_1
X_18193_ _09303_ net678 net79 VPWR VGND sg13g2_nand2_1
X_17144_ _08300_ _08276_ _08277_ VPWR VGND sg13g2_xnor2_1
X_14356_ _05659_ _05634_ _05661_ VPWR VGND sg13g2_xor2_1
XFILLER_128_444 VPWR VGND sg13g2_decap_8
X_13307_ _04652_ _04646_ _04650_ VPWR VGND sg13g2_xnor2_1
X_17075_ VGND VPWR _08197_ _08205_ _08231_ _08204_ sg13g2_a21oi_1
X_14287_ _05594_ _05565_ _05593_ VPWR VGND sg13g2_xnor2_1
XFILLER_109_691 VPWR VGND sg13g2_fill_1
X_16026_ _07267_ _07255_ _07265_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_295 VPWR VGND sg13g2_decap_8
X_13238_ _04585_ _04577_ _04584_ VPWR VGND sg13g2_xnor2_1
X_13169_ _04502_ VPWR _04517_ VGND _04496_ _04500_ sg13g2_o21ai_1
XFILLER_97_578 VPWR VGND sg13g2_fill_2
X_17977_ _08984_ u_LMS.w\[1\]\[15\] _09107_ VPWR VGND sg13g2_xor2_1
Xclkbuf_leaf_34_clkA clknet_4_13_0_clkA clknet_leaf_34_clkA VPWR VGND sg13g2_buf_8
XFILLER_84_217 VPWR VGND sg13g2_fill_2
X_19716_ VGND VPWR u_LMS.w\[4\]\[5\] _10766_ _10780_ _10779_ sg13g2_a21oi_1
X_16928_ _08077_ _08083_ _08084_ VPWR VGND sg13g2_nor2b_1
XFILLER_66_943 VPWR VGND sg13g2_fill_1
XFILLER_38_645 VPWR VGND sg13g2_fill_1
X_19647_ _10710_ _10705_ _10711_ VPWR VGND sg13g2_nor2b_1
X_16859_ _08013_ _08006_ _08015_ VPWR VGND sg13g2_xor2_1
XFILLER_92_250 VPWR VGND sg13g2_fill_2
XFILLER_25_317 VPWR VGND sg13g2_fill_2
XFILLER_81_946 VPWR VGND sg13g2_decap_4
XFILLER_92_283 VPWR VGND sg13g2_fill_1
X_19578_ _10635_ _10641_ _10642_ VPWR VGND sg13g2_nor2_1
XFILLER_92_294 VPWR VGND sg13g2_fill_2
XFILLER_53_648 VPWR VGND sg13g2_fill_2
X_18529_ _09639_ _09638_ _09603_ VPWR VGND sg13g2_nand2b_1
X_21540_ _01827_ _01809_ _02157_ VPWR VGND sg13g2_xor2_1
XFILLER_21_534 VPWR VGND sg13g2_decap_4
X_21471_ _02086_ _02082_ _02087_ _02088_ VPWR VGND sg13g2_a21o_1
XFILLER_14_1012 VPWR VGND sg13g2_fill_2
XFILLER_21_589 VPWR VGND sg13g2_decap_8
XFILLER_119_422 VPWR VGND sg13g2_fill_1
XFILLER_14_1034 VPWR VGND sg13g2_decap_8
X_23210_ net1463 VGND VPWR _00272_ u_FIR.w\[7\]\[6\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
X_20422_ VGND VPWR _01081_ _01082_ _00397_ net934 sg13g2_a21oi_1
XFILLER_101_1026 VPWR VGND sg13g2_fill_2
X_23141_ net1577 VGND VPWR _00203_ u_FIR.sum\[8\]\[13\] clknet_leaf_44_clkA sg13g2_dfrbpq_1
X_20353_ _01015_ VPWR _01016_ VGND _03313_ _00996_ sg13g2_o21ai_1
X_23471__1515 VPWR VGND net1514 sg13g2_tiehi
X_20284_ _00947_ _00945_ _00946_ VPWR VGND sg13g2_nand2_1
X_23072_ net1098 VGND VPWR _00134_ u_FIR.sum\[4\]\[15\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
XFILLER_121_108 VPWR VGND sg13g2_decap_8
X_22023_ _02617_ net584 net185 VPWR VGND sg13g2_nand2_1
XFILLER_121_119 VPWR VGND sg13g2_fill_1
XFILLER_0_438 VPWR VGND sg13g2_decap_8
XFILLER_102_344 VPWR VGND sg13g2_fill_2
XFILLER_102_355 VPWR VGND sg13g2_fill_1
XFILLER_29_46 VPWR VGND sg13g2_fill_2
XFILLER_28_122 VPWR VGND sg13g2_fill_1
X_22925_ spi_addr\[0\] net325 _03191_ VPWR VGND sg13g2_nor2_1
XFILLER_29_678 VPWR VGND sg13g2_decap_8
XFILLER_72_924 VPWR VGND sg13g2_fill_2
XFILLER_44_615 VPWR VGND sg13g2_fill_1
X_22856_ VGND VPWR net300 _03149_ _00763_ _03150_ sg13g2_a21oi_1
XFILLER_43_125 VPWR VGND sg13g2_decap_8
XFILLER_72_979 VPWR VGND sg13g2_decap_8
XFILLER_45_78 VPWR VGND sg13g2_decap_8
X_21807_ _02400_ VPWR _02401_ VGND _02374_ _02381_ sg13g2_o21ai_1
X_22787_ VGND VPWR _07818_ net347 _00733_ _03111_ sg13g2_a21oi_1
X_12540_ VGND VPWR _03889_ _03907_ _03913_ _03910_ sg13g2_a21oi_1
X_21738_ VGND VPWR net49 _02332_ _02333_ net10 sg13g2_a21oi_1
XFILLER_51_191 VPWR VGND sg13g2_fill_1
XFILLER_40_854 VPWR VGND sg13g2_decap_4
XFILLER_12_545 VPWR VGND sg13g2_fill_2
X_12471_ _03847_ _03823_ _03846_ VPWR VGND sg13g2_nand2_1
X_21669_ _02230_ _02232_ _02279_ VPWR VGND sg13g2_and2_1
X_14210_ _05519_ _05484_ _05517_ VPWR VGND sg13g2_xnor2_1
X_23408_ net1124 VGND VPWR _00470_ u_LMS.w\[8\]\[18\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
X_15190_ _06461_ _06460_ _06456_ VPWR VGND sg13g2_nand2b_1
XFILLER_6_28 VPWR VGND sg13g2_decap_8
X_14141_ _03365_ net892 _05451_ VPWR VGND sg13g2_nor2_1
XFILLER_117_0 VPWR VGND sg13g2_decap_8
X_23339_ net1262 VGND VPWR _00401_ u_LMS.w\[5\]\[18\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
XFILLER_4_722 VPWR VGND sg13g2_fill_2
X_14072_ _05384_ _05376_ _05383_ VPWR VGND sg13g2_nand2_1
XFILLER_4_766 VPWR VGND sg13g2_decap_8
X_23250__1393 VPWR VGND net1392 sg13g2_tiehi
Xclkbuf_leaf_57_clkA clknet_4_1_0_clkA clknet_leaf_57_clkA VPWR VGND sg13g2_buf_8
X_17900_ VGND VPWR _09030_ _09031_ _09033_ _08996_ sg13g2_a21oi_1
X_13023_ _04376_ net744 net896 VPWR VGND sg13g2_nand2_1
XFILLER_106_694 VPWR VGND sg13g2_decap_8
X_18880_ _09967_ _09962_ _09965_ VPWR VGND sg13g2_xnor2_1
XFILLER_10_92 VPWR VGND sg13g2_decap_8
Xfanout1000 net1009 net1000 VPWR VGND sg13g2_buf_1
XFILLER_126_70 VPWR VGND sg13g2_decap_8
Xfanout1011 net1014 net1011 VPWR VGND sg13g2_buf_1
XFILLER_117_1044 VPWR VGND sg13g2_decap_8
XFILLER_0_950 VPWR VGND sg13g2_decap_8
Xfanout1022 net1026 net1022 VPWR VGND sg13g2_buf_1
X_17831_ _08962_ _08963_ _08964_ VPWR VGND sg13g2_and2_1
Xfanout1033 net1042 net1033 VPWR VGND sg13g2_buf_1
X_17762_ _08895_ _08886_ _08893_ VPWR VGND sg13g2_xnor2_1
X_14974_ _06253_ VPWR _06254_ VGND net268 _06240_ sg13g2_o21ai_1
XFILLER_47_420 VPWR VGND sg13g2_decap_8
X_19501_ _10565_ _10559_ _10560_ VPWR VGND sg13g2_xnor2_1
X_16713_ VGND VPWR net526 _07874_ _00273_ _07875_ sg13g2_a21oi_1
X_13925_ _05244_ _05229_ _05246_ VPWR VGND sg13g2_xor2_1
X_17693_ _08819_ _08818_ _08821_ _08826_ VPWR VGND sg13g2_a21o_1
XFILLER_48_998 VPWR VGND sg13g2_decap_4
XFILLER_75_795 VPWR VGND sg13g2_decap_8
X_19432_ _10490_ _10495_ _10496_ VPWR VGND sg13g2_nor2_1
X_16644_ VGND VPWR net519 _07822_ _00256_ _07823_ sg13g2_a21oi_1
X_13856_ _05178_ _05150_ _05180_ VPWR VGND sg13g2_xor2_1
XFILLER_74_283 VPWR VGND sg13g2_fill_2
XFILLER_74_294 VPWR VGND sg13g2_decap_8
XFILLER_34_125 VPWR VGND sg13g2_fill_1
X_23116__1616 VPWR VGND net1615 sg13g2_tiehi
X_12807_ _04161_ VPWR _04169_ VGND _04132_ _04162_ sg13g2_o21ai_1
X_19363_ _10425_ _10416_ _10427_ VPWR VGND sg13g2_xor2_1
X_16575_ _07770_ VPWR _07773_ VGND _07771_ _07772_ sg13g2_o21ai_1
X_13787_ _05111_ _05081_ _05113_ VPWR VGND sg13g2_xor2_1
X_18314_ VPWR _09424_ _09423_ VGND sg13g2_inv_1
X_15526_ _06781_ _06763_ _06783_ VPWR VGND sg13g2_xor2_1
X_12738_ _04102_ net735 net830 VPWR VGND sg13g2_nand2_1
X_19294_ _10356_ _10350_ _10358_ VPWR VGND sg13g2_xor2_1
XFILLER_42_180 VPWR VGND sg13g2_decap_8
XFILLER_31_865 VPWR VGND sg13g2_fill_2
XFILLER_124_1026 VPWR VGND sg13g2_decap_8
XFILLER_89_4 VPWR VGND sg13g2_fill_2
X_18245_ VGND VPWR _09355_ _09354_ _09349_ sg13g2_or2_1
X_15457_ _06715_ VPWR _06719_ VGND _06704_ _06716_ sg13g2_o21ai_1
X_12669_ _03995_ _03997_ _04035_ VPWR VGND sg13g2_and2_1
XFILLER_30_375 VPWR VGND sg13g2_decap_4
X_14408_ _05709_ _05694_ _05711_ VPWR VGND sg13g2_xor2_1
XFILLER_128_230 VPWR VGND sg13g2_decap_8
X_18176_ _09286_ _09218_ _09219_ VPWR VGND sg13g2_xnor2_1
X_15388_ _06648_ _06653_ _06654_ VPWR VGND sg13g2_nor2b_1
X_17127_ net714 net194 net712 _08283_ VPWR VGND net231 sg13g2_nand4_1
X_14339_ _05642_ _05606_ _05644_ VPWR VGND sg13g2_xor2_1
XFILLER_128_296 VPWR VGND sg13g2_decap_8
X_23382__1203 VPWR VGND net1202 sg13g2_tiehi
XFILLER_7_593 VPWR VGND sg13g2_decap_8
Xrebuffer2205 _02618_ net2204 VPWR VGND sg13g2_buf_1
Xrebuffer2216 net2216 net2215 VPWR VGND sg13g2_buf_1
X_17058_ _08184_ VPWR _08214_ VGND _08174_ _08182_ sg13g2_o21ai_1
X_16009_ net845 u_FIR.sum\[7\]\[4\] net802 _07250_ VPWR VGND sg13g2_nand3_1
XFILLER_124_480 VPWR VGND sg13g2_fill_2
XFILLER_32_0 VPWR VGND sg13g2_decap_8
XFILLER_98_865 VPWR VGND sg13g2_decap_4
XFILLER_44_1038 VPWR VGND sg13g2_fill_2
XFILLER_44_1049 VPWR VGND sg13g2_decap_8
XFILLER_100_826 VPWR VGND sg13g2_decap_8
XFILLER_111_152 VPWR VGND sg13g2_decap_8
XFILLER_39_921 VPWR VGND sg13g2_decap_8
X_20971_ _01611_ _01609_ _01610_ VPWR VGND sg13g2_nand2b_1
XFILLER_66_784 VPWR VGND sg13g2_fill_1
XFILLER_65_261 VPWR VGND sg13g2_fill_2
XFILLER_53_412 VPWR VGND sg13g2_fill_2
X_22710_ _03071_ u_debug_unit.error_signal_sync\[6\] _03073_ _00694_ VPWR VGND sg13g2_a21o_1
XFILLER_81_732 VPWR VGND sg13g2_fill_2
X_23690_ net987 VGND VPWR _00752_ u_debug_unit.mon_w8_sync\[0\] clknet_leaf_54_clkA
+ sg13g2_dfrbpq_1
XFILLER_53_434 VPWR VGND sg13g2_fill_2
XFILLER_25_125 VPWR VGND sg13g2_decap_4
XFILLER_81_754 VPWR VGND sg13g2_fill_1
XFILLER_53_467 VPWR VGND sg13g2_decap_4
X_22641_ coeff_force_packed\[17\] net466 _03063_ _00635_ VPWR VGND sg13g2_mux2_1
XFILLER_15_37 VPWR VGND sg13g2_decap_4
X_22572_ net918 _03045_ _00584_ VPWR VGND sg13g2_nor2_1
XFILLER_22_865 VPWR VGND sg13g2_fill_1
X_21523_ _01828_ VPWR _02140_ VGND _01829_ _02139_ sg13g2_o21ai_1
XFILLER_21_353 VPWR VGND sg13g2_decap_8
XFILLER_31_14 VPWR VGND sg13g2_decap_8
XFILLER_21_386 VPWR VGND sg13g2_decap_8
X_21454_ _02043_ _02070_ _02071_ VPWR VGND sg13g2_and2_1
XFILLER_31_36 VPWR VGND sg13g2_decap_8
XFILLER_119_263 VPWR VGND sg13g2_decap_8
X_20405_ _01067_ _01066_ _01068_ VPWR VGND sg13g2_nor2b_1
XFILLER_108_948 VPWR VGND sg13g2_decap_4
XFILLER_110_7 VPWR VGND sg13g2_fill_1
X_21385_ _02002_ _01780_ _01916_ VPWR VGND sg13g2_xnor2_1
XFILLER_107_447 VPWR VGND sg13g2_decap_4
X_23124_ net1603 VGND VPWR _00186_ u_FIR.sum\[7\]\[10\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
X_20336_ _03314_ _00998_ _00999_ VPWR VGND sg13g2_nor2_1
XFILLER_123_929 VPWR VGND sg13g2_decap_8
X_23055_ net1123 VGND VPWR _00117_ u_FIR.sum\[3\]\[17\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
X_20267_ _00905_ _00904_ _00930_ VPWR VGND sg13g2_xor2_1
XFILLER_89_843 VPWR VGND sg13g2_fill_2
XFILLER_115_480 VPWR VGND sg13g2_fill_2
XFILLER_115_491 VPWR VGND sg13g2_fill_2
XFILLER_0_235 VPWR VGND sg13g2_decap_8
XFILLER_103_642 VPWR VGND sg13g2_fill_1
X_22006_ _02598_ _02597_ _02600_ VPWR VGND sg13g2_xor2_1
XFILLER_102_130 VPWR VGND sg13g2_fill_1
X_20198_ _00859_ _00858_ _00861_ VPWR VGND sg13g2_xor2_1
XFILLER_103_675 VPWR VGND sg13g2_fill_2
XFILLER_76_515 VPWR VGND sg13g2_fill_2
XFILLER_131_995 VPWR VGND sg13g2_decap_8
XFILLER_56_11 VPWR VGND sg13g2_fill_1
X_11971_ _03387_ VPWR _03391_ VGND u_spi_slave.tx_cnt\[2\] _03390_ sg13g2_o21ai_1
X_13710_ _05036_ VPWR _05038_ VGND _04996_ _04998_ sg13g2_o21ai_1
X_22908_ VGND VPWR net555 _03209_ _00783_ _03182_ sg13g2_a21oi_1
XFILLER_72_732 VPWR VGND sg13g2_decap_8
XFILLER_56_283 VPWR VGND sg13g2_decap_4
X_14690_ _05980_ u_FIR.w\[3\]\[1\] net806 VPWR VGND sg13g2_nand2_1
X_13641_ net879 net749 _04968_ _04970_ VPWR VGND sg13g2_a21o_1
X_22839_ _03138_ net478 net552 VPWR VGND sg13g2_nand2b_1
XFILLER_72_32 VPWR VGND sg13g2_decap_8
XFILLER_72_43 VPWR VGND sg13g2_fill_2
XFILLER_25_681 VPWR VGND sg13g2_decap_4
X_16360_ _07593_ _07584_ _07592_ VPWR VGND sg13g2_xnor2_1
XFILLER_31_128 VPWR VGND sg13g2_fill_2
X_13572_ _04903_ _04902_ _04868_ VPWR VGND sg13g2_nand2b_1
X_15311_ _06579_ _06576_ _06577_ VPWR VGND sg13g2_nand2_1
X_23112__1622 VPWR VGND net1621 sg13g2_tiehi
X_12523_ _03897_ _03865_ _03896_ VPWR VGND sg13g2_xnor2_1
XFILLER_40_662 VPWR VGND sg13g2_fill_2
X_16291_ _07526_ _07523_ _07524_ VPWR VGND sg13g2_nand2_1
X_18030_ net359 VPWR _09150_ VGND u_LMS.w\[1\]\[2\] net375 sg13g2_o21ai_1
X_15242_ _06512_ _06494_ _06511_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_346 VPWR VGND sg13g2_decap_8
X_12454_ VGND VPWR _03830_ _03829_ _03804_ sg13g2_or2_1
X_15173_ _06445_ _06413_ _06443_ VPWR VGND sg13g2_xnor2_1
X_12385_ _03761_ _03762_ _03763_ VPWR VGND sg13g2_and2_1
X_14124_ _05408_ _05434_ _05435_ VPWR VGND sg13g2_nor2_1
X_19981_ _11022_ _11003_ _11021_ VPWR VGND sg13g2_nand2_1
XFILLER_125_266 VPWR VGND sg13g2_decap_4
XFILLER_125_277 VPWR VGND sg13g2_fill_2
X_18932_ _10019_ net254 net655 net239 net657 VPWR VGND sg13g2_a22oi_1
X_14055_ _05368_ _05339_ _05366_ VPWR VGND sg13g2_xnor2_1
X_13006_ _04362_ _04356_ _04361_ VPWR VGND sg13g2_xnor2_1
XFILLER_79_342 VPWR VGND sg13g2_decap_8
X_18863_ _09916_ _09914_ _09950_ VPWR VGND sg13g2_xor2_1
XFILLER_97_95 VPWR VGND sg13g2_fill_2
XFILLER_122_995 VPWR VGND sg13g2_decap_8
X_17814_ _08924_ _08946_ _08947_ VPWR VGND sg13g2_nor2b_1
XFILLER_94_323 VPWR VGND sg13g2_fill_1
XFILLER_79_397 VPWR VGND sg13g2_decap_4
X_18794_ _09881_ net195 net653 net218 net655 VPWR VGND sg13g2_a22oi_1
X_17745_ _08878_ _08841_ _08848_ VPWR VGND sg13g2_xnor2_1
X_14957_ _06238_ _06224_ _06226_ VPWR VGND sg13g2_nand2_1
XFILLER_82_529 VPWR VGND sg13g2_fill_1
XFILLER_36_924 VPWR VGND sg13g2_decap_8
X_13908_ _05224_ _05226_ _05229_ VPWR VGND sg13g2_nor2_1
X_17676_ _08809_ _08781_ _08782_ VPWR VGND sg13g2_xnor2_1
X_14888_ _06173_ _06152_ _06172_ VPWR VGND sg13g2_xnor2_1
X_19415_ _10479_ _10446_ _10477_ VPWR VGND sg13g2_nand2_1
XFILLER_23_607 VPWR VGND sg13g2_fill_1
X_16627_ _03317_ _03319_ _03316_ _07811_ VPWR VGND _07810_ sg13g2_nand4_1
X_13839_ _05163_ _05155_ _05161_ VPWR VGND sg13g2_xnor2_1
XFILLER_62_286 VPWR VGND sg13g2_fill_1
XFILLER_51_949 VPWR VGND sg13g2_decap_8
X_19346_ _10410_ _10409_ _10397_ VPWR VGND sg13g2_nand2b_1
X_16558_ VGND VPWR net489 _07759_ _00233_ _07760_ sg13g2_a21oi_1
X_15509_ _06765_ _06766_ _06767_ VPWR VGND sg13g2_nor2_1
X_19277_ VPWR VGND _10342_ _08554_ net27 _03329_ _00370_ net368 sg13g2_a221oi_1
X_16489_ u_LMS.w\[0\]\[19\] u_LMS.w\[0\]\[18\] u_LMS.w\[0\]\[20\] _07708_ VPWR VGND
+ sg13g2_nand3_1
X_18228_ _09338_ _09337_ _09334_ VPWR VGND sg13g2_nand2b_1
XFILLER_30_183 VPWR VGND sg13g2_fill_2
XFILLER_129_550 VPWR VGND sg13g2_decap_8
X_18159_ _09177_ _09175_ _09269_ VPWR VGND sg13g2_xor2_1
XFILLER_116_211 VPWR VGND sg13g2_fill_1
XFILLER_117_745 VPWR VGND sg13g2_decap_4
XFILLER_11_1059 VPWR VGND sg13g2_fill_2
XFILLER_105_918 VPWR VGND sg13g2_decap_8
XFILLER_116_244 VPWR VGND sg13g2_fill_1
X_21170_ VGND VPWR _01785_ _01786_ _01787_ _01779_ sg13g2_a21oi_1
X_20121_ _11160_ VPWR _11162_ VGND _03239_ net180 sg13g2_o21ai_1
Xclkbuf_leaf_9_clkA clknet_4_10_0_clkA clknet_leaf_9_clkA VPWR VGND sg13g2_buf_8
Xrebuffer2068 _07916_ net2067 VPWR VGND sg13g2_buf_1
XFILLER_131_236 VPWR VGND sg13g2_decap_8
Xfanout804 net805 net804 VPWR VGND sg13g2_buf_1
Xfanout815 net816 net815 VPWR VGND sg13g2_buf_1
Xrebuffer2079 net2079 net2078 VPWR VGND sg13g2_buf_1
X_20052_ net625 net236 net623 _11093_ VPWR VGND net211 sg13g2_nand4_1
Xfanout826 net831 net826 VPWR VGND sg13g2_buf_1
XFILLER_86_802 VPWR VGND sg13g2_decap_4
Xfanout837 u_FIR.x_reg\[5\] net837 VPWR VGND sg13g2_buf_1
Xfanout848 net850 net848 VPWR VGND sg13g2_buf_1
Xfanout859 net861 net859 VPWR VGND sg13g2_buf_1
XFILLER_85_323 VPWR VGND sg13g2_fill_2
XFILLER_85_345 VPWR VGND sg13g2_decap_4
X_23180__1516 VPWR VGND net1515 sg13g2_tiehi
XFILLER_73_507 VPWR VGND sg13g2_decap_8
XFILLER_73_518 VPWR VGND sg13g2_fill_1
XFILLER_100_689 VPWR VGND sg13g2_fill_2
XFILLER_39_773 VPWR VGND sg13g2_decap_8
XFILLER_94_890 VPWR VGND sg13g2_decap_4
X_23742_ net991 VGND VPWR _00804_ spi_wdata\[1\] clknet_3_2__leaf_spi_sclk sg13g2_dfrbpq_1
XFILLER_26_25 VPWR VGND sg13g2_fill_2
X_20954_ _01594_ net619 net261 VPWR VGND sg13g2_nand2_1
XFILLER_26_36 VPWR VGND sg13g2_fill_2
XFILLER_54_754 VPWR VGND sg13g2_decap_8
XFILLER_26_58 VPWR VGND sg13g2_decap_4
X_23673_ net1020 VGND VPWR _00735_ u_debug_unit.mon_w5_sync\[4\] clknet_leaf_35_clkA
+ sg13g2_dfrbpq_1
X_20885_ _01428_ _01427_ _01525_ VPWR VGND sg13g2_xor2_1
X_22624_ coeff_force_packed\[4\] net465 _03061_ _00620_ VPWR VGND sg13g2_mux2_1
X_22555_ u_LMS.count\[19\] _03034_ _03035_ VPWR VGND sg13g2_and2_1
XFILLER_10_846 VPWR VGND sg13g2_fill_2
X_21506_ _01918_ _01923_ _02123_ VPWR VGND sg13g2_xor2_1
Xclkbuf_4_3_0_clkA clknet_0_clkA clknet_4_3_0_clkA VPWR VGND sg13g2_buf_8
XFILLER_10_868 VPWR VGND sg13g2_fill_2
X_22486_ VGND VPWR net442 _03226_ _00551_ _02992_ sg13g2_a21oi_1
XFILLER_108_723 VPWR VGND sg13g2_decap_4
X_21437_ _02046_ _02044_ _02048_ _02054_ VPWR VGND sg13g2_a21o_1
XFILLER_107_255 VPWR VGND sg13g2_fill_1
X_12170_ net943 u_spi_slave.rx_shift\[0\] _00006_ VPWR VGND sg13g2_nor2b_1
XFILLER_107_266 VPWR VGND sg13g2_decap_4
X_21368_ _01983_ _01984_ _01985_ VPWR VGND sg13g2_nor2_2
X_23107_ net1045 VGND VPWR _00169_ u_FIR.sum\[6\]\[12\] clknet_leaf_42_clkA sg13g2_dfrbpq_1
X_20319_ VGND VPWR _11189_ _00939_ _00982_ _11187_ sg13g2_a21oi_1
X_21299_ _03224_ net93 _01916_ VPWR VGND sg13g2_nor2_1
XFILLER_27_1022 VPWR VGND sg13g2_decap_4
XFILLER_122_258 VPWR VGND sg13g2_fill_1
X_23038_ net1149 VGND VPWR _00100_ u_FIR.sum\[3\]\[0\] clknet_leaf_35_clkA sg13g2_dfrbpq_1
XFILLER_27_1033 VPWR VGND sg13g2_fill_1
XFILLER_88_150 VPWR VGND sg13g2_decap_8
XFILLER_77_813 VPWR VGND sg13g2_fill_2
XFILLER_131_792 VPWR VGND sg13g2_fill_2
X_15860_ _07108_ _07101_ _07106_ VPWR VGND sg13g2_xnor2_1
XFILLER_67_87 VPWR VGND sg13g2_fill_2
XFILLER_114_1058 VPWR VGND sg13g2_fill_2
X_14811_ _06098_ _06090_ _06097_ VPWR VGND sg13g2_nand2_1
X_15791_ _07041_ _06999_ _07039_ VPWR VGND sg13g2_xnor2_1
X_17530_ _08663_ _08652_ _08662_ VPWR VGND sg13g2_xnor2_1
X_14742_ _06031_ u_FIR.sum\[4\]\[9\] net398 VPWR VGND sg13g2_nand2_1
X_11954_ VPWR _03375_ u_FIR.w\[0\]\[6\] VGND sg13g2_inv_1
X_23012__1189 VPWR VGND net1188 sg13g2_tiehi
XFILLER_18_968 VPWR VGND sg13g2_decap_8
XFILLER_17_445 VPWR VGND sg13g2_fill_1
XFILLER_72_540 VPWR VGND sg13g2_decap_4
XFILLER_44_242 VPWR VGND sg13g2_fill_1
XFILLER_72_562 VPWR VGND sg13g2_decap_8
X_17461_ _08593_ _08587_ _08594_ VPWR VGND sg13g2_nor2b_1
X_14673_ _05927_ _05963_ _05964_ VPWR VGND sg13g2_nor2b_1
X_11885_ VPWR _03306_ u_LMS.w\[6\]\[6\] VGND sg13g2_inv_1
X_19200_ net31 VPWR _10283_ VGND net29 _10282_ sg13g2_o21ai_1
X_16412_ _07628_ _07642_ _07643_ VPWR VGND sg13g2_nor2b_1
X_13624_ _04954_ _04924_ _04953_ VPWR VGND sg13g2_xnor2_1
XFILLER_60_757 VPWR VGND sg13g2_decap_8
X_17392_ VGND VPWR u_LMS.w\[0\]\[21\] net313 _08539_ _08524_ sg13g2_a21oi_1
XFILLER_73_1053 VPWR VGND sg13g2_decap_8
X_19131_ _10218_ _03330_ _10191_ VPWR VGND sg13g2_nand2_1
XFILLER_41_971 VPWR VGND sg13g2_decap_8
X_16343_ _07575_ VPWR _07577_ VGND _07544_ _07546_ sg13g2_o21ai_1
X_13555_ VGND VPWR net523 _04885_ _00104_ _04886_ sg13g2_a21oi_1
X_12506_ _03879_ _03858_ _03881_ VPWR VGND sg13g2_xor2_1
X_19062_ VGND VPWR _10143_ _10147_ _10149_ _10148_ sg13g2_a21oi_1
X_16274_ _07510_ _07481_ _07509_ VPWR VGND sg13g2_xnor2_1
X_13486_ net1022 VPWR _04821_ VGND net516 u_FIR.sum\[3\]\[1\] sg13g2_o21ai_1
X_18013_ VGND VPWR _09135_ _09136_ _00312_ net920 sg13g2_a21oi_1
X_15225_ _06495_ _06458_ _06461_ VPWR VGND sg13g2_nand2_1
X_12437_ _03812_ _03788_ _03814_ VPWR VGND sg13g2_xor2_1
XFILLER_126_531 VPWR VGND sg13g2_decap_8
X_15156_ net820 u_FIR.w\[2\]\[1\] _06426_ _06428_ VPWR VGND sg13g2_a21o_1
XFILLER_5_850 VPWR VGND sg13g2_fill_2
X_12368_ _03707_ _03710_ _03746_ _03747_ VPWR VGND sg13g2_or3_1
XFILLER_99_415 VPWR VGND sg13g2_fill_2
X_23301__1301 VPWR VGND net1300 sg13g2_tiehi
X_14107_ _05418_ net762 net851 VPWR VGND sg13g2_nand2_1
X_19964_ _10995_ VPWR _11005_ VGND _10962_ _10996_ sg13g2_o21ai_1
X_15087_ _06361_ _06321_ _06359_ VPWR VGND sg13g2_xnor2_1
X_12299_ _03665_ _03667_ _03679_ VPWR VGND sg13g2_and2_1
X_18915_ _09962_ _10001_ _10002_ VPWR VGND sg13g2_nor2_1
X_14038_ _05351_ _05350_ _05343_ VPWR VGND sg13g2_nand2b_1
X_19895_ net425 _03236_ net191 net161 _10936_ VPWR VGND sg13g2_nor4_1
XFILLER_95_610 VPWR VGND sg13g2_decap_8
X_18846_ _03257_ _07991_ _09933_ VPWR VGND sg13g2_nor2_1
XFILLER_110_987 VPWR VGND sg13g2_decap_4
X_23334__1268 VPWR VGND net1267 sg13g2_tiehi
X_18777_ _09857_ VPWR _09864_ VGND _09773_ _09858_ sg13g2_o21ai_1
X_15989_ net799 net886 net797 _07230_ VPWR VGND net899 sg13g2_nand4_1
XFILLER_76_890 VPWR VGND sg13g2_fill_2
X_17728_ _08832_ _08860_ _08861_ VPWR VGND sg13g2_nor2_1
XFILLER_35_220 VPWR VGND sg13g2_decap_4
XFILLER_91_860 VPWR VGND sg13g2_fill_1
X_17659_ _08790_ _08791_ _08792_ VPWR VGND sg13g2_nor2b_1
XFILLER_35_275 VPWR VGND sg13g2_fill_2
XFILLER_63_595 VPWR VGND sg13g2_fill_1
XFILLER_23_426 VPWR VGND sg13g2_fill_2
X_20670_ _01275_ _01273_ _01310_ VPWR VGND sg13g2_xor2_1
XFILLER_23_459 VPWR VGND sg13g2_decap_4
X_23728__1320 VPWR VGND net1319 sg13g2_tiehi
X_19329_ VGND VPWR _10391_ _10392_ _10393_ _10385_ sg13g2_a21oi_1
X_22340_ _02914_ _02915_ _00482_ VPWR VGND sg13g2_nor2_1
X_22271_ _02759_ VPWR _02861_ VGND _02761_ _02820_ sg13g2_o21ai_1
XFILLER_128_49 VPWR VGND sg13g2_decap_8
X_21222_ VGND VPWR _01839_ _01837_ _01836_ sg13g2_or2_1
XFILLER_132_501 VPWR VGND sg13g2_decap_8
X_21153_ net427 net131 _01770_ VPWR VGND sg13g2_nor2_1
Xfanout601 u_LMS.x_r\[7\]\[2\] net601 VPWR VGND sg13g2_buf_1
X_20104_ _11143_ _11144_ _11145_ VPWR VGND sg13g2_nor2_1
Xfanout612 net613 net612 VPWR VGND sg13g2_buf_1
XFILLER_132_578 VPWR VGND sg13g2_decap_8
XFILLER_101_910 VPWR VGND sg13g2_fill_2
X_21084_ _01711_ u_LMS.w\[6\]\[2\] _01508_ VPWR VGND sg13g2_xnor2_1
Xfanout623 u_LMS.x_r\[5\]\[7\] net623 VPWR VGND sg13g2_buf_1
Xclkbuf_4_11_0_clkA clknet_0_clkA clknet_4_11_0_clkA VPWR VGND sg13g2_buf_8
Xfanout634 net635 net634 VPWR VGND sg13g2_buf_1
Xfanout645 u_LMS.x_r\[4\]\[4\] net645 VPWR VGND sg13g2_buf_1
Xfanout656 u_LMS.x_r\[3\]\[5\] net656 VPWR VGND sg13g2_buf_1
X_20035_ _11066_ VPWR _11076_ VGND _11067_ _11075_ sg13g2_o21ai_1
Xfanout667 u_LMS.x_r\[3\]\[0\] net667 VPWR VGND sg13g2_buf_1
XFILLER_101_965 VPWR VGND sg13g2_fill_1
Xfanout678 u_LMS.x_r\[2\]\[2\] net678 VPWR VGND sg13g2_buf_1
Xfanout689 net690 net689 VPWR VGND sg13g2_buf_1
XFILLER_101_987 VPWR VGND sg13g2_fill_1
XFILLER_85_153 VPWR VGND sg13g2_decap_4
XFILLER_37_46 VPWR VGND sg13g2_decap_4
XFILLER_27_710 VPWR VGND sg13g2_decap_8
XFILLER_2_1013 VPWR VGND sg13g2_decap_8
XFILLER_96_1020 VPWR VGND sg13g2_fill_1
XFILLER_39_592 VPWR VGND sg13g2_fill_1
XFILLER_27_732 VPWR VGND sg13g2_decap_8
X_21986_ _02578_ _02579_ _02580_ VPWR VGND sg13g2_nor2_1
X_23725_ net1342 VGND VPWR _00787_ u_s2p_input.reg_sh\[6\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
X_20937_ _01577_ _01576_ _01532_ VPWR VGND sg13g2_xnor2_1
XFILLER_82_882 VPWR VGND sg13g2_decap_8
X_23656_ net985 VGND VPWR _00718_ u_debug_unit.mon_w3_sync\[1\] clknet_leaf_53_clkA
+ sg13g2_dfrbpq_1
X_20868_ _01508_ net621 net261 VPWR VGND sg13g2_nand2_1
X_22607_ net462 debug_load_bus\[5\] _03059_ _00605_ VPWR VGND sg13g2_mux2_1
X_23587_ net967 VGND VPWR _00649_ coeff_force_packed\[29\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_20799_ _03233_ _03234_ net179 _01439_ VGND VPWR net160 sg13g2_nor4_2
X_13340_ _04684_ _04681_ _04682_ VPWR VGND sg13g2_nand2_1
X_22538_ net916 _03023_ _03024_ _00571_ VPWR VGND sg13g2_nor3_1
X_23412__1113 VPWR VGND net1112 sg13g2_tiehi
XFILLER_127_317 VPWR VGND sg13g2_decap_8
XFILLER_10_665 VPWR VGND sg13g2_decap_8
XFILLER_10_687 VPWR VGND sg13g2_decap_8
X_13271_ VPWR _04617_ _04616_ VGND sg13g2_inv_1
X_22469_ net960 VPWR _02984_ VGND net448 net605 sg13g2_o21ai_1
XFILLER_120_1040 VPWR VGND sg13g2_decap_8
X_15010_ net979 VPWR _06287_ VGND net484 u_FIR.sum\[6\]\[2\] sg13g2_o21ai_1
X_12222_ _03606_ _03605_ _03604_ VPWR VGND sg13g2_nand2b_1
X_12153_ _03559_ _03560_ _03557_ _03562_ VPWR VGND _03561_ sg13g2_nand4_1
XFILLER_78_31 VPWR VGND sg13g2_decap_8
X_16961_ _08117_ _08112_ _08115_ VPWR VGND sg13g2_xnor2_1
X_12084_ _03495_ _03496_ _03494_ _03497_ VPWR VGND sg13g2_nand3_1
XFILLER_96_429 VPWR VGND sg13g2_fill_2
XFILLER_78_86 VPWR VGND sg13g2_fill_1
X_18700_ _09787_ net656 net80 VPWR VGND sg13g2_nand2_1
X_15912_ _07158_ _07149_ _07156_ VPWR VGND sg13g2_xnor2_1
X_19680_ VPWR _10744_ _10743_ VGND sg13g2_inv_1
XFILLER_76_120 VPWR VGND sg13g2_decap_8
XFILLER_49_334 VPWR VGND sg13g2_fill_2
X_16892_ _08038_ VPWR _08048_ VGND _08005_ _08039_ sg13g2_o21ai_1
XFILLER_77_665 VPWR VGND sg13g2_decap_4
X_18631_ _09728_ net370 _09680_ VPWR VGND sg13g2_nand2_1
X_15843_ _07091_ net784 net804 VPWR VGND sg13g2_nand2_1
X_18562_ net69 u_LMS.w\[2\]\[22\] _09672_ VPWR VGND sg13g2_xor2_1
X_15774_ _07024_ net786 net819 VPWR VGND sg13g2_nand2_1
X_12986_ _04343_ _04324_ u_FIR.sum\[0\]\[14\] VPWR VGND sg13g2_nand2b_1
X_17513_ _08646_ _08645_ _08633_ VPWR VGND sg13g2_nand2b_1
X_14725_ net849 _06013_ net767 _06014_ VPWR VGND sg13g2_nand3_1
XFILLER_27_90 VPWR VGND sg13g2_decap_8
X_18493_ _03336_ _09602_ _09603_ VPWR VGND sg13g2_nor2_1
X_11937_ VPWR _03358_ net722 VGND sg13g2_inv_1
XFILLER_73_893 VPWR VGND sg13g2_fill_2
X_17444_ net364 VPWR _08579_ VGND u_LMS.w\[0\]\[10\] net382 sg13g2_o21ai_1
XFILLER_60_543 VPWR VGND sg13g2_fill_1
X_14656_ _05947_ _05940_ _05945_ VPWR VGND sg13g2_xnor2_1
X_11868_ VPWR _03289_ u_LMS.x\[1\] VGND sg13g2_inv_1
XFILLER_33_779 VPWR VGND sg13g2_fill_1
X_13607_ _04937_ _04895_ _04935_ VPWR VGND sg13g2_xnor2_1
X_17375_ VGND VPWR u_LMS.w\[0\]\[18\] net313 _08525_ _08524_ sg13g2_a21oi_1
X_14587_ _05843_ _05879_ _05880_ VPWR VGND sg13g2_nor2_1
X_11799_ VPWR _03220_ net594 VGND sg13g2_inv_1
X_19114_ VGND VPWR _10110_ _10200_ _10201_ _10119_ sg13g2_a21oi_1
X_16326_ _07560_ _07559_ _07553_ VPWR VGND sg13g2_nand2b_1
X_13538_ _04847_ _04849_ _04870_ VPWR VGND sg13g2_and2_1
XFILLER_118_306 VPWR VGND sg13g2_fill_1
X_19045_ VGND VPWR _10128_ _10130_ _10132_ _10131_ sg13g2_a21oi_1
X_16257_ _07493_ _07492_ _07488_ VPWR VGND sg13g2_nand2b_1
X_13469_ _04807_ _04803_ _04808_ VPWR VGND sg13g2_xor2_1
X_15208_ _06479_ _06478_ _06437_ VPWR VGND sg13g2_nand2b_1
X_16188_ VPWR _07426_ _07425_ VGND sg13g2_inv_1
XFILLER_126_361 VPWR VGND sg13g2_fill_1
XFILLER_99_212 VPWR VGND sg13g2_decap_4
X_15139_ _06405_ _06408_ _06411_ VPWR VGND sg13g2_nor2_1
XFILLER_114_578 VPWR VGND sg13g2_decap_8
X_19947_ _10967_ VPWR _10988_ VGND _10964_ _10968_ sg13g2_o21ai_1
XFILLER_96_930 VPWR VGND sg13g2_fill_1
XFILLER_96_952 VPWR VGND sg13g2_fill_2
X_19878_ _10922_ _10923_ _00390_ VPWR VGND sg13g2_nor2_1
XFILLER_83_602 VPWR VGND sg13g2_decap_4
XFILLER_28_507 VPWR VGND sg13g2_fill_1
X_18829_ _09916_ _09913_ _09915_ VPWR VGND sg13g2_nand2_1
X_23065__1109 VPWR VGND net1108 sg13g2_tiehi
XFILLER_67_186 VPWR VGND sg13g2_decap_8
X_21840_ VGND VPWR _02434_ _02432_ _02431_ sg13g2_or2_1
XFILLER_83_668 VPWR VGND sg13g2_fill_1
XFILLER_64_871 VPWR VGND sg13g2_fill_1
X_21771_ _03217_ net131 _02365_ VPWR VGND sg13g2_nor2_1
XFILLER_130_28 VPWR VGND sg13g2_decap_8
X_23510_ net1376 VGND VPWR _00572_ u_LMS.count\[13\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
X_20722_ _01328_ _01322_ _01362_ VPWR VGND sg13g2_xor2_1
XFILLER_12_919 VPWR VGND sg13g2_decap_8
X_23441_ net1608 VGND VPWR _00503_ u_LMS.x_r\[2\]\[0\] clknet_leaf_64_clkA sg13g2_dfrbpq_1
X_20653_ _01284_ VPWR _01293_ VGND _01281_ _01285_ sg13g2_o21ai_1
XFILLER_23_26 VPWR VGND sg13g2_fill_1
XFILLER_20_930 VPWR VGND sg13g2_fill_1
XFILLER_32_790 VPWR VGND sg13g2_decap_8
X_23372_ net1229 VGND VPWR _00434_ u_LMS.w\[6\]\[5\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
X_20584_ _01224_ _01223_ _01203_ VPWR VGND sg13g2_nand2b_1
XFILLER_104_1035 VPWR VGND sg13g2_fill_2
XFILLER_104_1057 VPWR VGND sg13g2_decap_4
X_22323_ net357 VPWR _02903_ VGND u_LMS.w\[8\]\[3\] net374 sg13g2_o21ai_1
X_22254_ _02848_ net48 _02847_ VPWR VGND sg13g2_nand2_2
XFILLER_2_105 VPWR VGND sg13g2_decap_8
X_21205_ _01811_ _01821_ _01822_ VPWR VGND sg13g2_and2_1
X_22185_ _02779_ _02686_ _02692_ VPWR VGND sg13g2_xnor2_1
XFILLER_3_7 VPWR VGND sg13g2_decap_8
XFILLER_132_331 VPWR VGND sg13g2_decap_8
XFILLER_79_919 VPWR VGND sg13g2_fill_2
XFILLER_132_342 VPWR VGND sg13g2_decap_8
X_21136_ _01751_ _01745_ _01753_ VPWR VGND sg13g2_xor2_1
Xfanout420 _03260_ net420 VPWR VGND sg13g2_buf_1
Xfanout431 net439 net431 VPWR VGND sg13g2_buf_1
Xfanout442 net445 net442 VPWR VGND sg13g2_buf_1
X_21067_ net17 VPWR _01698_ VGND net15 _01697_ sg13g2_o21ai_1
Xfanout453 net457 net453 VPWR VGND sg13g2_buf_1
XFILLER_58_120 VPWR VGND sg13g2_fill_2
XFILLER_24_1014 VPWR VGND sg13g2_fill_1
Xfanout464 spi_wdata\[4\] net464 VPWR VGND sg13g2_buf_1
Xfanout475 net478 net475 VPWR VGND sg13g2_buf_1
XFILLER_59_665 VPWR VGND sg13g2_fill_2
XFILLER_47_805 VPWR VGND sg13g2_fill_1
XFILLER_24_1036 VPWR VGND sg13g2_fill_2
Xfanout486 net487 net486 VPWR VGND sg13g2_buf_1
XFILLER_101_773 VPWR VGND sg13g2_decap_4
X_20018_ net425 _03236_ _08068_ net211 _11059_ VPWR VGND sg13g2_nor4_1
Xfanout497 net499 net497 VPWR VGND sg13g2_buf_1
XFILLER_100_261 VPWR VGND sg13g2_fill_2
X_23500__1413 VPWR VGND net1412 sg13g2_tiehi
XFILLER_100_294 VPWR VGND sg13g2_fill_2
X_12840_ _04202_ _04169_ _04201_ VPWR VGND sg13g2_nand2b_1
XFILLER_64_44 VPWR VGND sg13g2_fill_1
X_12771_ VGND VPWR _04093_ _04100_ _04134_ _04109_ sg13g2_a21oi_1
X_21969_ VGND VPWR _02550_ _02562_ _02563_ _02549_ sg13g2_a21oi_1
XFILLER_14_201 VPWR VGND sg13g2_decap_8
XFILLER_54_370 VPWR VGND sg13g2_fill_1
X_14510_ net862 net773 u_FIR.sum\[4\]\[3\] _05805_ VPWR VGND sg13g2_a21o_1
XFILLER_70_841 VPWR VGND sg13g2_decap_8
XFILLER_54_392 VPWR VGND sg13g2_decap_4
X_23708_ net1460 VGND VPWR _00770_ u_p2s_output.reg_cnt\[2\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
X_15490_ _06749_ net791 net888 u_FIR.sum\[6\]\[1\] VPWR VGND sg13g2_and3_1
XFILLER_15_768 VPWR VGND sg13g2_decap_8
XFILLER_14_245 VPWR VGND sg13g2_fill_2
X_23290__1316 VPWR VGND net1315 sg13g2_tiehi
XFILLER_9_28 VPWR VGND sg13g2_decap_8
X_23639_ net1010 VGND VPWR _00701_ u_debug_unit.mon_w0_sync\[5\] clknet_leaf_17_clkA
+ sg13g2_dfrbpq_1
X_14441_ _05740_ _05741_ _05742_ VPWR VGND sg13g2_nor2b_1
XFILLER_42_587 VPWR VGND sg13g2_decap_8
XFILLER_14_278 VPWR VGND sg13g2_fill_1
Xfanout60 net61 net60 VPWR VGND sg13g2_buf_2
Xfanout71 net71 net72 VPWR VGND sg13g2_buf_4
Xfanout82 net82 net89 VPWR VGND sg13g2_buf_4
X_17160_ _08316_ _08313_ _08315_ VPWR VGND sg13g2_nand2_1
X_14372_ VGND VPWR _05676_ _05674_ _05673_ sg13g2_or2_1
Xfanout93 net97 net93 VPWR VGND sg13g2_buf_1
XFILLER_6_400 VPWR VGND sg13g2_decap_4
X_16111_ _07351_ _07350_ _07310_ VPWR VGND sg13g2_nand2b_1
X_13323_ _04668_ _04636_ _04667_ VPWR VGND sg13g2_xnor2_1
XFILLER_13_70 VPWR VGND sg13g2_decap_8
X_17091_ VPWR _08247_ _08246_ VGND sg13g2_inv_1
XFILLER_7_956 VPWR VGND sg13g2_fill_2
XFILLER_129_70 VPWR VGND sg13g2_decap_8
X_16042_ _07283_ _07282_ _07273_ _07281_ net799 VPWR VGND sg13g2_a22oi_1
X_13254_ _04600_ net741 net842 VPWR VGND sg13g2_nand2_1
XFILLER_127_169 VPWR VGND sg13g2_fill_1
X_12205_ _03591_ net912 net918 _00049_ VPWR VGND sg13g2_a21o_1
X_13185_ _04531_ _04532_ _04533_ VPWR VGND sg13g2_and2_1
XFILLER_97_705 VPWR VGND sg13g2_fill_1
X_19801_ _10863_ net310 u_LMS.w\[4\]\[14\] coeff_force_packed\[30\] net562 VPWR VGND
+ sg13g2_a22oi_1
X_12136_ _03543_ _03544_ _03542_ _03546_ VPWR VGND _03545_ sg13g2_nand4_1
XFILLER_9_1019 VPWR VGND sg13g2_decap_8
XFILLER_124_887 VPWR VGND sg13g2_fill_2
X_17993_ _09069_ _09119_ _09120_ VPWR VGND sg13g2_nor2b_1
XFILLER_36_7 VPWR VGND sg13g2_decap_8
XFILLER_123_375 VPWR VGND sg13g2_decap_8
XFILLER_97_749 VPWR VGND sg13g2_decap_8
X_19732_ u_LMS.w\[4\]\[11\] _10755_ _10796_ VPWR VGND sg13g2_nor2_1
XFILLER_1_171 VPWR VGND sg13g2_decap_4
X_16944_ _08100_ _08089_ _08095_ VPWR VGND sg13g2_xnor2_1
X_12067_ _03476_ _03477_ _03467_ _03481_ VPWR VGND _03480_ sg13g2_nand4_1
XFILLER_49_153 VPWR VGND sg13g2_decap_8
X_19663_ VGND VPWR _10599_ _10727_ _10726_ _10725_ sg13g2_a21oi_2
XFILLER_37_304 VPWR VGND sg13g2_decap_8
X_16875_ _08010_ VPWR _08031_ VGND _08007_ _08011_ sg13g2_o21ai_1
XFILLER_92_410 VPWR VGND sg13g2_fill_1
XFILLER_38_838 VPWR VGND sg13g2_fill_1
X_18614_ _09714_ net33 net35 _09715_ VPWR VGND sg13g2_a21o_1
XFILLER_64_123 VPWR VGND sg13g2_decap_4
X_15826_ _07068_ _07074_ _07075_ VPWR VGND sg13g2_nor2b_1
X_19594_ _10658_ net168 net652 net187 net650 VPWR VGND sg13g2_a22oi_1
XFILLER_46_860 VPWR VGND sg13g2_fill_1
X_18545_ VPWR _09655_ _09654_ VGND sg13g2_inv_1
X_15757_ _07008_ _06977_ _07007_ VPWR VGND sg13g2_xnor2_1
XFILLER_64_189 VPWR VGND sg13g2_decap_8
X_12969_ _04327_ _04326_ _04298_ VPWR VGND sg13g2_nand2b_1
XFILLER_33_510 VPWR VGND sg13g2_decap_4
X_23061__1115 VPWR VGND net1114 sg13g2_tiehi
XFILLER_61_830 VPWR VGND sg13g2_decap_8
XFILLER_45_381 VPWR VGND sg13g2_decap_8
XFILLER_127_1002 VPWR VGND sg13g2_decap_8
X_14708_ _05998_ _05969_ _05997_ VPWR VGND sg13g2_nand2b_1
X_18476_ VGND VPWR _09292_ net2089 _09586_ _09291_ sg13g2_a21oi_1
X_15688_ _06940_ _06904_ _06907_ VPWR VGND sg13g2_nand2_1
X_17427_ VGND VPWR net58 _08565_ _08566_ net42 sg13g2_a21oi_1
X_14639_ _05916_ VPWR _05930_ VGND _05867_ _05906_ sg13g2_o21ai_1
X_23266__1362 VPWR VGND net1361 sg13g2_tiehi
XFILLER_20_226 VPWR VGND sg13g2_fill_2
XFILLER_20_248 VPWR VGND sg13g2_fill_1
X_17358_ net46 VPWR _08511_ VGND net44 _08510_ sg13g2_o21ai_1
X_16309_ _07517_ _07543_ _07544_ VPWR VGND sg13g2_nor2_1
X_17289_ _08445_ u_LMS.w\[0\]\[7\] _08423_ VPWR VGND sg13g2_xnor2_1
Xclkload30 clkload30/Y clknet_leaf_5_clkA VPWR VGND sg13g2_inv_2
XFILLER_62_0 VPWR VGND sg13g2_decap_8
Xclkload41 clknet_leaf_23_clkA clkload41/Y VPWR VGND sg13g2_inv_4
X_19028_ _10113_ _10109_ _10114_ _10115_ VPWR VGND sg13g2_a21o_1
Xclkload52 VPWR clkload52/Y clknet_3_1__leaf_spi_sclk VGND sg13g2_inv_1
XFILLER_115_821 VPWR VGND sg13g2_fill_1
XFILLER_47_1014 VPWR VGND sg13g2_decap_8
XFILLER_47_1036 VPWR VGND sg13g2_fill_2
XFILLER_87_204 VPWR VGND sg13g2_decap_8
XFILLER_125_28 VPWR VGND sg13g2_decap_8
XFILLER_88_749 VPWR VGND sg13g2_decap_8
XFILLER_130_846 VPWR VGND sg13g2_fill_2
XFILLER_87_237 VPWR VGND sg13g2_decap_8
XFILLER_68_451 VPWR VGND sg13g2_decap_4
X_22941_ _03202_ net323 u_spi_slave.rx_shift\[4\] u_spi_slave.rx_shift\[12\] net428
+ VPWR VGND sg13g2_a22oi_1
XFILLER_29_838 VPWR VGND sg13g2_fill_2
XFILLER_18_26 VPWR VGND sg13g2_fill_2
XFILLER_84_944 VPWR VGND sg13g2_fill_2
XFILLER_83_421 VPWR VGND sg13g2_fill_1
XFILLER_55_112 VPWR VGND sg13g2_fill_2
X_22872_ u_p2s_output.reg_cnt\[1\] u_p2s_output.reg_cnt\[2\] _03162_ VPWR VGND u_p2s_output.reg_cnt\[0\]
+ sg13g2_nand3b_1
XFILLER_44_819 VPWR VGND sg13g2_fill_2
XFILLER_37_860 VPWR VGND sg13g2_fill_1
X_21823_ _02416_ _02386_ _02417_ VPWR VGND sg13g2_xor2_1
XFILLER_70_148 VPWR VGND sg13g2_fill_2
X_21754_ _02346_ _02340_ _02348_ VPWR VGND sg13g2_xor2_1
X_20705_ _01345_ net609 net245 VPWR VGND sg13g2_nand2_1
X_21685_ VGND VPWR _02291_ _02292_ _00450_ net933 sg13g2_a21oi_1
X_23424_ net1076 VGND VPWR _00486_ u_LMS.w\[8\]\[11\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
XFILLER_11_248 VPWR VGND sg13g2_fill_1
X_20636_ _01276_ _01275_ _01273_ VPWR VGND sg13g2_nand2b_1
Xclkload2 clknet_4_3_0_clkA clkload2/X VPWR VGND sg13g2_buf_8
XFILLER_109_114 VPWR VGND sg13g2_fill_1
X_23355_ net1246 VGND VPWR _00417_ u_LMS.w\[5\]\[11\] clknet_leaf_11_clkA sg13g2_dfrbpq_1
XFILLER_50_46 VPWR VGND sg13g2_decap_8
X_20567_ _01203_ VPWR _01207_ VGND _01204_ _01205_ sg13g2_o21ai_1
X_22306_ VGND VPWR _02888_ _02889_ _00474_ net924 sg13g2_a21oi_1
X_23286_ net1322 VGND VPWR _00348_ u_LMS.w\[2\]\[11\] clknet_leaf_64_clkA sg13g2_dfrbpq_1
XFILLER_106_821 VPWR VGND sg13g2_fill_1
X_20498_ _01141_ _01022_ _01024_ VPWR VGND sg13g2_xnor2_1
XFILLER_105_320 VPWR VGND sg13g2_decap_8
X_22237_ _02831_ u_LMS.w\[8\]\[21\] net61 VPWR VGND sg13g2_nand2_1
XFILLER_105_342 VPWR VGND sg13g2_decap_8
XFILLER_79_705 VPWR VGND sg13g2_decap_4
XFILLER_59_44 VPWR VGND sg13g2_fill_1
XFILLER_132_150 VPWR VGND sg13g2_decap_8
X_22168_ _02762_ _02725_ _02726_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_824 VPWR VGND sg13g2_decap_4
XFILLER_120_312 VPWR VGND sg13g2_fill_2
X_21119_ _01736_ _01737_ _00439_ VPWR VGND sg13g2_nor2_1
X_22099_ _02686_ _02692_ _02693_ VPWR VGND sg13g2_nor2_1
Xfanout250 _06539_ net250 VPWR VGND sg13g2_buf_1
X_14990_ _06266_ _06260_ _06268_ VPWR VGND sg13g2_xor2_1
Xfanout261 net262 net261 VPWR VGND sg13g2_buf_1
Xfanout272 _07486_ net272 VPWR VGND sg13g2_buf_1
Xfanout283 _04691_ net283 VPWR VGND sg13g2_buf_1
X_13941_ _05260_ _05249_ _05261_ VPWR VGND sg13g2_nor2b_1
XFILLER_75_922 VPWR VGND sg13g2_fill_2
Xfanout294 _03428_ net294 VPWR VGND sg13g2_buf_1
XFILLER_46_123 VPWR VGND sg13g2_fill_2
X_16660_ VGND VPWR u_LMS.w\[6\]\[13\] _07832_ _07836_ _07833_ sg13g2_a21oi_1
XFILLER_46_134 VPWR VGND sg13g2_decap_8
X_13872_ _05195_ u_FIR.sum\[2\]\[13\] net402 VPWR VGND sg13g2_nand2_1
XFILLER_90_903 VPWR VGND sg13g2_fill_2
XFILLER_90_914 VPWR VGND sg13g2_decap_8
X_15611_ _06865_ _06864_ _06861_ VPWR VGND sg13g2_nand2b_1
X_12823_ _04182_ _04184_ _04185_ VPWR VGND sg13g2_nor2b_1
X_16591_ VGND VPWR net492 _07783_ _00242_ _07784_ sg13g2_a21oi_1
XFILLER_15_510 VPWR VGND sg13g2_decap_8
XFILLER_90_958 VPWR VGND sg13g2_decap_8
XFILLER_131_60 VPWR VGND sg13g2_decap_8
X_18330_ _09440_ net422 _09405_ VPWR VGND sg13g2_xnor2_1
XFILLER_15_532 VPWR VGND sg13g2_fill_2
X_15542_ _06798_ net788 net872 VPWR VGND sg13g2_nand2_1
X_12754_ _04117_ _04114_ _04118_ VPWR VGND sg13g2_nor2b_1
X_23221__1443 VPWR VGND net1442 sg13g2_tiehi
X_18261_ net200 _09370_ net672 _09371_ VPWR VGND sg13g2_nand3_1
X_15473_ _06720_ _06726_ _06734_ VPWR VGND sg13g2_nor2_1
X_12685_ net1037 VPWR _04051_ VGND net541 u_FIR.sum\[1\]\[5\] sg13g2_o21ai_1
X_17212_ _08365_ _08366_ _08368_ VPWR VGND sg13g2_nor2b_1
X_14424_ _05701_ VPWR _05726_ VGND net277 _05699_ sg13g2_o21ai_1
X_18192_ _09302_ _09299_ _09300_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_401 VPWR VGND sg13g2_fill_2
XFILLER_128_423 VPWR VGND sg13g2_decap_8
X_17143_ VGND VPWR _08294_ _08295_ _08299_ _08298_ sg13g2_a21oi_1
X_14355_ _05634_ _05659_ _05660_ VPWR VGND sg13g2_nor2_1
XFILLER_11_793 VPWR VGND sg13g2_decap_4
XFILLER_7_742 VPWR VGND sg13g2_fill_2
XFILLER_129_979 VPWR VGND sg13g2_decap_8
XFILLER_7_753 VPWR VGND sg13g2_decap_4
X_13306_ _04651_ _04650_ _04646_ VPWR VGND sg13g2_nand2b_1
X_17074_ _08208_ net2195 _08230_ VPWR VGND sg13g2_nor2_1
X_14286_ _05593_ _05566_ _05591_ VPWR VGND sg13g2_xnor2_1
XFILLER_109_670 VPWR VGND sg13g2_decap_8
XFILLER_109_681 VPWR VGND sg13g2_fill_2
X_16025_ _07266_ _07255_ _07265_ VPWR VGND sg13g2_nand2_1
X_13237_ _04584_ _04541_ _04582_ VPWR VGND sg13g2_xnor2_1
X_13168_ VGND VPWR _04478_ _04507_ _04516_ _04506_ sg13g2_a21oi_1
XFILLER_123_150 VPWR VGND sg13g2_fill_1
X_12119_ VPWR VGND sys_enable_bus\[2\] _03522_ net285 coeff_force_packed\[30\] _03530_
+ net287 sg13g2_a221oi_1
X_17976_ VGND VPWR _09105_ _09106_ _00305_ net923 sg13g2_a21oi_1
X_13099_ _04449_ net742 net867 VPWR VGND sg13g2_nand2_1
XFILLER_111_367 VPWR VGND sg13g2_decap_4
X_19715_ _10777_ _10778_ _10779_ VPWR VGND sg13g2_nor2_1
X_16927_ _08082_ _07988_ _08083_ VPWR VGND sg13g2_xor2_1
XFILLER_78_782 VPWR VGND sg13g2_decap_4
XFILLER_65_410 VPWR VGND sg13g2_fill_2
XFILLER_38_635 VPWR VGND sg13g2_fill_2
XFILLER_65_432 VPWR VGND sg13g2_fill_2
X_19646_ _10710_ _10709_ net196 _10708_ _10674_ VPWR VGND sg13g2_a22oi_1
X_16858_ _08006_ _08013_ _08014_ VPWR VGND sg13g2_and2_1
XFILLER_66_977 VPWR VGND sg13g2_decap_8
XFILLER_38_668 VPWR VGND sg13g2_fill_1
XFILLER_81_914 VPWR VGND sg13g2_decap_8
XFILLER_1_84 VPWR VGND sg13g2_decap_8
X_15809_ u_FIR.w\[1\]\[4\] net803 _07058_ VPWR VGND sg13g2_and2_1
XFILLER_80_413 VPWR VGND sg13g2_fill_1
XFILLER_53_627 VPWR VGND sg13g2_fill_1
X_19577_ _10641_ _10636_ _10640_ VPWR VGND sg13g2_xnor2_1
X_16789_ net2069 _07944_ _07945_ VPWR VGND sg13g2_and2_1
XFILLER_80_446 VPWR VGND sg13g2_fill_2
X_18528_ _09638_ _03336_ _09602_ VPWR VGND sg13g2_nand2_1
XFILLER_52_148 VPWR VGND sg13g2_decap_8
XFILLER_33_340 VPWR VGND sg13g2_fill_1
XFILLER_21_502 VPWR VGND sg13g2_decap_8
XFILLER_33_373 VPWR VGND sg13g2_fill_1
X_18459_ _09258_ VPWR _09569_ VGND _09259_ _09291_ sg13g2_o21ai_1
XFILLER_60_170 VPWR VGND sg13g2_decap_8
XFILLER_60_192 VPWR VGND sg13g2_decap_8
X_21470_ _03226_ net236 net229 _02083_ _02087_ VPWR VGND sg13g2_nor4_1
XFILLER_21_579 VPWR VGND sg13g2_fill_1
X_20421_ _01082_ net316 u_LMS.w\[5\]\[14\] coeff_force_packed\[37\] net564 VPWR VGND
+ sg13g2_a22oi_1
X_23140_ net1579 VGND VPWR _00202_ u_FIR.sum\[8\]\[12\] clknet_leaf_44_clkA sg13g2_dfrbpq_1
X_20352_ _01015_ _01014_ _01013_ VPWR VGND sg13g2_nand2b_1
X_23071_ net1099 VGND VPWR _00133_ u_FIR.sum\[4\]\[14\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
X_20283_ _00942_ VPWR _00946_ VGND _11187_ _00943_ sg13g2_o21ai_1
X_22022_ _02616_ _02608_ _02615_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_406 VPWR VGND sg13g2_decap_4
XFILLER_115_695 VPWR VGND sg13g2_fill_1
XFILLER_103_846 VPWR VGND sg13g2_decap_8
XFILLER_130_676 VPWR VGND sg13g2_fill_1
XFILLER_96_590 VPWR VGND sg13g2_fill_1
X_22924_ _00791_ u_spi_slave.rd_toggle _03190_ VPWR VGND sg13g2_xnor2_1
XFILLER_83_251 VPWR VGND sg13g2_decap_8
XFILLER_71_402 VPWR VGND sg13g2_decap_8
XFILLER_16_318 VPWR VGND sg13g2_fill_1
X_22855_ net971 VPWR _03150_ VGND u_p2s_output.reg_sh\[2\] net300 sg13g2_o21ai_1
XFILLER_72_958 VPWR VGND sg13g2_decap_4
XFILLER_45_46 VPWR VGND sg13g2_decap_8
X_21806_ _02400_ _02386_ _02398_ VPWR VGND sg13g2_xnor2_1
XFILLER_43_159 VPWR VGND sg13g2_fill_2
X_22786_ u_debug_unit.mon_w5_sync\[2\] net347 _03111_ VPWR VGND sg13g2_nor2_1
XFILLER_40_811 VPWR VGND sg13g2_fill_2
X_21737_ _02332_ _02213_ _02215_ VPWR VGND sg13g2_xnor2_1
X_23347__1255 VPWR VGND net1254 sg13g2_tiehi
X_12470_ _03846_ _03826_ _03845_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_506 VPWR VGND sg13g2_decap_4
X_21668_ VGND VPWR _02275_ _02278_ _00447_ net931 sg13g2_a21oi_1
XFILLER_61_56 VPWR VGND sg13g2_decap_8
XFILLER_61_67 VPWR VGND sg13g2_fill_1
XFILLER_61_89 VPWR VGND sg13g2_fill_1
X_20619_ _01254_ _01253_ _01259_ VPWR VGND sg13g2_xor2_1
X_23407_ net1127 VGND VPWR _00469_ u_LMS.w\[8\]\[17\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
X_21599_ _02173_ VPWR _02216_ VGND _02214_ _02213_ sg13g2_o21ai_1
X_14140_ _05450_ net760 net863 VPWR VGND sg13g2_nand2_1
X_23338_ net1263 VGND VPWR _00400_ u_LMS.w\[5\]\[17\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
X_23708__1461 VPWR VGND net1460 sg13g2_tiehi
XFILLER_3_211 VPWR VGND sg13g2_decap_8
X_14071_ _05383_ _05377_ _05381_ VPWR VGND sg13g2_xnor2_1
X_23269_ net1355 VGND VPWR _00331_ u_LMS.w\[2\]\[17\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
XFILLER_3_244 VPWR VGND sg13g2_decap_8
X_13022_ VGND VPWR net521 _04374_ _00082_ _04375_ sg13g2_a21oi_1
XFILLER_10_60 VPWR VGND sg13g2_decap_4
XFILLER_105_172 VPWR VGND sg13g2_decap_8
XFILLER_117_1023 VPWR VGND sg13g2_fill_2
Xfanout1001 net1002 net1001 VPWR VGND sg13g2_buf_1
Xfanout1012 net1013 net1012 VPWR VGND sg13g2_buf_1
X_17830_ _08963_ _08961_ _08960_ VPWR VGND sg13g2_nand2b_1
XFILLER_79_568 VPWR VGND sg13g2_fill_1
Xfanout1023 net1025 net1023 VPWR VGND sg13g2_buf_1
Xfanout1034 net1042 net1034 VPWR VGND sg13g2_buf_1
XFILLER_94_516 VPWR VGND sg13g2_decap_8
XFILLER_120_153 VPWR VGND sg13g2_decap_8
X_17761_ _08886_ _08893_ _08894_ VPWR VGND sg13g2_nor2b_1
XFILLER_120_175 VPWR VGND sg13g2_decap_4
X_14973_ _06239_ u_FIR.sum\[4\]\[16\] _06222_ _06253_ VPWR VGND sg13g2_a21o_1
XFILLER_75_730 VPWR VGND sg13g2_fill_2
X_19500_ _10564_ _10562_ _10561_ VPWR VGND sg13g2_nand2b_1
XFILLER_75_741 VPWR VGND sg13g2_fill_2
X_16712_ net1029 VPWR _07875_ VGND net526 u_FIR.w\[8\]\[0\] sg13g2_o21ai_1
X_13924_ _05229_ _05244_ _05245_ VPWR VGND sg13g2_nor2b_1
XFILLER_19_80 VPWR VGND sg13g2_decap_8
X_17692_ _08823_ _08824_ _08825_ VPWR VGND sg13g2_nor2_1
XFILLER_75_774 VPWR VGND sg13g2_fill_2
XFILLER_63_914 VPWR VGND sg13g2_decap_4
XFILLER_19_91 VPWR VGND sg13g2_fill_2
X_19431_ _10495_ _10492_ _10493_ VPWR VGND sg13g2_xnor2_1
X_16643_ net1023 VPWR _07823_ VGND net518 net750 sg13g2_o21ai_1
X_13855_ _05150_ _05178_ _05179_ VPWR VGND sg13g2_nor2b_1
X_19362_ _10416_ _10425_ _10426_ VPWR VGND sg13g2_and2_1
X_12806_ VGND VPWR net544 _04167_ _00073_ _04168_ sg13g2_a21oi_1
X_16574_ u_LMS.w\[3\]\[23\] u_LMS.w\[3\]\[22\] net717 _07772_ VPWR VGND u_LMS.w\[3\]\[21\]
+ sg13g2_nand4_1
X_13786_ _05081_ _05111_ _05112_ VPWR VGND sg13g2_nor2_1
X_18313_ _09423_ _09422_ _09421_ VPWR VGND sg13g2_nand2b_1
XFILLER_43_671 VPWR VGND sg13g2_fill_2
X_15525_ VGND VPWR _06782_ _06781_ _06763_ sg13g2_or2_1
XFILLER_16_896 VPWR VGND sg13g2_fill_1
X_19293_ _10356_ _10350_ _10357_ VPWR VGND sg13g2_nor2b_1
X_12737_ _04101_ _04093_ _04100_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_1005 VPWR VGND sg13g2_decap_8
X_18244_ _09354_ _09351_ _09352_ VPWR VGND sg13g2_xnor2_1
X_15456_ VGND VPWR net500 _06717_ _00173_ _06718_ sg13g2_a21oi_1
XFILLER_129_710 VPWR VGND sg13g2_fill_1
X_12668_ _04034_ _03999_ _04032_ VPWR VGND sg13g2_xnor2_1
X_14407_ _05694_ _05709_ _05710_ VPWR VGND sg13g2_nor2b_1
XFILLER_129_743 VPWR VGND sg13g2_decap_4
X_18175_ VGND VPWR _09283_ _09284_ _09285_ _09280_ sg13g2_a21oi_1
X_15387_ _06653_ _06620_ _06651_ VPWR VGND sg13g2_xnor2_1
X_12599_ net1031 VPWR _03968_ VGND net531 u_FIR.sum\[1\]\[2\] sg13g2_o21ai_1
X_17126_ _08282_ net714 net231 VPWR VGND sg13g2_nand2_1
X_14338_ _05643_ _05606_ _05642_ VPWR VGND sg13g2_nand2_1
XFILLER_116_415 VPWR VGND sg13g2_decap_8
XFILLER_117_949 VPWR VGND sg13g2_decap_8
Xrebuffer2206 _10592_ net2205 VPWR VGND sg13g2_buf_1
Xrebuffer2217 net2217 net2216 VPWR VGND sg13g2_buf_1
X_17057_ _08213_ _08211_ _08212_ VPWR VGND sg13g2_nand2_1
XFILLER_116_459 VPWR VGND sg13g2_fill_1
X_14269_ _05574_ _05575_ _05576_ VPWR VGND sg13g2_and2_1
XFILLER_132_919 VPWR VGND sg13g2_decap_8
X_16008_ _07244_ _07246_ _07249_ VPWR VGND sg13g2_and2_1
XFILLER_98_877 VPWR VGND sg13g2_decap_8
XFILLER_97_354 VPWR VGND sg13g2_fill_1
XFILLER_111_142 VPWR VGND sg13g2_fill_2
XFILLER_57_207 VPWR VGND sg13g2_fill_1
XFILLER_97_376 VPWR VGND sg13g2_decap_4
XFILLER_25_0 VPWR VGND sg13g2_decap_8
XFILLER_131_1009 VPWR VGND sg13g2_decap_8
XFILLER_112_698 VPWR VGND sg13g2_decap_4
X_17959_ _09092_ _09087_ _09088_ _09091_ VPWR VGND sg13g2_and3_1
XFILLER_85_538 VPWR VGND sg13g2_fill_2
XFILLER_111_197 VPWR VGND sg13g2_decap_8
XFILLER_39_955 VPWR VGND sg13g2_decap_8
X_20970_ _01610_ _03305_ _01589_ VPWR VGND sg13g2_xnor2_1
XFILLER_54_903 VPWR VGND sg13g2_decap_4
XFILLER_65_251 VPWR VGND sg13g2_fill_1
XFILLER_54_925 VPWR VGND sg13g2_fill_1
XFILLER_81_711 VPWR VGND sg13g2_fill_2
XFILLER_81_722 VPWR VGND sg13g2_decap_4
XFILLER_66_796 VPWR VGND sg13g2_fill_2
X_19629_ _10693_ _10683_ _10685_ VPWR VGND sg13g2_xnor2_1
XFILLER_53_424 VPWR VGND sg13g2_fill_1
XFILLER_38_498 VPWR VGND sg13g2_fill_2
XFILLER_26_638 VPWR VGND sg13g2_decap_4
XFILLER_54_969 VPWR VGND sg13g2_decap_4
XFILLER_80_232 VPWR VGND sg13g2_decap_4
X_22640_ coeff_force_packed\[16\] net469 _03063_ _00634_ VPWR VGND sg13g2_mux2_1
XFILLER_41_608 VPWR VGND sg13g2_decap_8
XFILLER_80_287 VPWR VGND sg13g2_decap_4
X_22571_ _03045_ u_LMS.count\[25\] _03044_ VPWR VGND sg13g2_xnor2_1
X_21522_ _01861_ VPWR _02139_ VGND _01860_ _02137_ sg13g2_o21ai_1
X_21453_ net211 net601 _02042_ _02070_ VPWR VGND sg13g2_a21o_1
XFILLER_119_231 VPWR VGND sg13g2_decap_4
X_20404_ VGND VPWR _03316_ _03317_ _01067_ net76 sg13g2_a21oi_1
X_21384_ _01972_ VPWR _02001_ VGND _01904_ _01946_ sg13g2_o21ai_1
XFILLER_107_426 VPWR VGND sg13g2_decap_8
X_23123_ net1604 VGND VPWR _00185_ u_FIR.sum\[7\]\[9\] clknet_leaf_44_clkA sg13g2_dfrbpq_1
X_20335_ _00998_ _00926_ _00997_ VPWR VGND sg13g2_nand2_1
XFILLER_123_908 VPWR VGND sg13g2_fill_2
XFILLER_123_919 VPWR VGND sg13g2_fill_1
XFILLER_116_960 VPWR VGND sg13g2_fill_2
X_23054_ net1125 VGND VPWR _00116_ u_FIR.sum\[3\]\[16\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
X_20266_ _00907_ _00928_ _00929_ VPWR VGND sg13g2_nor2b_1
X_22005_ _02597_ _02598_ _02599_ VPWR VGND sg13g2_and2_1
X_20197_ _00858_ _00859_ _00860_ VPWR VGND sg13g2_nor2_1
XFILLER_89_899 VPWR VGND sg13g2_fill_2
XFILLER_69_590 VPWR VGND sg13g2_fill_2
XFILLER_5_1044 VPWR VGND sg13g2_decap_8
X_11970_ u_spi_slave.tx_cnt\[1\] u_spi_slave.tx_cnt\[0\] u_spi_slave.tx_active _03388_
+ _03390_ VPWR VGND sg13g2_and4_1
XFILLER_56_56 VPWR VGND sg13g2_decap_4
XFILLER_56_67 VPWR VGND sg13g2_fill_2
XFILLER_29_465 VPWR VGND sg13g2_decap_4
XFILLER_56_262 VPWR VGND sg13g2_decap_8
X_23253__1387 VPWR VGND net1386 sg13g2_tiehi
X_22907_ net1028 VPWR _03182_ VGND net553 u_s2p_input.reg_sh\[2\] sg13g2_o21ai_1
XFILLER_29_498 VPWR VGND sg13g2_fill_1
XFILLER_71_210 VPWR VGND sg13g2_fill_1
XFILLER_16_137 VPWR VGND sg13g2_decap_8
X_13640_ net879 _04968_ net749 _04969_ VPWR VGND sg13g2_nand3_1
XFILLER_71_243 VPWR VGND sg13g2_fill_2
X_22838_ net551 net411 _03137_ VPWR VGND sg13g2_nor2_1
XFILLER_13_811 VPWR VGND sg13g2_decap_4
XFILLER_53_991 VPWR VGND sg13g2_fill_2
X_13571_ _04900_ _04893_ _04902_ VPWR VGND sg13g2_xor2_1
XFILLER_71_298 VPWR VGND sg13g2_fill_1
XFILLER_13_833 VPWR VGND sg13g2_fill_1
X_22769_ VGND VPWR _07795_ net340 _00724_ _03102_ sg13g2_a21oi_1
X_15310_ _06576_ _06577_ _06578_ VPWR VGND sg13g2_nor2_1
X_12522_ _03896_ _03893_ _03894_ VPWR VGND sg13g2_xnor2_1
X_16290_ _07523_ _07524_ _07525_ VPWR VGND sg13g2_nor2_1
XFILLER_9_837 VPWR VGND sg13g2_decap_4
XFILLER_12_376 VPWR VGND sg13g2_decap_8
X_15241_ _06511_ _06503_ _06509_ VPWR VGND sg13g2_xnor2_1
Xclkbuf_leaf_24_clkA clknet_4_11_0_clkA clknet_leaf_24_clkA VPWR VGND sg13g2_buf_8
X_12453_ net812 VPWR _03829_ VGND net723 u_FIR.w\[8\]\[2\] sg13g2_o21ai_1
XFILLER_126_713 VPWR VGND sg13g2_decap_8
X_15172_ _06413_ _06443_ _06444_ VPWR VGND sg13g2_and2_1
X_12384_ net866 net719 _03760_ _03762_ VPWR VGND sg13g2_a21o_1
XFILLER_125_201 VPWR VGND sg13g2_fill_1
X_14123_ _05434_ _05424_ _05432_ VPWR VGND sg13g2_xnor2_1
XFILLER_67_1017 VPWR VGND sg13g2_fill_2
X_19980_ _11021_ _10984_ _11020_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_245 VPWR VGND sg13g2_decap_8
X_18931_ _10018_ _10014_ _10016_ VPWR VGND sg13g2_xnor2_1
X_14054_ VGND VPWR _05367_ _05366_ _05339_ sg13g2_or2_1
XFILLER_79_310 VPWR VGND sg13g2_decap_4
XFILLER_122_930 VPWR VGND sg13g2_decap_8
XFILLER_97_52 VPWR VGND sg13g2_decap_8
X_13005_ _04361_ _04357_ _04360_ VPWR VGND sg13g2_xnor2_1
XFILLER_122_952 VPWR VGND sg13g2_fill_2
X_18862_ _09948_ VPWR _09949_ VGND _09944_ _09945_ sg13g2_o21ai_1
XFILLER_97_85 VPWR VGND sg13g2_decap_4
XFILLER_79_365 VPWR VGND sg13g2_decap_4
XFILLER_121_462 VPWR VGND sg13g2_decap_4
X_17813_ _08934_ VPWR _08946_ VGND _08944_ _08945_ sg13g2_o21ai_1
XFILLER_0_781 VPWR VGND sg13g2_decap_8
X_18793_ _09880_ net656 net183 VPWR VGND sg13g2_nand2_1
XFILLER_43_1050 VPWR VGND sg13g2_decap_8
XFILLER_95_869 VPWR VGND sg13g2_fill_2
XFILLER_94_346 VPWR VGND sg13g2_decap_8
X_17744_ VGND VPWR _08858_ _08866_ _08877_ _08876_ sg13g2_a21oi_1
X_14956_ VGND VPWR _06204_ _06236_ _06237_ _06229_ sg13g2_a21oi_1
XFILLER_75_560 VPWR VGND sg13g2_fill_2
XFILLER_47_251 VPWR VGND sg13g2_decap_8
XFILLER_130_1053 VPWR VGND sg13g2_decap_8
X_13907_ VGND VPWR net536 _05227_ _00114_ _05228_ sg13g2_a21oi_1
X_17675_ VGND VPWR _08797_ _08798_ _08808_ _08807_ sg13g2_a21oi_1
X_14887_ _06172_ _06153_ _06170_ VPWR VGND sg13g2_xnor2_1
XFILLER_35_435 VPWR VGND sg13g2_decap_4
X_19414_ _10478_ net646 net133 VPWR VGND sg13g2_nand2_1
X_16626_ u_LMS.w\[5\]\[24\] u_LMS.w\[5\]\[21\] u_LMS.w\[5\]\[20\] u_LMS.w\[5\]\[18\]
+ _07810_ VPWR VGND sg13g2_nor4_1
X_13838_ _05162_ _05161_ _05155_ VPWR VGND sg13g2_nand2b_1
XFILLER_35_468 VPWR VGND sg13g2_decap_4
XFILLER_90_574 VPWR VGND sg13g2_fill_1
XFILLER_63_788 VPWR VGND sg13g2_fill_1
X_19345_ _10408_ _10398_ _10409_ VPWR VGND sg13g2_xor2_1
XFILLER_44_991 VPWR VGND sg13g2_decap_4
X_16557_ net982 VPWR _07760_ VGND net488 net780 sg13g2_o21ai_1
XFILLER_16_693 VPWR VGND sg13g2_decap_4
X_13769_ _05095_ _05089_ _05093_ VPWR VGND sg13g2_xnor2_1
X_15508_ _06766_ net899 net788 net886 net789 VPWR VGND sg13g2_a22oi_1
X_19276_ _10342_ net55 _10341_ VPWR VGND sg13g2_nand2_1
X_16488_ VGND VPWR _07706_ _07707_ _00216_ net938 sg13g2_a21oi_1
X_18227_ _09336_ _09304_ _09337_ VPWR VGND sg13g2_xor2_1
X_15439_ net1002 VPWR _06703_ VGND net500 u_FIR.sum\[6\]\[15\] sg13g2_o21ai_1
XFILLER_50_1021 VPWR VGND sg13g2_fill_1
X_18158_ _09264_ VPWR _09268_ VGND _09265_ _09266_ sg13g2_o21ai_1
XFILLER_129_595 VPWR VGND sg13g2_decap_8
XFILLER_8_892 VPWR VGND sg13g2_decap_8
XFILLER_11_1038 VPWR VGND sg13g2_decap_8
X_17109_ net714 net192 net712 _08265_ VPWR VGND net173 sg13g2_nand4_1
X_18089_ VGND VPWR _09199_ _09198_ _03264_ sg13g2_or2_1
XFILLER_132_716 VPWR VGND sg13g2_decap_8
XFILLER_116_267 VPWR VGND sg13g2_decap_8
X_20120_ VGND VPWR _11161_ _11159_ _11123_ sg13g2_or2_1
XFILLER_131_215 VPWR VGND sg13g2_decap_8
XFILLER_116_289 VPWR VGND sg13g2_decap_8
Xrebuffer2058 net2058 net2057 VPWR VGND sg13g2_buf_1
XFILLER_113_930 VPWR VGND sg13g2_fill_1
Xrebuffer2069 net2155 net2068 VPWR VGND sg13g2_buf_1
Xfanout805 net808 net805 VPWR VGND sg13g2_buf_1
Xfanout816 u_FIR.x_reg\[7\] net816 VPWR VGND sg13g2_buf_1
X_20051_ _11092_ net623 net236 VPWR VGND sg13g2_nand2_1
Xfanout827 net828 net827 VPWR VGND sg13g2_buf_1
Xfanout838 net840 net838 VPWR VGND sg13g2_buf_1
Xfanout849 net850 net849 VPWR VGND sg13g2_buf_1
XFILLER_86_847 VPWR VGND sg13g2_decap_4
XFILLER_86_869 VPWR VGND sg13g2_fill_2
XFILLER_39_752 VPWR VGND sg13g2_fill_2
XFILLER_38_262 VPWR VGND sg13g2_fill_1
X_20953_ _01593_ _01476_ _01510_ VPWR VGND sg13g2_xnor2_1
X_23741_ net994 VGND VPWR _00803_ spi_wdata\[0\] clknet_3_5__leaf_spi_sclk sg13g2_dfrbpq_1
XFILLER_93_390 VPWR VGND sg13g2_decap_4
XFILLER_53_243 VPWR VGND sg13g2_decap_4
XFILLER_42_906 VPWR VGND sg13g2_fill_1
XFILLER_81_563 VPWR VGND sg13g2_fill_1
X_20884_ VGND VPWR _01454_ _01524_ _01523_ _01522_ sg13g2_a21oi_2
X_23672_ net1020 VGND VPWR _00734_ u_debug_unit.mon_w5_sync\[3\] clknet_leaf_35_clkA
+ sg13g2_dfrbpq_1
XFILLER_54_788 VPWR VGND sg13g2_decap_8
X_22623_ coeff_force_packed\[3\] net467 _03061_ _00619_ VPWR VGND sg13g2_mux2_1
XFILLER_53_298 VPWR VGND sg13g2_fill_2
XFILLER_13_129 VPWR VGND sg13g2_fill_2
Xclkbuf_leaf_47_clkA clknet_4_4_0_clkA clknet_leaf_47_clkA VPWR VGND sg13g2_buf_8
X_23446__1594 VPWR VGND net1593 sg13g2_tiehi
XFILLER_42_25 VPWR VGND sg13g2_fill_1
X_22554_ net917 _03033_ _03034_ _00577_ VPWR VGND sg13g2_nor3_1
XFILLER_42_47 VPWR VGND sg13g2_decap_4
XFILLER_10_825 VPWR VGND sg13g2_decap_4
XFILLER_10_836 VPWR VGND sg13g2_fill_1
X_21505_ VGND VPWR _02112_ _02116_ _02122_ _02115_ sg13g2_a21oi_1
X_22485_ net958 VPWR _02992_ VGND net442 net588 sg13g2_o21ai_1
XFILLER_6_829 VPWR VGND sg13g2_fill_1
X_21436_ _02051_ _02052_ _02053_ VPWR VGND sg13g2_nor2_1
XFILLER_107_212 VPWR VGND sg13g2_decap_4
X_23092__1069 VPWR VGND net1068 sg13g2_tiehi
X_21367_ _01984_ net84 net605 net111 net603 VPWR VGND sg13g2_a22oi_1
XFILLER_122_204 VPWR VGND sg13g2_decap_8
XFILLER_107_289 VPWR VGND sg13g2_fill_2
X_20318_ u_LMS.w\[5\]\[14\] _00980_ _00981_ VPWR VGND sg13g2_and2_1
X_23106_ net1047 VGND VPWR _00168_ u_FIR.sum\[6\]\[11\] clknet_leaf_42_clkA sg13g2_dfrbpq_1
XFILLER_1_501 VPWR VGND sg13g2_fill_1
X_21298_ _03224_ _03226_ _01915_ VPWR VGND sg13g2_nor2_1
XFILLER_1_534 VPWR VGND sg13g2_fill_2
XFILLER_104_952 VPWR VGND sg13g2_decap_8
XFILLER_107_51 VPWR VGND sg13g2_decap_8
X_23037_ net1150 VGND VPWR _00099_ u_FIR.sum\[2\]\[18\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
XFILLER_107_62 VPWR VGND sg13g2_fill_1
X_20249_ net213 _00911_ net633 _00912_ VPWR VGND sg13g2_nand3_1
XFILLER_114_1026 VPWR VGND sg13g2_decap_4
XFILLER_77_858 VPWR VGND sg13g2_fill_2
XFILLER_67_66 VPWR VGND sg13g2_decap_8
XFILLER_49_549 VPWR VGND sg13g2_decap_4
XFILLER_67_77 VPWR VGND sg13g2_fill_1
X_14810_ _06097_ _06091_ _06096_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_806 VPWR VGND sg13g2_fill_1
X_15790_ _07040_ _07039_ _06999_ VPWR VGND sg13g2_nand2b_1
X_14741_ VPWR _06030_ _06029_ VGND sg13g2_inv_1
X_11953_ VPWR _03374_ net787 VGND sg13g2_inv_1
XFILLER_29_284 VPWR VGND sg13g2_decap_8
XFILLER_123_83 VPWR VGND sg13g2_fill_2
XFILLER_84_390 VPWR VGND sg13g2_fill_2
X_17460_ _08593_ _08588_ _08591_ VPWR VGND sg13g2_xnor2_1
X_14672_ _05961_ _05928_ _05963_ VPWR VGND sg13g2_xor2_1
X_11884_ VPWR _03305_ u_LMS.w\[6\]\[7\] VGND sg13g2_inv_1
XFILLER_60_725 VPWR VGND sg13g2_fill_1
X_16411_ _07640_ _07639_ _07642_ VPWR VGND sg13g2_xor2_1
X_13623_ _04951_ _04925_ _04953_ VPWR VGND sg13g2_xor2_1
X_17391_ net45 VPWR _08538_ VGND net43 _08537_ sg13g2_o21ai_1
XFILLER_44_298 VPWR VGND sg13g2_decap_4
XFILLER_16_81 VPWR VGND sg13g2_fill_2
XFILLER_16_92 VPWR VGND sg13g2_fill_2
X_19130_ _10193_ u_LMS.w\[3\]\[7\] _10216_ _10217_ VPWR VGND sg13g2_a21o_1
X_16342_ _07544_ _07546_ _07575_ _07576_ VPWR VGND sg13g2_or3_1
X_13554_ net1033 VPWR _04886_ VGND net532 u_FIR.sum\[3\]\[4\] sg13g2_o21ai_1
XFILLER_8_100 VPWR VGND sg13g2_fill_1
XFILLER_13_696 VPWR VGND sg13g2_fill_1
X_19061_ _09910_ VPWR _10148_ VGND _09909_ _09943_ sg13g2_o21ai_1
X_12505_ _03880_ _03858_ _03879_ VPWR VGND sg13g2_nand2b_1
X_16273_ _07509_ _07482_ _07507_ VPWR VGND sg13g2_xnor2_1
X_13485_ _04820_ _04814_ _04819_ VPWR VGND sg13g2_xnor2_1
X_18012_ VGND VPWR u_LMS.w\[1\]\[21\] net303 _09136_ _09122_ sg13g2_a21oi_1
X_15224_ _06462_ _06455_ _06470_ _06494_ VPWR VGND sg13g2_a21o_1
X_23473__1508 VPWR VGND net1507 sg13g2_tiehi
X_12436_ _03788_ _03812_ _03813_ VPWR VGND sg13g2_nor2_1
XFILLER_126_510 VPWR VGND sg13g2_decap_8
XFILLER_66_7 VPWR VGND sg13g2_decap_8
XFILLER_32_91 VPWR VGND sg13g2_decap_8
X_15155_ net820 _06426_ u_FIR.w\[2\]\[1\] _06427_ VPWR VGND sg13g2_nand3_1
XFILLER_126_554 VPWR VGND sg13g2_fill_1
X_12367_ _03746_ _03713_ _03744_ VPWR VGND sg13g2_xnor2_1
XFILLER_10_1060 VPWR VGND sg13g2_fill_1
X_14106_ _05417_ net761 net851 VPWR VGND sg13g2_nand2_1
X_19963_ _10998_ VPWR _11004_ VGND _10986_ _10999_ sg13g2_o21ai_1
X_15086_ _06360_ _06359_ _06321_ VPWR VGND sg13g2_nand2b_1
X_12298_ _03669_ _03671_ _03678_ VPWR VGND sg13g2_nor2_1
X_18914_ _10001_ net80 net667 net107 net666 VPWR VGND sg13g2_a22oi_1
X_14037_ _05350_ _05344_ _05348_ VPWR VGND sg13g2_xnor2_1
XFILLER_68_803 VPWR VGND sg13g2_decap_8
X_19894_ _10934_ _10935_ _00394_ VPWR VGND sg13g2_nor2_1
XFILLER_68_814 VPWR VGND sg13g2_fill_2
XFILLER_110_911 VPWR VGND sg13g2_decap_8
XFILLER_67_313 VPWR VGND sg13g2_decap_8
X_18845_ _03257_ _03258_ _09932_ VPWR VGND sg13g2_nor2_1
XFILLER_110_955 VPWR VGND sg13g2_fill_2
XFILLER_68_869 VPWR VGND sg13g2_fill_2
XFILLER_110_966 VPWR VGND sg13g2_fill_1
X_18776_ _09861_ _09862_ _09863_ VPWR VGND sg13g2_nor2_1
X_15988_ VGND VPWR net499 _07228_ _00194_ _07229_ sg13g2_a21oi_1
XFILLER_95_688 VPWR VGND sg13g2_fill_1
X_23342__1260 VPWR VGND net1259 sg13g2_tiehi
X_17727_ _08860_ net695 net242 VPWR VGND sg13g2_nand2_1
X_14939_ _06221_ u_FIR.sum\[4\]\[16\] net396 VPWR VGND sg13g2_nand2_1
X_17658_ _08757_ _08751_ _08791_ VPWR VGND sg13g2_xor2_1
X_16609_ VGND VPWR net515 _07797_ _00246_ _07798_ sg13g2_a21oi_1
XFILLER_50_224 VPWR VGND sg13g2_fill_2
X_17589_ _08713_ VPWR _08722_ VGND _08710_ _08714_ sg13g2_o21ai_1
XFILLER_92_0 VPWR VGND sg13g2_decap_8
X_19328_ _10384_ _10368_ _10392_ VPWR VGND sg13g2_xor2_1
X_19259_ net55 _10329_ _10330_ VPWR VGND _10210_ sg13g2_nand3b_1
X_22270_ VGND VPWR _02859_ _02860_ _00467_ net930 sg13g2_a21oi_1
XFILLER_128_28 VPWR VGND sg13g2_decap_8
XFILLER_117_532 VPWR VGND sg13g2_decap_8
X_21221_ _01836_ _01837_ _01838_ VPWR VGND sg13g2_and2_1
X_21152_ _01769_ net594 net83 VPWR VGND sg13g2_nand2_1
X_20103_ _11144_ _11105_ _11106_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_557 VPWR VGND sg13g2_decap_8
Xfanout602 net603 net602 VPWR VGND sg13g2_buf_1
XFILLER_99_961 VPWR VGND sg13g2_fill_2
XFILLER_120_708 VPWR VGND sg13g2_fill_1
X_21083_ _01710_ net378 _01659_ VPWR VGND sg13g2_nand2b_1
Xfanout613 u_LMS.x_r\[6\]\[4\] net613 VPWR VGND sg13g2_buf_1
Xfanout624 u_LMS.x_r\[5\]\[6\] net624 VPWR VGND sg13g2_buf_1
Xfanout635 u_LMS.x_r\[5\]\[1\] net635 VPWR VGND sg13g2_buf_1
X_20034_ VPWR _11075_ _11074_ VGND sg13g2_inv_1
Xfanout646 u_LMS.x_r\[4\]\[3\] net646 VPWR VGND sg13g2_buf_1
XFILLER_58_313 VPWR VGND sg13g2_decap_4
Xfanout657 u_LMS.x_r\[3\]\[5\] net657 VPWR VGND sg13g2_buf_1
Xfanout668 u_LMS.x_r\[3\]\[0\] net668 VPWR VGND sg13g2_buf_1
Xfanout679 u_LMS.x_r\[2\]\[2\] net679 VPWR VGND sg13g2_buf_1
XFILLER_58_346 VPWR VGND sg13g2_fill_1
XFILLER_100_443 VPWR VGND sg13g2_decap_8
XFILLER_58_368 VPWR VGND sg13g2_decap_8
XFILLER_46_519 VPWR VGND sg13g2_decap_8
XFILLER_74_839 VPWR VGND sg13g2_decap_8
XFILLER_37_69 VPWR VGND sg13g2_fill_2
X_21985_ _02579_ net82 net587 net108 u_LMS.x_r\[8\]\[1\] VPWR VGND sg13g2_a22oi_1
XFILLER_54_541 VPWR VGND sg13g2_fill_2
X_23724_ net1350 VGND VPWR _00786_ u_s2p_input.reg_sh\[5\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
X_20936_ VGND VPWR _01402_ _01527_ _01576_ _01400_ sg13g2_a21oi_1
XFILLER_54_585 VPWR VGND sg13g2_decap_4
XFILLER_26_276 VPWR VGND sg13g2_fill_1
XFILLER_42_736 VPWR VGND sg13g2_decap_8
X_20867_ _01507_ _01499_ _01503_ VPWR VGND sg13g2_xnor2_1
X_23655_ net986 VGND VPWR _00717_ u_debug_unit.mon_w3_sync\[0\] clknet_leaf_53_clkA
+ sg13g2_dfrbpq_1
X_22606_ net464 debug_load_bus\[4\] _03059_ _00604_ VPWR VGND sg13g2_mux2_1
X_20798_ _01438_ _01430_ _01437_ VPWR VGND sg13g2_xnor2_1
X_23586_ net963 VGND VPWR _00648_ coeff_force_packed\[28\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
XFILLER_50_780 VPWR VGND sg13g2_fill_2
XFILLER_23_994 VPWR VGND sg13g2_decap_8
X_22537_ u_LMS.count\[12\] _03022_ _03024_ VPWR VGND sg13g2_and2_1
XFILLER_10_644 VPWR VGND sg13g2_fill_1
XFILLER_10_655 VPWR VGND sg13g2_decap_4
XFILLER_127_307 VPWR VGND sg13g2_fill_2
XFILLER_108_510 VPWR VGND sg13g2_fill_1
X_23430__1059 VPWR VGND net1058 sg13g2_tiehi
X_13270_ VGND VPWR _04616_ _04571_ _04569_ sg13g2_or2_1
X_22468_ VGND VPWR net449 _03235_ _00542_ _02983_ sg13g2_a21oi_1
X_12221_ _03594_ VPWR _03605_ VGND _03602_ _03603_ sg13g2_o21ai_1
X_21419_ VGND VPWR _02034_ _02035_ _02036_ _02033_ sg13g2_a21oi_1
X_22399_ net948 VPWR _02949_ VGND net431 net673 sg13g2_o21ai_1
XFILLER_123_502 VPWR VGND sg13g2_fill_2
X_12152_ _03561_ net293 coeff_force_packed\[49\] _03410_ u_debug_unit.mon_w4_sync\[0\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_123_557 VPWR VGND sg13g2_fill_1
XFILLER_123_568 VPWR VGND sg13g2_decap_8
X_16960_ _08116_ _08115_ _08112_ VPWR VGND sg13g2_nand2b_1
X_12083_ _03496_ net293 coeff_force_packed\[53\] _03405_ u_debug_unit.mon_w5_sync\[4\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_89_460 VPWR VGND sg13g2_decap_8
XFILLER_2_887 VPWR VGND sg13g2_decap_8
X_15911_ _07149_ _07156_ _07157_ VPWR VGND sg13g2_nor2b_1
XFILLER_49_313 VPWR VGND sg13g2_fill_1
XFILLER_103_270 VPWR VGND sg13g2_decap_4
X_16891_ _08042_ VPWR _08047_ VGND _08030_ _08040_ sg13g2_o21ai_1
XFILLER_103_281 VPWR VGND sg13g2_decap_4
X_18630_ net950 _09727_ _00338_ VPWR VGND sg13g2_and2_1
X_15842_ VGND VPWR _07058_ _07062_ _07090_ _07061_ sg13g2_a21oi_1
XFILLER_94_42 VPWR VGND sg13g2_fill_2
XFILLER_65_839 VPWR VGND sg13g2_fill_1
XFILLER_76_176 VPWR VGND sg13g2_decap_4
XFILLER_91_113 VPWR VGND sg13g2_decap_8
X_18561_ u_LMS.w\[2\]\[22\] net69 _09671_ VPWR VGND sg13g2_and2_1
XFILLER_40_1053 VPWR VGND sg13g2_decap_8
XFILLER_18_733 VPWR VGND sg13g2_fill_1
X_15773_ _07023_ _06983_ _06986_ VPWR VGND sg13g2_nand2_1
XFILLER_17_210 VPWR VGND sg13g2_fill_1
X_12985_ VGND VPWR _04316_ _04322_ _04342_ _04329_ sg13g2_a21oi_1
X_17512_ _08644_ _08634_ _08645_ VPWR VGND sg13g2_xor2_1
XFILLER_73_861 VPWR VGND sg13g2_decap_8
X_14724_ _03367_ net871 _06013_ VPWR VGND sg13g2_nor2_1
X_18492_ _09602_ net2117 _09547_ VPWR VGND sg13g2_xnor2_1
X_11936_ VPWR _03357_ net499 VGND sg13g2_inv_1
XFILLER_45_585 VPWR VGND sg13g2_decap_4
XFILLER_17_287 VPWR VGND sg13g2_fill_2
X_17443_ VGND VPWR net58 _08577_ _08578_ net42 sg13g2_a21oi_1
X_14655_ _05940_ _05945_ _05946_ VPWR VGND sg13g2_nor2b_1
XFILLER_72_393 VPWR VGND sg13g2_decap_4
X_11867_ VPWR _03288_ u_LMS.x\[2\] VGND sg13g2_inv_1
XFILLER_33_769 VPWR VGND sg13g2_fill_1
X_13606_ VGND VPWR _04936_ _04934_ _04896_ sg13g2_or2_1
X_17374_ net563 coeff_force_packed\[6\] _08524_ VPWR VGND sg13g2_and2_1
X_14586_ _05879_ _05870_ _05877_ VPWR VGND sg13g2_xnor2_1
XFILLER_60_588 VPWR VGND sg13g2_fill_1
X_11798_ VPWR _03219_ net591 VGND sg13g2_inv_1
X_19113_ _10200_ net665 net253 VPWR VGND sg13g2_nand2_1
XFILLER_13_471 VPWR VGND sg13g2_fill_1
X_16325_ _07557_ _07522_ _07559_ VPWR VGND sg13g2_xor2_1
X_13537_ _04869_ _04860_ _04867_ VPWR VGND sg13g2_xnor2_1
X_19044_ _10087_ _10129_ _10131_ VPWR VGND sg13g2_nor2_1
X_16256_ _07490_ _07491_ _07492_ VPWR VGND sg13g2_and2_1
X_13468_ _04807_ _04804_ _04806_ VPWR VGND sg13g2_xnor2_1
X_15207_ _06478_ _06474_ _06477_ VPWR VGND sg13g2_xnor2_1
X_12419_ net866 net718 _03796_ VPWR VGND sg13g2_nor2b_1
X_16187_ _07378_ VPWR _07425_ VGND _07337_ _07376_ sg13g2_o21ai_1
XFILLER_126_351 VPWR VGND sg13g2_fill_2
X_13399_ _04720_ _04644_ _04719_ _04741_ VPWR VGND sg13g2_a21o_1
XFILLER_5_670 VPWR VGND sg13g2_decap_8
X_15138_ _06410_ _06409_ _00163_ VPWR VGND sg13g2_nor2b_1
XFILLER_5_692 VPWR VGND sg13g2_decap_4
XFILLER_99_246 VPWR VGND sg13g2_decap_8
XFILLER_4_180 VPWR VGND sg13g2_decap_8
XFILLER_114_557 VPWR VGND sg13g2_decap_8
X_19946_ _10971_ VPWR _10987_ VGND _10962_ _10972_ sg13g2_o21ai_1
X_15069_ _06340_ _06342_ _06343_ VPWR VGND sg13g2_nor2_1
XFILLER_99_279 VPWR VGND sg13g2_fill_2
XFILLER_4_84 VPWR VGND sg13g2_decap_8
X_19877_ net358 VPWR _10923_ VGND u_LMS.w\[4\]\[7\] net373 sg13g2_o21ai_1
XFILLER_56_806 VPWR VGND sg13g2_decap_8
X_18828_ _09912_ VPWR _09915_ VGND _03252_ net195 sg13g2_o21ai_1
XFILLER_68_688 VPWR VGND sg13g2_decap_8
XFILLER_110_785 VPWR VGND sg13g2_fill_1
XFILLER_55_316 VPWR VGND sg13g2_fill_1
XFILLER_55_327 VPWR VGND sg13g2_decap_8
X_18759_ net423 net218 _09846_ VPWR VGND sg13g2_nor2_1
XFILLER_48_390 VPWR VGND sg13g2_decap_4
XFILLER_64_850 VPWR VGND sg13g2_fill_1
XFILLER_82_157 VPWR VGND sg13g2_decap_8
X_21770_ _02364_ net576 net83 VPWR VGND sg13g2_nand2_1
XFILLER_24_736 VPWR VGND sg13g2_decap_4
X_20721_ VGND VPWR _01358_ _01360_ _01361_ _01357_ sg13g2_a21oi_1
XFILLER_23_257 VPWR VGND sg13g2_fill_2
X_20652_ _01292_ _01289_ _01290_ VPWR VGND sg13g2_xnor2_1
X_23440_ net1611 VGND VPWR _00502_ u_LMS.x_r\[1\]\[7\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
X_23371_ net1230 VGND VPWR _00433_ u_LMS.w\[6\]\[4\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
XFILLER_17_1055 VPWR VGND sg13g2_decap_4
XFILLER_104_1014 VPWR VGND sg13g2_decap_8
X_20583_ _01221_ _01222_ _01223_ VPWR VGND sg13g2_and2_1
X_22322_ VGND VPWR net47 _02901_ _02902_ net6 sg13g2_a21oi_1
XFILLER_118_841 VPWR VGND sg13g2_decap_8
XFILLER_118_852 VPWR VGND sg13g2_fill_2
X_22253_ net716 _02840_ net60 _02847_ VPWR VGND sg13g2_or3_2
XFILLER_117_351 VPWR VGND sg13g2_fill_1
X_21204_ _01821_ _01817_ _01820_ VPWR VGND sg13g2_xnor2_1
X_22184_ _02778_ _02694_ _02695_ VPWR VGND sg13g2_xnor2_1
X_21135_ _01751_ _01745_ _01752_ VPWR VGND sg13g2_nor2b_1
Xfanout410 _03377_ net410 VPWR VGND sg13g2_buf_1
Xfanout421 net422 net421 VPWR VGND sg13g2_buf_1
Xfanout432 net439 net432 VPWR VGND sg13g2_buf_1
XFILLER_132_398 VPWR VGND sg13g2_decap_8
X_21066_ _01697_ _01695_ _01696_ VPWR VGND sg13g2_xnor2_1
Xfanout443 net445 net443 VPWR VGND sg13g2_buf_1
XFILLER_59_633 VPWR VGND sg13g2_fill_1
XFILLER_48_35 VPWR VGND sg13g2_decap_4
Xfanout454 net455 net454 VPWR VGND sg13g2_buf_1
XFILLER_98_290 VPWR VGND sg13g2_fill_1
XFILLER_101_752 VPWR VGND sg13g2_decap_8
Xfanout465 spi_wdata\[4\] net465 VPWR VGND sg13g2_buf_1
X_20017_ VPWR _11058_ _11057_ VGND sg13g2_inv_1
Xfanout476 net478 net476 VPWR VGND sg13g2_buf_1
XFILLER_58_143 VPWR VGND sg13g2_fill_1
Xfanout487 net550 net487 VPWR VGND sg13g2_buf_1
Xfanout498 net499 net498 VPWR VGND sg13g2_buf_1
XFILLER_74_614 VPWR VGND sg13g2_decap_8
XFILLER_24_1059 VPWR VGND sg13g2_fill_2
XFILLER_46_327 VPWR VGND sg13g2_decap_8
XFILLER_46_338 VPWR VGND sg13g2_fill_2
XFILLER_73_135 VPWR VGND sg13g2_fill_2
XFILLER_39_390 VPWR VGND sg13g2_decap_8
XFILLER_55_872 VPWR VGND sg13g2_decap_8
X_12770_ _04111_ VPWR _04133_ VGND _04112_ _04120_ sg13g2_o21ai_1
X_21968_ _02560_ net2167 _02562_ VPWR VGND sg13g2_xor2_1
XFILLER_15_725 VPWR VGND sg13g2_decap_8
XFILLER_14_213 VPWR VGND sg13g2_decap_8
X_23707_ net1467 VGND VPWR _00769_ u_p2s_output.reg_cnt\[1\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
X_20919_ _01559_ _01558_ _01544_ VPWR VGND sg13g2_xnor2_1
X_21899_ _02493_ net576 net222 VPWR VGND sg13g2_nand2_1
XFILLER_70_875 VPWR VGND sg13g2_decap_8
XFILLER_30_706 VPWR VGND sg13g2_fill_1
XFILLER_120_51 VPWR VGND sg13g2_fill_2
X_14440_ _05719_ _05739_ _05717_ _05741_ VPWR VGND sg13g2_nand3_1
XFILLER_120_62 VPWR VGND sg13g2_fill_2
X_23638_ net1019 VGND VPWR _00700_ u_debug_unit.mon_w0_sync\[4\] clknet_leaf_36_clkA
+ sg13g2_dfrbpq_1
Xfanout50 _02248_ net50 VPWR VGND sg13g2_buf_2
XFILLER_70_1013 VPWR VGND sg13g2_decap_8
Xfanout61 net2179 net61 VPWR VGND sg13g2_buf_8
XFILLER_120_95 VPWR VGND sg13g2_fill_2
Xfanout72 _08394_ net72 VPWR VGND sg13g2_buf_2
Xfanout83 net84 net83 VPWR VGND sg13g2_buf_2
X_14371_ _05670_ _05672_ _05675_ VPWR VGND sg13g2_nor2_1
X_23569_ net953 VGND VPWR _00631_ u_debug_unit.force_w1\[7\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
Xfanout94 net97 net94 VPWR VGND sg13g2_buf_1
XFILLER_7_913 VPWR VGND sg13g2_fill_1
XFILLER_11_964 VPWR VGND sg13g2_fill_1
XFILLER_10_452 VPWR VGND sg13g2_decap_8
X_16110_ _07349_ _07345_ _07350_ VPWR VGND sg13g2_xor2_1
X_13322_ _04667_ _04637_ _04665_ VPWR VGND sg13g2_xnor2_1
X_17090_ _08246_ _08223_ _08245_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_148 VPWR VGND sg13g2_decap_8
X_16041_ net886 net801 u_FIR.sum\[7\]\[1\] _07282_ VPWR VGND sg13g2_a21o_1
X_13253_ _04599_ _04562_ _04565_ VPWR VGND sg13g2_nand2_1
X_12204_ VGND VPWR _03382_ _03591_ _00048_ net918 sg13g2_a21oi_1
XFILLER_89_75 VPWR VGND sg13g2_decap_8
XFILLER_108_395 VPWR VGND sg13g2_fill_2
X_13184_ net829 u_FIR.w\[6\]\[1\] _04530_ _04532_ VPWR VGND sg13g2_a21o_1
X_19800_ _10854_ _10861_ _10862_ VPWR VGND sg13g2_and2_1
X_12135_ _03545_ net292 coeff_force_packed\[15\] _03412_ u_debug_unit.mon_w6_sync\[1\]
+ VPWR VGND sg13g2_a22oi_1
X_17992_ _09048_ _09068_ _08980_ _09119_ VPWR VGND sg13g2_nand3_1
X_19731_ VGND VPWR _10792_ _10793_ _10795_ _10758_ sg13g2_a21oi_1
X_16943_ _08096_ _08097_ _08099_ VPWR VGND sg13g2_nor2_1
XFILLER_104_590 VPWR VGND sg13g2_fill_1
X_12066_ VPWR VGND coeff_force_packed\[5\] _03479_ net290 coeff_force_packed\[19\]
+ _03480_ net292 sg13g2_a221oi_1
XFILLER_38_806 VPWR VGND sg13g2_fill_2
X_19662_ _10598_ _10565_ _10726_ VPWR VGND sg13g2_xor2_1
X_16874_ VGND VPWR _08004_ _08015_ _08030_ _08014_ sg13g2_a21oi_1
X_18613_ _09714_ _09712_ _09713_ VPWR VGND sg13g2_xnor2_1
X_15825_ _07074_ _07037_ _07072_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_647 VPWR VGND sg13g2_decap_8
X_19593_ _10656_ VPWR _10657_ VGND _10629_ _10654_ sg13g2_o21ai_1
XFILLER_92_433 VPWR VGND sg13g2_decap_4
X_23389__1182 VPWR VGND net1181 sg13g2_tiehi
XFILLER_92_477 VPWR VGND sg13g2_fill_1
X_18544_ _09654_ u_LMS.w\[2\]\[16\] net2105 VPWR VGND sg13g2_xnor2_1
X_15756_ _07007_ _06978_ _07005_ VPWR VGND sg13g2_xnor2_1
X_12968_ _04325_ net284 _04326_ VPWR VGND sg13g2_xor2_1
XFILLER_46_883 VPWR VGND sg13g2_decap_8
X_14707_ _05997_ _05989_ _05996_ VPWR VGND sg13g2_xnor2_1
X_18475_ net70 u_LMS.w\[2\]\[19\] _09585_ VPWR VGND sg13g2_xor2_1
X_11919_ VPWR _03340_ u_LMS.w\[2\]\[5\] VGND sg13g2_inv_1
X_15687_ VGND VPWR _06901_ _06908_ _06939_ _06915_ sg13g2_a21oi_1
X_12899_ _04257_ _04256_ _04259_ VPWR VGND sg13g2_xor2_1
X_17426_ _08565_ _08441_ _08443_ VPWR VGND sg13g2_xnor2_1
X_14638_ _05914_ VPWR _05929_ VGND _05908_ _05912_ sg13g2_o21ai_1
XFILLER_61_897 VPWR VGND sg13g2_decap_8
XFILLER_127_1058 VPWR VGND sg13g2_fill_2
XFILLER_60_385 VPWR VGND sg13g2_decap_4
X_17357_ _08510_ _08467_ _08509_ VPWR VGND sg13g2_xnor2_1
X_14569_ _05862_ net771 net862 VPWR VGND sg13g2_nand2_1
X_16308_ _07543_ _07518_ _07542_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_261 VPWR VGND sg13g2_decap_4
X_17288_ _08425_ VPWR _08444_ VGND _08441_ _08442_ sg13g2_o21ai_1
XFILLER_118_137 VPWR VGND sg13g2_fill_2
Xclkload20 clknet_leaf_4_clkA clkload20/X VPWR VGND sg13g2_buf_8
X_19027_ _03257_ net219 net196 _10110_ _10114_ VPWR VGND sg13g2_nor4_1
Xclkload31 clkload31/Y clknet_leaf_6_clkA VPWR VGND sg13g2_inv_2
X_16239_ _07474_ _07442_ _07476_ VPWR VGND sg13g2_xor2_1
Xclkload42 clknet_leaf_24_clkA clkload42/X VPWR VGND sg13g2_buf_8
XFILLER_127_660 VPWR VGND sg13g2_decap_8
XFILLER_115_800 VPWR VGND sg13g2_fill_2
Xclkload53 VPWR clkload53/Y clknet_3_2__leaf_spi_sclk VGND sg13g2_inv_1
XFILLER_55_0 VPWR VGND sg13g2_decap_8
XFILLER_6_990 VPWR VGND sg13g2_decap_8
XFILLER_114_343 VPWR VGND sg13g2_fill_1
XFILLER_47_1059 VPWR VGND sg13g2_fill_2
XFILLER_114_376 VPWR VGND sg13g2_decap_8
XFILLER_102_549 VPWR VGND sg13g2_decap_8
X_19929_ _10970_ _10964_ _10969_ VPWR VGND sg13g2_xnor2_1
XFILLER_29_806 VPWR VGND sg13g2_decap_8
X_22940_ spi_addr\[5\] net324 _03201_ VPWR VGND sg13g2_nor2_1
XFILLER_84_923 VPWR VGND sg13g2_decap_8
XFILLER_69_997 VPWR VGND sg13g2_fill_2
XFILLER_110_593 VPWR VGND sg13g2_decap_8
X_22871_ VGND VPWR net299 _03160_ _00767_ _03161_ sg13g2_a21oi_1
XFILLER_28_349 VPWR VGND sg13g2_fill_1
XFILLER_56_669 VPWR VGND sg13g2_fill_2
XFILLER_55_146 VPWR VGND sg13g2_fill_1
X_21822_ _02416_ _02405_ _02415_ VPWR VGND sg13g2_xnor2_1
XFILLER_83_488 VPWR VGND sg13g2_decap_4
XFILLER_24_511 VPWR VGND sg13g2_fill_2
XFILLER_36_382 VPWR VGND sg13g2_fill_2
X_21753_ _02346_ _02340_ _02347_ VPWR VGND sg13g2_nor2b_1
XFILLER_63_190 VPWR VGND sg13g2_decap_4
X_23037__1151 VPWR VGND net1150 sg13g2_tiehi
XFILLER_52_875 VPWR VGND sg13g2_fill_2
XFILLER_34_59 VPWR VGND sg13g2_fill_2
X_20704_ _01344_ net607 net252 VPWR VGND sg13g2_nand2_1
X_21684_ VGND VPWR u_LMS.w\[7\]\[21\] net313 _02292_ _02276_ sg13g2_a21oi_1
X_23423_ net1079 VGND VPWR _00485_ u_LMS.w\[8\]\[10\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
X_20635_ _01272_ _01274_ _01275_ VPWR VGND sg13g2_nor2_1
Xclkload3 clknet_4_4_0_clkA clkload3/X VPWR VGND sg13g2_buf_8
XFILLER_20_772 VPWR VGND sg13g2_fill_2
X_20566_ _01203_ _01204_ _01205_ _01206_ VPWR VGND sg13g2_nor3_1
X_23354_ net1247 VGND VPWR _00416_ u_LMS.w\[5\]\[10\] clknet_leaf_11_clkA sg13g2_dfrbpq_1
X_22305_ VGND VPWR u_LMS.w\[8\]\[22\] net307 _02889_ _02871_ sg13g2_a21oi_1
X_20497_ _01139_ _01140_ _00414_ VPWR VGND sg13g2_nor2_1
X_23285_ net1323 VGND VPWR _00347_ u_LMS.w\[2\]\[10\] clknet_leaf_64_clkA sg13g2_dfrbpq_1
XFILLER_124_118 VPWR VGND sg13g2_decap_8
X_22236_ _02830_ u_LMS.w\[8\]\[20\] net61 VPWR VGND sg13g2_nand2_1
XFILLER_105_332 VPWR VGND sg13g2_fill_1
XFILLER_106_866 VPWR VGND sg13g2_fill_1
X_22167_ u_LMS.w\[8\]\[15\] net2168 _02761_ VPWR VGND sg13g2_nor2_1
XFILLER_121_814 VPWR VGND sg13g2_decap_4
XFILLER_120_302 VPWR VGND sg13g2_fill_2
XFILLER_78_227 VPWR VGND sg13g2_decap_4
X_21118_ net362 VPWR _01737_ VGND u_LMS.w\[6\]\[10\] net379 sg13g2_o21ai_1
X_22098_ VGND VPWR net196 _02691_ _02692_ _02690_ sg13g2_a21oi_1
Xfanout240 net241 net240 VPWR VGND sg13g2_buf_1
XFILLER_120_346 VPWR VGND sg13g2_fill_2
Xfanout251 _07923_ net251 VPWR VGND sg13g2_buf_1
XFILLER_59_441 VPWR VGND sg13g2_decap_4
Xfanout262 net265 net262 VPWR VGND sg13g2_buf_1
X_21049_ _01639_ _01682_ _01683_ VPWR VGND sg13g2_nor2b_1
Xfanout273 net274 net273 VPWR VGND sg13g2_buf_1
X_13940_ _05260_ _05250_ _05258_ VPWR VGND sg13g2_xnor2_1
XFILLER_120_379 VPWR VGND sg13g2_decap_8
Xfanout284 _04265_ net284 VPWR VGND sg13g2_buf_1
XFILLER_19_316 VPWR VGND sg13g2_fill_1
Xfanout295 _03425_ net295 VPWR VGND sg13g2_buf_1
XFILLER_74_433 VPWR VGND sg13g2_decap_4
X_13871_ _05194_ _05186_ _05193_ VPWR VGND sg13g2_xnor2_1
XFILLER_75_967 VPWR VGND sg13g2_decap_8
XFILLER_75_978 VPWR VGND sg13g2_fill_2
XFILLER_75_989 VPWR VGND sg13g2_decap_4
X_15610_ _06864_ _06824_ _06862_ VPWR VGND sg13g2_xnor2_1
X_12822_ VGND VPWR _04184_ _04183_ net409 sg13g2_or2_1
XFILLER_62_617 VPWR VGND sg13g2_fill_2
X_16590_ net997 VPWR _07784_ VGND net492 net769 sg13g2_o21ai_1
XFILLER_62_639 VPWR VGND sg13g2_fill_1
XFILLER_15_500 VPWR VGND sg13g2_fill_2
XFILLER_28_894 VPWR VGND sg13g2_decap_8
XFILLER_27_382 VPWR VGND sg13g2_decap_8
XFILLER_15_522 VPWR VGND sg13g2_fill_1
X_15541_ _06797_ net787 net872 VPWR VGND sg13g2_nand2_1
XFILLER_61_138 VPWR VGND sg13g2_decap_8
X_12753_ _04117_ u_FIR.sum\[0\]\[7\] net407 VPWR VGND sg13g2_xnor2_1
XFILLER_15_544 VPWR VGND sg13g2_fill_2
XFILLER_70_650 VPWR VGND sg13g2_fill_1
XFILLER_91_54 VPWR VGND sg13g2_decap_8
X_18260_ _09368_ _09367_ _09370_ VPWR VGND sg13g2_xor2_1
XFILLER_43_886 VPWR VGND sg13g2_decap_4
XFILLER_30_503 VPWR VGND sg13g2_fill_2
X_15472_ VGND VPWR _06719_ _06730_ _06733_ _06729_ sg13g2_a21oi_1
X_12684_ _04050_ _04048_ _04049_ VPWR VGND sg13g2_xnor2_1
X_17211_ _08367_ _08365_ _08366_ VPWR VGND sg13g2_nand2b_1
XFILLER_91_98 VPWR VGND sg13g2_fill_2
X_14423_ _05723_ _05724_ _05725_ VPWR VGND sg13g2_and2_1
X_18191_ _09301_ _09299_ _09300_ VPWR VGND sg13g2_nand2_1
XFILLER_30_569 VPWR VGND sg13g2_decap_4
X_17142_ _08296_ _08297_ _08298_ VPWR VGND sg13g2_and2_1
X_14354_ _05659_ _05635_ _05658_ VPWR VGND sg13g2_xnor2_1
XFILLER_11_772 VPWR VGND sg13g2_decap_8
XFILLER_10_271 VPWR VGND sg13g2_fill_1
X_13305_ _04648_ _04649_ _04650_ VPWR VGND sg13g2_and2_1
X_17073_ _08229_ _08228_ _08220_ VPWR VGND sg13g2_xnor2_1
X_14285_ _05566_ _05591_ _05592_ VPWR VGND sg13g2_nor2b_1
XFILLER_7_776 VPWR VGND sg13g2_fill_2
XFILLER_6_253 VPWR VGND sg13g2_fill_1
XFILLER_7_787 VPWR VGND sg13g2_fill_1
X_16024_ _07265_ _07256_ _07263_ VPWR VGND sg13g2_xnor2_1
X_13236_ _04583_ _04582_ _04541_ VPWR VGND sg13g2_nand2b_1
X_23269__1356 VPWR VGND net1355 sg13g2_tiehi
X_13167_ _04509_ _04512_ _04515_ VPWR VGND sg13g2_nor2_1
XFILLER_3_993 VPWR VGND sg13g2_decap_8
X_12118_ VGND VPWR u_debug_unit.sw_reset\[2\] net286 _03529_ _03385_ sg13g2_a21oi_1
X_17975_ _09106_ net307 u_LMS.w\[1\]\[14\] coeff_force_packed\[9\] net557 VPWR VGND
+ sg13g2_a22oi_1
X_13098_ _04448_ net745 net855 VPWR VGND sg13g2_nand2_1
XFILLER_66_901 VPWR VGND sg13g2_decap_8
X_19714_ _10778_ u_LMS.w\[4\]\[5\] _10766_ VPWR VGND sg13g2_xnor2_1
X_16926_ _08082_ _08079_ _08080_ VPWR VGND sg13g2_xnor2_1
X_12049_ _00019_ VPWR _03464_ VGND u_spi_slave.tx_shift\[13\] net328 sg13g2_o21ai_1
XFILLER_66_923 VPWR VGND sg13g2_decap_8
XFILLER_66_934 VPWR VGND sg13g2_fill_1
XFILLER_37_102 VPWR VGND sg13g2_fill_2
X_19645_ _10698_ _10706_ _10709_ VPWR VGND sg13g2_nor2_1
X_16857_ _08013_ _08007_ _08012_ VPWR VGND sg13g2_xnor2_1
XFILLER_37_146 VPWR VGND sg13g2_fill_2
XFILLER_1_63 VPWR VGND sg13g2_decap_8
XFILLER_19_850 VPWR VGND sg13g2_decap_4
X_15808_ _07057_ _07026_ _07029_ VPWR VGND sg13g2_nand2_1
XFILLER_92_263 VPWR VGND sg13g2_decap_8
X_19576_ _10640_ _10638_ _10639_ VPWR VGND sg13g2_xnor2_1
X_16788_ u_FIR.sum\[8\]\[11\] u_FIR.sum\[8\]\[10\] u_FIR.sum\[8\]\[9\] _07889_ _07944_
+ VPWR VGND sg13g2_nor4_1
XFILLER_92_274 VPWR VGND sg13g2_fill_1
XFILLER_92_296 VPWR VGND sg13g2_fill_1
X_18527_ _09605_ VPWR _09637_ VGND _09634_ _09635_ sg13g2_o21ai_1
X_15739_ _06990_ u_FIR.w\[1\]\[3\] u_FIR.w\[1\]\[2\] net803 VPWR VGND sg13g2_and3_1
XFILLER_61_672 VPWR VGND sg13g2_decap_8
XFILLER_33_363 VPWR VGND sg13g2_fill_2
X_18458_ _09568_ _09567_ _09293_ VPWR VGND sg13g2_nand2b_1
X_17409_ VGND VPWR net58 _08551_ _08552_ net42 sg13g2_a21oi_1
X_18389_ _09499_ _09489_ _09490_ VPWR VGND sg13g2_xnor2_1
X_20420_ net22 VPWR _01081_ VGND net20 _01080_ sg13g2_o21ai_1
XFILLER_119_435 VPWR VGND sg13g2_fill_2
XFILLER_107_608 VPWR VGND sg13g2_decap_4
X_20351_ _01014_ u_LMS.w\[5\]\[6\] _00996_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_39 VPWR VGND sg13g2_fill_2
XFILLER_128_991 VPWR VGND sg13g2_decap_8
X_23070_ net1101 VGND VPWR _00132_ u_FIR.sum\[4\]\[13\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
X_20282_ _11189_ _00944_ _00939_ _00945_ VPWR VGND sg13g2_nand3_1
X_22021_ _02530_ _02614_ _02615_ VPWR VGND sg13g2_nor2b_1
XFILLER_103_825 VPWR VGND sg13g2_decap_8
XFILLER_102_302 VPWR VGND sg13g2_decap_4
XFILLER_69_750 VPWR VGND sg13g2_fill_1
XFILLER_60_1056 VPWR VGND sg13g2_decap_4
X_22923_ _03572_ _00012_ _03190_ VPWR VGND net428 sg13g2_nand3b_1
XFILLER_84_753 VPWR VGND sg13g2_fill_2
XFILLER_28_135 VPWR VGND sg13g2_decap_8
XFILLER_83_241 VPWR VGND sg13g2_fill_2
XFILLER_72_926 VPWR VGND sg13g2_fill_1
X_22854_ _03149_ _07899_ _03137_ net551 u_p2s_output.reg_sh\[1\] VPWR VGND sg13g2_a22oi_1
XFILLER_43_116 VPWR VGND sg13g2_decap_4
X_21805_ _02399_ _02398_ _02386_ VPWR VGND sg13g2_nand2b_1
X_22785_ VGND VPWR _07816_ net347 _00732_ _03110_ sg13g2_a21oi_1
XFILLER_36_190 VPWR VGND sg13g2_decap_4
XFILLER_25_864 VPWR VGND sg13g2_fill_2
XFILLER_24_341 VPWR VGND sg13g2_fill_2
X_21736_ _02330_ _02331_ _00462_ VPWR VGND sg13g2_nor2_1
XFILLER_40_834 VPWR VGND sg13g2_decap_8
XFILLER_24_385 VPWR VGND sg13g2_fill_2
XFILLER_61_24 VPWR VGND sg13g2_fill_1
XFILLER_12_547 VPWR VGND sg13g2_fill_1
X_21667_ VGND VPWR u_LMS.w\[7\]\[18\] net320 _02278_ _02276_ sg13g2_a21oi_1
XFILLER_131_4 VPWR VGND sg13g2_decap_8
X_23406_ net1130 VGND VPWR _00468_ u_LMS.w\[8\]\[16\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
X_20618_ _01258_ net117 _01256_ VPWR VGND sg13g2_xnor2_1
X_21598_ _02172_ u_LMS.w\[7\]\[11\] _02215_ VPWR VGND sg13g2_xor2_1
X_23337_ net1264 VGND VPWR _00399_ u_LMS.w\[5\]\[16\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
X_20549_ _01189_ net620 net151 VPWR VGND sg13g2_nand2_1
XFILLER_4_724 VPWR VGND sg13g2_fill_1
X_14070_ _05382_ _05381_ _05377_ VPWR VGND sg13g2_nand2b_1
X_23268_ net1357 VGND VPWR _00330_ u_LMS.w\[2\]\[16\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
X_13021_ net1025 VPWR _04375_ VGND net521 u_FIR.sum\[2\]\[1\] sg13g2_o21ai_1
XFILLER_4_779 VPWR VGND sg13g2_fill_1
X_22219_ _02813_ _02812_ _02768_ VPWR VGND sg13g2_nand2b_1
XFILLER_117_1002 VPWR VGND sg13g2_decap_4
X_23199_ net1482 VGND VPWR _00261_ u_FIR.w\[6\]\[2\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
Xfanout1002 net1004 net1002 VPWR VGND sg13g2_buf_1
Xfanout1013 net1014 net1013 VPWR VGND sg13g2_buf_1
Xfanout1024 net1025 net1024 VPWR VGND sg13g2_buf_1
XFILLER_120_132 VPWR VGND sg13g2_decap_8
XFILLER_86_43 VPWR VGND sg13g2_fill_1
Xfanout1035 net1036 net1035 VPWR VGND sg13g2_buf_1
XFILLER_121_688 VPWR VGND sg13g2_decap_4
XFILLER_0_985 VPWR VGND sg13g2_decap_8
X_17760_ _08892_ _08890_ _08893_ VPWR VGND sg13g2_xor2_1
X_14972_ _06243_ _06251_ _06252_ VPWR VGND sg13g2_nor2_1
XFILLER_102_880 VPWR VGND sg13g2_fill_2
XFILLER_94_539 VPWR VGND sg13g2_fill_1
XFILLER_86_98 VPWR VGND sg13g2_fill_1
XFILLER_19_113 VPWR VGND sg13g2_decap_8
X_16711_ VGND VPWR u_LMS.w\[8\]\[12\] _07872_ _07874_ _07873_ sg13g2_a21oi_1
X_13923_ _05244_ _05230_ _05242_ VPWR VGND sg13g2_xnor2_1
X_17691_ _08824_ _08787_ _08789_ VPWR VGND sg13g2_xnor2_1
XFILLER_74_252 VPWR VGND sg13g2_fill_1
X_19430_ _10492_ _10493_ _10494_ VPWR VGND sg13g2_and2_1
X_16642_ VGND VPWR u_LMS.w\[5\]\[16\] _07812_ _07822_ _07813_ sg13g2_a21oi_1
X_13854_ _05176_ _05151_ _05178_ VPWR VGND sg13g2_xor2_1
XFILLER_35_639 VPWR VGND sg13g2_fill_2
XFILLER_74_285 VPWR VGND sg13g2_fill_1
XFILLER_28_691 VPWR VGND sg13g2_decap_8
X_12805_ net1039 VPWR _04168_ VGND net544 u_FIR.sum\[1\]\[8\] sg13g2_o21ai_1
X_19361_ _10425_ _10373_ _10424_ VPWR VGND sg13g2_xnor2_1
X_16573_ u_LMS.w\[3\]\[19\] u_LMS.w\[3\]\[18\] u_LMS.w\[3\]\[20\] _07771_ VPWR VGND
+ sg13g2_nand3_1
XFILLER_16_853 VPWR VGND sg13g2_decap_8
X_13785_ _05111_ _05082_ _05110_ VPWR VGND sg13g2_xnor2_1
XFILLER_15_330 VPWR VGND sg13g2_fill_1
XFILLER_16_864 VPWR VGND sg13g2_fill_2
XFILLER_37_1014 VPWR VGND sg13g2_fill_2
XFILLER_15_352 VPWR VGND sg13g2_decap_4
X_18312_ _09417_ _09420_ _09388_ _09422_ VPWR VGND sg13g2_nand3_1
X_15524_ _06781_ net787 net901 VPWR VGND sg13g2_nand2_1
X_19292_ _10356_ _10351_ _10354_ VPWR VGND sg13g2_xnor2_1
X_12736_ _04100_ _04094_ _04098_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_300 VPWR VGND sg13g2_decap_8
XFILLER_96_7 VPWR VGND sg13g2_decap_8
XFILLER_31_834 VPWR VGND sg13g2_fill_2
X_18243_ _09353_ _09351_ net2096 VPWR VGND sg13g2_nand2_1
X_15455_ net1004 VPWR _06718_ VGND net500 u_FIR.sum\[6\]\[16\] sg13g2_o21ai_1
XFILLER_31_867 VPWR VGND sg13g2_fill_1
X_12667_ _04033_ _04032_ _03999_ VPWR VGND sg13g2_nand2b_1
XFILLER_31_889 VPWR VGND sg13g2_decap_8
X_14406_ _05707_ _05695_ _05709_ VPWR VGND sg13g2_xor2_1
X_18174_ _09279_ _09278_ _09284_ VPWR VGND sg13g2_xor2_1
X_15386_ _06652_ _06651_ _06620_ VPWR VGND sg13g2_nand2b_1
X_12598_ _03965_ _03964_ _03967_ VPWR VGND sg13g2_xor2_1
XFILLER_30_399 VPWR VGND sg13g2_fill_1
X_23157__1554 VPWR VGND net1553 sg13g2_tiehi
X_17125_ _08281_ _08280_ _08279_ VPWR VGND sg13g2_nand2b_1
XFILLER_7_540 VPWR VGND sg13g2_fill_1
X_14337_ _05642_ _05639_ _05640_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_788 VPWR VGND sg13g2_fill_2
XFILLER_128_265 VPWR VGND sg13g2_decap_8
X_17056_ net135 net711 _08210_ _08212_ VPWR VGND sg13g2_a21o_1
Xrebuffer2207 _10623_ net2206 VPWR VGND sg13g2_buf_1
X_14268_ net838 net758 _05573_ _05575_ VPWR VGND sg13g2_a21o_1
Xrebuffer2218 net2218 net2217 VPWR VGND sg13g2_buf_1
X_16007_ _07248_ _07239_ _07247_ VPWR VGND sg13g2_nand2_1
XFILLER_83_1012 VPWR VGND sg13g2_decap_4
X_13219_ _04566_ _04560_ _04564_ VPWR VGND sg13g2_xnor2_1
X_14199_ VPWR _05508_ _05507_ VGND sg13g2_inv_1
XFILLER_124_471 VPWR VGND sg13g2_fill_1
XFILLER_44_1007 VPWR VGND sg13g2_decap_8
X_23441__1609 VPWR VGND net1608 sg13g2_tiehi
XFILLER_44_1018 VPWR VGND sg13g2_decap_8
XFILLER_124_493 VPWR VGND sg13g2_fill_1
XFILLER_44_1029 VPWR VGND sg13g2_fill_1
XFILLER_85_506 VPWR VGND sg13g2_fill_1
X_23502__1406 VPWR VGND net1405 sg13g2_tiehi
X_17958_ VPWR _09091_ _09090_ VGND sg13g2_inv_1
XFILLER_66_742 VPWR VGND sg13g2_decap_8
XFILLER_18_0 VPWR VGND sg13g2_decap_8
X_16909_ VGND VPWR _08044_ _08046_ _08065_ _08064_ sg13g2_a21oi_1
X_17889_ _09022_ u_LMS.w\[1\]\[7\] _09001_ VPWR VGND sg13g2_xnor2_1
XFILLER_38_466 VPWR VGND sg13g2_fill_2
X_19628_ _10690_ _10691_ _10692_ VPWR VGND sg13g2_nor2_1
XFILLER_65_263 VPWR VGND sg13g2_fill_1
XFILLER_38_488 VPWR VGND sg13g2_fill_2
XFILLER_53_436 VPWR VGND sg13g2_fill_1
XFILLER_19_691 VPWR VGND sg13g2_fill_2
XFILLER_25_149 VPWR VGND sg13g2_fill_1
X_19559_ _10619_ _10618_ _10623_ VPWR VGND sg13g2_xor2_1
XFILLER_80_255 VPWR VGND sg13g2_fill_2
XFILLER_90_1005 VPWR VGND sg13g2_decap_8
X_22570_ net917 _03043_ _03044_ _00583_ VPWR VGND sg13g2_nor3_1
XFILLER_33_182 VPWR VGND sg13g2_fill_2
XFILLER_21_322 VPWR VGND sg13g2_fill_2
X_21521_ _01860_ _01861_ _02138_ VPWR VGND sg13g2_nor2b_1
XFILLER_33_193 VPWR VGND sg13g2_decap_4
X_21452_ _02068_ _02066_ _02069_ VPWR VGND sg13g2_xor2_1
XFILLER_108_906 VPWR VGND sg13g2_fill_2
X_20403_ _01061_ _01064_ _01057_ _01066_ VPWR VGND _01065_ sg13g2_nand4_1
X_21383_ _01998_ _01997_ _02000_ VPWR VGND sg13g2_xor2_1
X_23122_ net1606 VGND VPWR _00184_ u_FIR.sum\[7\]\[8\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
X_20334_ _00921_ _00924_ _00918_ _00997_ VPWR VGND sg13g2_nand3_1
X_20265_ _00917_ VPWR _00928_ VGND _00926_ _00927_ sg13g2_o21ai_1
X_23053_ net1126 VGND VPWR _00115_ u_FIR.sum\[3\]\[15\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
XFILLER_0_204 VPWR VGND sg13g2_decap_8
XFILLER_115_482 VPWR VGND sg13g2_fill_1
X_22004_ _02511_ _02375_ _02598_ VPWR VGND sg13g2_xor2_1
XFILLER_131_953 VPWR VGND sg13g2_decap_8
X_20196_ _00859_ _00822_ _00829_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_517 VPWR VGND sg13g2_fill_1
X_23419__1092 VPWR VGND net1091 sg13g2_tiehi
XFILLER_57_720 VPWR VGND sg13g2_fill_1
XFILLER_130_485 VPWR VGND sg13g2_decap_8
XFILLER_5_1023 VPWR VGND sg13g2_decap_8
XFILLER_29_433 VPWR VGND sg13g2_decap_4
XFILLER_56_230 VPWR VGND sg13g2_fill_2
X_22906_ VGND VPWR net553 _03210_ _00782_ _03181_ sg13g2_a21oi_1
XFILLER_17_628 VPWR VGND sg13g2_decap_8
XFILLER_17_639 VPWR VGND sg13g2_fill_1
XFILLER_16_116 VPWR VGND sg13g2_decap_8
XFILLER_45_959 VPWR VGND sg13g2_fill_2
XFILLER_44_436 VPWR VGND sg13g2_fill_1
XFILLER_112_41 VPWR VGND sg13g2_fill_2
XFILLER_71_222 VPWR VGND sg13g2_decap_4
XFILLER_112_63 VPWR VGND sg13g2_fill_1
X_22837_ VGND VPWR _03296_ net339 _00758_ _03136_ sg13g2_a21oi_1
XFILLER_44_458 VPWR VGND sg13g2_decap_8
XFILLER_44_469 VPWR VGND sg13g2_fill_1
XFILLER_53_970 VPWR VGND sg13g2_decap_8
XFILLER_53_981 VPWR VGND sg13g2_fill_2
X_13570_ _04901_ _04893_ _04900_ VPWR VGND sg13g2_nand2_1
X_22768_ u_debug_unit.mon_w4_sync\[0\] net340 _03102_ VPWR VGND sg13g2_nor2_1
XFILLER_72_78 VPWR VGND sg13g2_decap_4
X_23106__1048 VPWR VGND net1047 sg13g2_tiehi
X_12521_ _03895_ net720 net811 _03893_ VPWR VGND sg13g2_and3_1
XFILLER_13_856 VPWR VGND sg13g2_fill_1
X_21719_ net366 VPWR _02319_ VGND u_LMS.w\[7\]\[6\] net377 sg13g2_o21ai_1
XFILLER_12_344 VPWR VGND sg13g2_decap_8
XFILLER_13_878 VPWR VGND sg13g2_decap_8
X_22699_ u_debug_unit.force_w8\[7\] net458 _03069_ _00687_ VPWR VGND sg13g2_mux2_1
X_15240_ _06503_ _06509_ _06510_ VPWR VGND sg13g2_nor2b_1
X_12452_ _03801_ _03794_ _03808_ _03828_ VPWR VGND sg13g2_a21o_1
XFILLER_122_0 VPWR VGND sg13g2_decap_8
X_15171_ _06442_ _06414_ _06443_ VPWR VGND sg13g2_xor2_1
X_12383_ net866 _03760_ net719 _03761_ VPWR VGND sg13g2_nand3_1
X_14122_ _05433_ _05424_ _05432_ VPWR VGND sg13g2_nand2_1
X_23153__1560 VPWR VGND net1559 sg13g2_tiehi
XFILLER_4_554 VPWR VGND sg13g2_decap_4
X_18930_ _10017_ _10014_ _10016_ VPWR VGND sg13g2_nand2_1
X_14053_ _05366_ _05337_ _05364_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_279 VPWR VGND sg13g2_fill_1
XFILLER_122_920 VPWR VGND sg13g2_fill_2
X_13004_ _04360_ _04346_ _04359_ VPWR VGND sg13g2_xnor2_1
X_18861_ net201 _09947_ net657 _09948_ VPWR VGND sg13g2_nand3_1
XFILLER_97_75 VPWR VGND sg13g2_fill_2
X_17812_ _08933_ _08925_ _08945_ VPWR VGND sg13g2_xor2_1
X_18792_ net423 _03252_ _08068_ net201 _09879_ VPWR VGND sg13g2_nor4_1
XFILLER_11_7 VPWR VGND sg13g2_decap_8
X_17743_ _08867_ _08875_ _08876_ VPWR VGND sg13g2_nor2_1
X_14955_ _06159_ _06227_ _06236_ VPWR VGND sg13g2_nor2_1
XFILLER_130_1032 VPWR VGND sg13g2_decap_8
X_13906_ net1035 VPWR _05228_ VGND net536 u_FIR.sum\[3\]\[14\] sg13g2_o21ai_1
XFILLER_63_723 VPWR VGND sg13g2_fill_2
XFILLER_35_414 VPWR VGND sg13g2_decap_8
X_17674_ _08799_ _08806_ _08807_ VPWR VGND sg13g2_and2_1
X_14886_ _06153_ _06170_ _06171_ VPWR VGND sg13g2_nor2b_1
X_19413_ _03247_ net143 _10477_ VPWR VGND sg13g2_nor2_1
XFILLER_35_447 VPWR VGND sg13g2_decap_8
X_16625_ u_LMS.w\[5\]\[23\] u_LMS.w\[5\]\[22\] u_LMS.w\[5\]\[24\] _07809_ VPWR VGND
+ u_LMS.w\[5\]\[21\] sg13g2_nand4_1
X_13837_ _05159_ _05123_ _05161_ VPWR VGND sg13g2_xor2_1
XFILLER_63_767 VPWR VGND sg13g2_decap_8
XFILLER_63_778 VPWR VGND sg13g2_fill_2
XFILLER_62_244 VPWR VGND sg13g2_fill_2
XFILLER_62_255 VPWR VGND sg13g2_fill_1
XFILLER_44_970 VPWR VGND sg13g2_decap_4
X_19344_ _10408_ _10373_ _10407_ VPWR VGND sg13g2_xnor2_1
X_16556_ VGND VPWR u_LMS.w\[2\]\[14\] _07753_ _07759_ _07754_ sg13g2_a21oi_1
X_13768_ _05094_ _05093_ _05089_ VPWR VGND sg13g2_nand2b_1
XFILLER_94_4 VPWR VGND sg13g2_fill_1
XFILLER_43_491 VPWR VGND sg13g2_fill_2
X_15507_ VPWR _06765_ _06764_ VGND sg13g2_inv_1
X_12719_ _04053_ _04083_ _04084_ VPWR VGND sg13g2_nor2_1
X_19275_ _10341_ _10223_ _10225_ VPWR VGND sg13g2_xnor2_1
X_16487_ _07707_ net415 net812 VPWR VGND sg13g2_nand2_1
X_13699_ _05027_ u_FIR.sum\[2\]\[8\] net404 VPWR VGND sg13g2_xnor2_1
X_18226_ _09336_ net674 net164 VPWR VGND sg13g2_nand2_1
X_15438_ _06700_ _06683_ _06702_ VPWR VGND sg13g2_xor2_1
X_18157_ _09263_ _09266_ _09267_ VPWR VGND sg13g2_nor2_1
X_15369_ _06630_ _06632_ _06635_ VPWR VGND sg13g2_nor2_1
XFILLER_8_882 VPWR VGND sg13g2_fill_2
XFILLER_129_585 VPWR VGND sg13g2_fill_2
XFILLER_117_736 VPWR VGND sg13g2_decap_4
XFILLER_7_84 VPWR VGND sg13g2_decap_8
X_17108_ net417 net160 _08263_ _08264_ VPWR VGND sg13g2_nor3_1
X_18088_ _09190_ _09197_ net144 _09198_ VPWR VGND sg13g2_nand3_1
X_17039_ _08180_ _08194_ _08195_ VPWR VGND sg13g2_nor2_1
XFILLER_132_739 VPWR VGND sg13g2_decap_8
Xrebuffer2059 _01577_ net2058 VPWR VGND sg13g2_buf_2
X_20050_ _11091_ _11079_ _11086_ VPWR VGND sg13g2_xnor2_1
Xfanout806 net808 net806 VPWR VGND sg13g2_buf_1
XFILLER_112_430 VPWR VGND sg13g2_fill_1
Xfanout817 net818 net817 VPWR VGND sg13g2_buf_1
XFILLER_98_653 VPWR VGND sg13g2_decap_8
Xfanout828 net831 net828 VPWR VGND sg13g2_buf_1
XFILLER_98_664 VPWR VGND sg13g2_fill_1
Xfanout839 net840 net839 VPWR VGND sg13g2_buf_1
XFILLER_98_697 VPWR VGND sg13g2_decap_8
XFILLER_85_314 VPWR VGND sg13g2_decap_4
XFILLER_85_325 VPWR VGND sg13g2_fill_1
XFILLER_39_731 VPWR VGND sg13g2_fill_2
XFILLER_27_915 VPWR VGND sg13g2_decap_8
XFILLER_26_403 VPWR VGND sg13g2_decap_4
X_23740_ net988 VGND VPWR _00802_ spi_addr\[6\] clknet_3_1__leaf_spi_sclk sg13g2_dfrbpq_1
X_20952_ _03307_ _01591_ _01592_ VPWR VGND sg13g2_nor2_1
XFILLER_26_414 VPWR VGND sg13g2_decap_8
XFILLER_53_211 VPWR VGND sg13g2_fill_2
XFILLER_26_49 VPWR VGND sg13g2_fill_1
X_23671_ net1023 VGND VPWR _00733_ u_debug_unit.mon_w5_sync\[2\] clknet_leaf_20_clkA
+ sg13g2_dfrbpq_1
X_20883_ _01452_ _01453_ _01523_ VPWR VGND sg13g2_xor2_1
XFILLER_41_406 VPWR VGND sg13g2_decap_8
XFILLER_13_108 VPWR VGND sg13g2_fill_2
X_22622_ coeff_force_packed\[2\] net468 _03061_ _00618_ VPWR VGND sg13g2_mux2_1
X_22553_ _03034_ u_LMS.count\[18\] u_LMS.count\[17\] _03030_ VPWR VGND sg13g2_and3_1
X_23238__1414 VPWR VGND net1413 sg13g2_tiehi
X_21504_ VPWR _02121_ _02120_ VGND sg13g2_inv_1
X_22484_ VGND VPWR net446 net426 _00550_ _02991_ sg13g2_a21oi_1
X_23102__1054 VPWR VGND net1053 sg13g2_tiehi
X_21435_ _02052_ _02021_ _02029_ VPWR VGND sg13g2_xnor2_1
XFILLER_107_202 VPWR VGND sg13g2_decap_8
XFILLER_107_246 VPWR VGND sg13g2_decap_8
X_21366_ _03224_ _03226_ net93 _01983_ VGND VPWR net100 sg13g2_nor4_2
X_23105_ net1048 VGND VPWR _00167_ u_FIR.sum\[6\]\[10\] clknet_leaf_42_clkA sg13g2_dfrbpq_1
X_20317_ _00948_ _00947_ _00980_ VPWR VGND sg13g2_xor2_1
X_21297_ _01907_ VPWR _01914_ VGND _01873_ _01905_ sg13g2_o21ai_1
XFILLER_107_30 VPWR VGND sg13g2_decap_8
X_23115__1617 VPWR VGND net1616 sg13g2_tiehi
X_23036_ net1152 VGND VPWR _00098_ u_FIR.sum\[2\]\[17\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
XFILLER_122_249 VPWR VGND sg13g2_decap_8
X_20248_ _00911_ net636 net247 VPWR VGND sg13g2_nand2_1
XFILLER_89_664 VPWR VGND sg13g2_decap_4
XFILLER_88_141 VPWR VGND sg13g2_decap_4
X_20179_ _11191_ _00841_ _00842_ VPWR VGND sg13g2_nor2_1
XFILLER_91_306 VPWR VGND sg13g2_decap_4
XFILLER_57_561 VPWR VGND sg13g2_fill_2
X_14740_ VGND VPWR _06029_ _05983_ _05981_ sg13g2_or2_1
XFILLER_57_572 VPWR VGND sg13g2_fill_1
X_11952_ VPWR _03373_ u_FIR.w\[1\]\[6\] VGND sg13g2_inv_1
XFILLER_57_594 VPWR VGND sg13g2_decap_4
XFILLER_83_44 VPWR VGND sg13g2_decap_8
XFILLER_44_222 VPWR VGND sg13g2_decap_4
X_14671_ _05928_ _05961_ _05962_ VPWR VGND sg13g2_nor2_1
X_11883_ VPWR _03304_ u_LMS.w\[6\]\[8\] VGND sg13g2_inv_1
X_16410_ _07641_ _07639_ _07640_ VPWR VGND sg13g2_nand2_1
X_13622_ _04925_ _04951_ _04952_ VPWR VGND sg13g2_nor2_1
XFILLER_83_99 VPWR VGND sg13g2_decap_4
X_17390_ _08537_ _08535_ _08536_ VPWR VGND sg13g2_xnor2_1
XFILLER_60_748 VPWR VGND sg13g2_decap_4
X_16341_ _07574_ _07549_ _07575_ VPWR VGND sg13g2_xor2_1
XFILLER_41_951 VPWR VGND sg13g2_decap_4
X_13553_ _04885_ _04856_ _04883_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_613 VPWR VGND sg13g2_fill_1
X_19060_ _10144_ _10146_ _10147_ VPWR VGND sg13g2_and2_1
X_12504_ _03879_ _03862_ _03878_ VPWR VGND sg13g2_xnor2_1
XFILLER_40_472 VPWR VGND sg13g2_fill_2
X_16272_ _07482_ _07507_ _07508_ VPWR VGND sg13g2_nor2b_1
XFILLER_9_646 VPWR VGND sg13g2_decap_8
X_13484_ _04817_ _04810_ _04819_ VPWR VGND sg13g2_xor2_1
XFILLER_8_145 VPWR VGND sg13g2_fill_2
X_18011_ net40 VPWR _09135_ VGND net38 _09134_ sg13g2_o21ai_1
X_15223_ VGND VPWR _06473_ _06480_ _06493_ _06472_ sg13g2_a21oi_1
X_12435_ _03812_ _03792_ _03811_ VPWR VGND sg13g2_xnor2_1
X_15154_ _06425_ _06384_ _06426_ VPWR VGND sg13g2_xor2_1
X_12366_ _03745_ _03744_ _03713_ VPWR VGND sg13g2_nand2b_1
X_14105_ _05416_ net763 net836 VPWR VGND sg13g2_nand2_1
XFILLER_99_417 VPWR VGND sg13g2_fill_1
XFILLER_4_340 VPWR VGND sg13g2_decap_8
X_19962_ VGND VPWR _10978_ _11002_ _11003_ _11001_ sg13g2_a21oi_1
X_15085_ _06358_ _06355_ _06359_ VPWR VGND sg13g2_xor2_1
XFILLER_126_599 VPWR VGND sg13g2_decap_8
XFILLER_114_739 VPWR VGND sg13g2_fill_1
X_12297_ VGND VPWR net541 _03676_ _00055_ _03677_ sg13g2_a21oi_1
XFILLER_4_384 VPWR VGND sg13g2_fill_1
XFILLER_113_227 VPWR VGND sg13g2_decap_4
X_18913_ _09986_ VPWR _10000_ VGND _09983_ _09988_ sg13g2_o21ai_1
X_14036_ _05349_ _05348_ _05344_ VPWR VGND sg13g2_nand2b_1
XFILLER_113_249 VPWR VGND sg13g2_fill_2
X_19893_ net366 VPWR _10935_ VGND u_LMS.w\[4\]\[11\] net385 sg13g2_o21ai_1
XFILLER_122_761 VPWR VGND sg13g2_decap_4
XFILLER_79_152 VPWR VGND sg13g2_fill_2
X_18844_ _09924_ VPWR _09931_ VGND _09890_ _09922_ sg13g2_o21ai_1
XFILLER_80_1048 VPWR VGND sg13g2_decap_8
XFILLER_80_1059 VPWR VGND sg13g2_fill_2
XFILLER_79_185 VPWR VGND sg13g2_decap_8
X_18775_ _09780_ _09771_ _09862_ VPWR VGND sg13g2_xor2_1
X_22977__1641 VPWR net1640 clknet_3_7__leaf_spi_sclk VGND sg13g2_inv_1
X_15987_ net1002 VPWR _07229_ VGND net499 u_FIR.sum\[7\]\[18\] sg13g2_o21ai_1
XFILLER_48_550 VPWR VGND sg13g2_fill_1
X_17726_ _08859_ net696 net223 VPWR VGND sg13g2_nand2_1
XFILLER_94_188 VPWR VGND sg13g2_decap_8
XFILLER_82_328 VPWR VGND sg13g2_fill_2
X_14938_ VGND VPWR _06183_ _06203_ _06220_ _06202_ sg13g2_a21oi_1
XFILLER_94_199 VPWR VGND sg13g2_fill_1
XFILLER_36_745 VPWR VGND sg13g2_fill_2
XFILLER_36_756 VPWR VGND sg13g2_decap_8
XFILLER_36_767 VPWR VGND sg13g2_fill_1
X_17657_ VGND VPWR _08787_ _08789_ _08790_ _08786_ sg13g2_a21oi_1
X_14869_ _06130_ VPWR _06154_ VGND net269 _06132_ sg13g2_o21ai_1
XFILLER_90_350 VPWR VGND sg13g2_fill_2
XFILLER_36_789 VPWR VGND sg13g2_decap_8
X_16608_ net1022 VPWR _07798_ VGND net515 net763 sg13g2_o21ai_1
X_17588_ _08721_ _08718_ _08719_ VPWR VGND sg13g2_xnor2_1
XFILLER_16_491 VPWR VGND sg13g2_decap_8
X_19327_ VPWR _10391_ _10390_ VGND sg13g2_inv_1
X_16539_ net976 VPWR _07746_ VGND net479 u_FIR.w\[1\]\[5\] sg13g2_o21ai_1
XFILLER_32_973 VPWR VGND sg13g2_decap_8
XFILLER_85_0 VPWR VGND sg13g2_decap_8
X_19258_ _10208_ _10209_ _10199_ _10329_ VPWR VGND sg13g2_nand3_1
XFILLER_31_494 VPWR VGND sg13g2_decap_8
X_18209_ _09319_ _09317_ _09318_ VPWR VGND sg13g2_nand2_1
X_19189_ _10274_ net2088 _10236_ VPWR VGND sg13g2_xnor2_1
X_21220_ _01744_ _01742_ _01837_ VPWR VGND sg13g2_xor2_1
XFILLER_117_555 VPWR VGND sg13g2_fill_2
X_21151_ _01750_ VPWR _01768_ VGND _01747_ _01748_ sg13g2_o21ai_1
XFILLER_132_536 VPWR VGND sg13g2_decap_8
XFILLER_104_238 VPWR VGND sg13g2_decap_8
XFILLER_99_940 VPWR VGND sg13g2_fill_1
X_20102_ VGND VPWR _11138_ _11139_ _11143_ _11142_ sg13g2_a21oi_1
X_21082_ VGND VPWR _01708_ _01709_ _00430_ net937 sg13g2_a21oi_1
Xfanout603 u_LMS.x_r\[7\]\[1\] net603 VPWR VGND sg13g2_buf_1
Xfanout614 net615 net614 VPWR VGND sg13g2_buf_1
Xfanout625 u_LMS.x_r\[5\]\[6\] net625 VPWR VGND sg13g2_buf_1
X_20033_ _11074_ _11068_ _11072_ VPWR VGND sg13g2_xnor2_1
Xfanout636 net637 net636 VPWR VGND sg13g2_buf_1
Xfanout647 u_LMS.x_r\[4\]\[2\] net647 VPWR VGND sg13g2_buf_1
Xfanout658 u_LMS.x_r\[3\]\[4\] net658 VPWR VGND sg13g2_buf_1
X_23111__1623 VPWR VGND net1622 sg13g2_tiehi
Xfanout669 u_LMS.x_r\[2\]\[7\] net669 VPWR VGND sg13g2_buf_1
XFILLER_85_144 VPWR VGND sg13g2_decap_4
XFILLER_74_818 VPWR VGND sg13g2_decap_8
XFILLER_37_37 VPWR VGND sg13g2_decap_4
Xclkbuf_leaf_14_clkA clknet_4_9_0_clkA clknet_leaf_14_clkA VPWR VGND sg13g2_buf_8
XFILLER_39_561 VPWR VGND sg13g2_decap_8
XFILLER_85_188 VPWR VGND sg13g2_fill_2
X_21984_ net585 net587 net108 net82 _02578_ VPWR VGND sg13g2_and4_1
XFILLER_96_1033 VPWR VGND sg13g2_fill_1
XFILLER_2_1048 VPWR VGND sg13g2_decap_8
X_23126__1601 VPWR VGND net1600 sg13g2_tiehi
X_23723_ net1358 VGND VPWR _00785_ u_s2p_input.reg_sh\[4\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
XFILLER_2_1059 VPWR VGND sg13g2_fill_2
X_20935_ u_LMS.w\[6\]\[14\] _01574_ _01575_ VPWR VGND sg13g2_and2_1
XFILLER_81_350 VPWR VGND sg13g2_fill_1
X_23654_ net976 VGND VPWR _00716_ u_debug_unit.mon_w2_sync\[6\] clknet_leaf_49_clkA
+ sg13g2_dfrbpq_1
X_20866_ _01506_ _01505_ _01497_ VPWR VGND sg13g2_nand2b_1
XFILLER_53_47 VPWR VGND sg13g2_decap_8
XFILLER_53_58 VPWR VGND sg13g2_fill_1
X_22605_ net466 debug_load_bus\[3\] _03059_ _00603_ VPWR VGND sg13g2_mux2_1
XFILLER_23_951 VPWR VGND sg13g2_fill_2
X_23585_ net954 VGND VPWR _00647_ u_debug_unit.force_w3\[7\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
X_20797_ _01366_ _01436_ _01437_ VPWR VGND sg13g2_nor2b_1
XFILLER_50_770 VPWR VGND sg13g2_fill_2
XFILLER_22_461 VPWR VGND sg13g2_decap_8
X_22536_ u_LMS.count\[12\] _03022_ _03023_ VPWR VGND sg13g2_nor2_1
XFILLER_33_1050 VPWR VGND sg13g2_decap_8
X_22467_ net961 VPWR _02983_ VGND net449 net607 sg13g2_o21ai_1
XFILLER_6_627 VPWR VGND sg13g2_decap_8
XFILLER_108_533 VPWR VGND sg13g2_fill_1
X_12220_ _03594_ _03602_ _03603_ _03604_ VPWR VGND sg13g2_nor3_1
X_21418_ _02032_ _02031_ _02035_ VPWR VGND sg13g2_xor2_1
X_22398_ VGND VPWR net434 _03270_ _00507_ _02948_ sg13g2_a21oi_1
X_12151_ _03560_ net291 coeff_force_packed\[42\] _03418_ u_debug_unit.mon_w2_sync\[0\]
+ VPWR VGND sg13g2_a22oi_1
X_21349_ _01964_ net2138 _01966_ VPWR VGND sg13g2_xor2_1
XFILLER_2_855 VPWR VGND sg13g2_fill_1
X_12082_ _03495_ net287 coeff_force_packed\[32\] _03400_ u_debug_unit.mon_w3_sync\[4\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_110_208 VPWR VGND sg13g2_fill_2
X_23019_ net1177 VGND VPWR _00081_ u_FIR.sum\[2\]\[0\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
X_15910_ _07156_ _07128_ _07154_ VPWR VGND sg13g2_xnor2_1
XFILLER_104_794 VPWR VGND sg13g2_decap_4
X_16890_ _08046_ _08020_ _08045_ VPWR VGND sg13g2_nand2_1
XFILLER_49_336 VPWR VGND sg13g2_fill_1
X_15841_ _07065_ VPWR _07089_ VGND net275 _07066_ sg13g2_o21ai_1
XFILLER_92_604 VPWR VGND sg13g2_fill_2
X_18560_ _09668_ _09669_ _09670_ VPWR VGND sg13g2_nor2_1
X_15772_ _06949_ net790 _07021_ _07022_ VPWR VGND sg13g2_mux2_1
X_12984_ VPWR _04341_ _04340_ VGND sg13g2_inv_1
X_17511_ _08644_ _08609_ _08643_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_147 VPWR VGND sg13g2_decap_8
XFILLER_45_542 VPWR VGND sg13g2_fill_2
X_14723_ _06012_ net769 net836 VPWR VGND sg13g2_nand2_1
X_11935_ VPWR _03356_ u_LMS.w\[0\]\[12\] VGND sg13g2_inv_1
XFILLER_45_553 VPWR VGND sg13g2_decap_8
X_18491_ _09601_ u_LMS.w\[2\]\[11\] _09600_ VPWR VGND sg13g2_nand2_1
XFILLER_45_564 VPWR VGND sg13g2_fill_2
XFILLER_73_895 VPWR VGND sg13g2_fill_1
XFILLER_33_726 VPWR VGND sg13g2_decap_8
XFILLER_17_277 VPWR VGND sg13g2_fill_2
X_17442_ _08577_ _08453_ _08455_ VPWR VGND sg13g2_xnor2_1
X_14654_ _05943_ _05944_ _05945_ VPWR VGND sg13g2_and2_1
X_11866_ VPWR _03287_ u_LMS.x\[3\] VGND sg13g2_inv_1
X_13605_ _04935_ net752 net852 VPWR VGND sg13g2_nand2_1
X_17373_ net45 VPWR _08523_ VGND net43 _08522_ sg13g2_o21ai_1
X_14585_ _05878_ _05870_ _05877_ VPWR VGND sg13g2_nand2_1
X_11797_ VPWR _03218_ net589 VGND sg13g2_inv_1
XFILLER_14_984 VPWR VGND sg13g2_decap_8
X_19112_ _10199_ u_LMS.w\[3\]\[4\] _10198_ VPWR VGND sg13g2_nand2_1
XFILLER_14_995 VPWR VGND sg13g2_fill_1
X_16324_ _07558_ _07522_ _07557_ VPWR VGND sg13g2_nand2_1
X_13536_ _04868_ _04867_ _04860_ VPWR VGND sg13g2_nand2b_1
XFILLER_13_483 VPWR VGND sg13g2_fill_2
X_19043_ _10129_ _10087_ _10130_ VPWR VGND sg13g2_xor2_1
X_16255_ net834 net793 _07489_ _07491_ VPWR VGND sg13g2_a21o_1
XFILLER_118_319 VPWR VGND sg13g2_decap_4
X_13467_ _04806_ _04791_ _04805_ VPWR VGND sg13g2_xnor2_1
X_15206_ _06477_ u_FIR.sum\[5\]\[8\] net395 VPWR VGND sg13g2_xnor2_1
X_12418_ _03795_ net721 net841 VPWR VGND sg13g2_nand2_1
X_16186_ _07424_ _07405_ _07422_ VPWR VGND sg13g2_xnor2_1
X_13398_ VGND VPWR _04711_ _04721_ _04740_ _04728_ sg13g2_a21oi_1
XFILLER_127_875 VPWR VGND sg13g2_decap_4
X_15137_ net980 VPWR _06410_ VGND net485 u_FIR.sum\[6\]\[6\] sg13g2_o21ai_1
X_12349_ _03726_ _03727_ _03728_ VPWR VGND sg13g2_and2_1
X_19945_ VGND VPWR _10986_ _10985_ _10984_ sg13g2_or2_1
X_15068_ _06342_ net901 net776 net889 net777 VPWR VGND sg13g2_a22oi_1
XFILLER_4_63 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_37_clkA clknet_4_12_0_clkA clknet_leaf_37_clkA VPWR VGND sg13g2_buf_8
X_14019_ _05333_ _05327_ _05331_ VPWR VGND sg13g2_xnor2_1
X_19876_ VGND VPWR net53 _10921_ _10922_ net24 sg13g2_a21oi_1
XFILLER_110_731 VPWR VGND sg13g2_decap_4
XFILLER_96_954 VPWR VGND sg13g2_fill_1
XFILLER_67_122 VPWR VGND sg13g2_fill_2
XFILLER_68_656 VPWR VGND sg13g2_decap_8
X_18827_ _09914_ net656 net218 VPWR VGND sg13g2_nand2_1
XFILLER_96_987 VPWR VGND sg13g2_decap_8
XFILLER_67_166 VPWR VGND sg13g2_fill_2
X_18758_ _09845_ _09826_ _09843_ VPWR VGND sg13g2_nand2_1
X_17709_ _08842_ net698 net168 VPWR VGND sg13g2_nand2_1
X_18689_ _09776_ net80 _09774_ VPWR VGND sg13g2_nand2b_1
X_20720_ VPWR _01360_ _01359_ VGND sg13g2_inv_1
XFILLER_56_1050 VPWR VGND sg13g2_decap_8
X_20651_ _01291_ _01289_ _01290_ VPWR VGND sg13g2_nand2_1
XFILLER_11_409 VPWR VGND sg13g2_decap_8
XFILLER_17_1034 VPWR VGND sg13g2_decap_8
X_23370_ net1231 VGND VPWR _00432_ u_LMS.w\[6\]\[3\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
X_20582_ _01220_ VPWR _01222_ VGND net426 net88 sg13g2_o21ai_1
X_22321_ _02901_ _02785_ _02787_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_976 VPWR VGND sg13g2_fill_1
X_22252_ _02846_ net2165 _02813_ VPWR VGND sg13g2_xnor2_1
X_21203_ _01820_ _01766_ _01818_ VPWR VGND sg13g2_xnor2_1
X_22183_ _02696_ _02674_ _02777_ VPWR VGND sg13g2_xor2_1
XFILLER_132_311 VPWR VGND sg13g2_fill_2
XFILLER_105_536 VPWR VGND sg13g2_decap_8
X_21134_ _01751_ _01746_ _01749_ VPWR VGND sg13g2_xnor2_1
X_23700__1517 VPWR VGND net1516 sg13g2_tiehi
XFILLER_105_569 VPWR VGND sg13g2_fill_1
XFILLER_78_409 VPWR VGND sg13g2_decap_8
Xfanout400 _05469_ net400 VPWR VGND sg13g2_buf_1
Xfanout411 _03357_ net411 VPWR VGND sg13g2_buf_1
Xfanout422 _03259_ net422 VPWR VGND sg13g2_buf_1
XFILLER_99_781 VPWR VGND sg13g2_fill_2
XFILLER_48_14 VPWR VGND sg13g2_fill_2
XFILLER_132_377 VPWR VGND sg13g2_decap_8
XFILLER_101_720 VPWR VGND sg13g2_fill_1
X_21065_ _01643_ VPWR _01696_ VGND _01642_ _01647_ sg13g2_o21ai_1
Xfanout433 net434 net433 VPWR VGND sg13g2_buf_1
XFILLER_99_792 VPWR VGND sg13g2_decap_8
X_23026__1168 VPWR VGND net1167 sg13g2_tiehi
Xfanout444 net445 net444 VPWR VGND sg13g2_buf_1
Xfanout455 net456 net455 VPWR VGND sg13g2_buf_1
XFILLER_87_954 VPWR VGND sg13g2_decap_4
Xfanout466 spi_wdata\[3\] net466 VPWR VGND sg13g2_buf_1
X_20016_ _11057_ _11026_ _11055_ VPWR VGND sg13g2_xnor2_1
Xfanout477 net478 net477 VPWR VGND sg13g2_buf_1
XFILLER_24_1038 VPWR VGND sg13g2_fill_1
Xfanout488 net489 net488 VPWR VGND sg13g2_buf_1
Xfanout499 net503 net499 VPWR VGND sg13g2_buf_1
XFILLER_100_263 VPWR VGND sg13g2_fill_1
XFILLER_111_1019 VPWR VGND sg13g2_decap_8
XFILLER_73_114 VPWR VGND sg13g2_decap_8
XFILLER_100_296 VPWR VGND sg13g2_fill_1
XFILLER_55_851 VPWR VGND sg13g2_decap_8
XFILLER_64_35 VPWR VGND sg13g2_decap_8
XFILLER_55_862 VPWR VGND sg13g2_fill_1
X_21967_ net2167 _02560_ _02561_ VPWR VGND sg13g2_nor2_1
XFILLER_82_670 VPWR VGND sg13g2_fill_2
X_23706_ net1474 VGND VPWR _00768_ u_p2s_output.reg_cnt\[0\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
X_20918_ _01558_ _01545_ _01557_ VPWR VGND sg13g2_xnor2_1
XFILLER_27_597 VPWR VGND sg13g2_decap_4
X_23300__1302 VPWR VGND net1301 sg13g2_tiehi
XFILLER_42_534 VPWR VGND sg13g2_fill_1
X_21898_ VGND VPWR _02492_ _02491_ _02490_ sg13g2_or2_1
X_23637_ net986 VGND VPWR _00699_ u_debug_unit.mon_w0_sync\[3\] clknet_leaf_53_clkA
+ sg13g2_dfrbpq_1
X_20849_ _01489_ _01486_ _01488_ VPWR VGND sg13g2_nand2_1
Xfanout40 _09094_ net40 VPWR VGND sg13g2_buf_1
XFILLER_30_729 VPWR VGND sg13g2_decap_4
Xfanout51 net52 net51 VPWR VGND sg13g2_buf_1
Xfanout62 net64 net62 VPWR VGND sg13g2_buf_2
XFILLER_23_781 VPWR VGND sg13g2_decap_4
XFILLER_11_921 VPWR VGND sg13g2_fill_2
X_14370_ net279 _05672_ _05674_ VPWR VGND sg13g2_and2_1
X_23568_ net953 VGND VPWR _00630_ coeff_force_packed\[13\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
Xfanout73 net74 net73 VPWR VGND sg13g2_buf_2
Xfanout84 net84 net85 VPWR VGND sg13g2_buf_4
Xfanout95 net95 net96 VPWR VGND sg13g2_buf_4
X_13321_ _04637_ _04665_ _04666_ VPWR VGND sg13g2_nor2b_1
X_22519_ _03011_ _03012_ _00564_ VPWR VGND sg13g2_nor2b_1
XFILLER_7_925 VPWR VGND sg13g2_decap_8
X_23499_ net1415 VGND VPWR _00561_ u_LMS.count\[2\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
XFILLER_109_842 VPWR VGND sg13g2_fill_2
X_22976__1640 VPWR net1639 clknet_3_6__leaf_spi_sclk VGND sg13g2_inv_1
X_23333__1269 VPWR VGND net1268 sg13g2_tiehi
X_16040_ net801 u_FIR.sum\[7\]\[0\] _07281_ VPWR VGND sg13g2_and2_1
X_13252_ _04566_ _04559_ _04574_ _04598_ VPWR VGND sg13g2_a21o_1
X_12203_ _03588_ _03589_ _03582_ _03591_ VPWR VGND _03590_ sg13g2_nand4_1
XFILLER_124_812 VPWR VGND sg13g2_fill_2
XFILLER_124_823 VPWR VGND sg13g2_fill_1
XFILLER_123_300 VPWR VGND sg13g2_decap_8
X_13183_ net829 _04530_ net745 _04531_ VPWR VGND sg13g2_nand3_1
XFILLER_124_856 VPWR VGND sg13g2_fill_1
X_12134_ _03544_ _03434_ u_debug_unit.mon_w0_sync\[1\] _03410_ u_debug_unit.mon_w4_sync\[1\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_124_878 VPWR VGND sg13g2_decap_4
X_17991_ VGND VPWR _09117_ _09118_ _00308_ net923 sg13g2_a21oi_1
XFILLER_124_889 VPWR VGND sg13g2_fill_1
XFILLER_1_140 VPWR VGND sg13g2_decap_8
X_19730_ _10794_ _10793_ _10758_ VPWR VGND sg13g2_nand2b_1
X_16942_ _08098_ _08096_ _08097_ VPWR VGND sg13g2_nand2_1
X_12065_ _03472_ _03478_ _03471_ _03479_ VPWR VGND sg13g2_nand3_1
XFILLER_78_976 VPWR VGND sg13g2_decap_8
X_19661_ _10626_ VPWR _10725_ VGND _10724_ _10722_ sg13g2_o21ai_1
X_16873_ _08029_ _08027_ _08028_ VPWR VGND sg13g2_nand2_1
XFILLER_78_987 VPWR VGND sg13g2_fill_1
XFILLER_38_829 VPWR VGND sg13g2_decap_8
XFILLER_65_626 VPWR VGND sg13g2_decap_8
X_18612_ VGND VPWR _09664_ _09708_ _09713_ _09665_ sg13g2_a21oi_1
X_15824_ _07073_ _07072_ _07037_ VPWR VGND sg13g2_nand2b_1
X_19592_ net206 _10655_ net647 _10656_ VPWR VGND sg13g2_nand3_1
XFILLER_93_957 VPWR VGND sg13g2_decap_8
X_18543_ _09592_ VPWR _09653_ VGND _09652_ _09651_ sg13g2_o21ai_1
X_15755_ _06978_ _07005_ _07006_ VPWR VGND sg13g2_nor2b_1
X_12967_ _04325_ u_FIR.sum\[0\]\[13\] net408 VPWR VGND sg13g2_xnor2_1
X_14706_ _05996_ _05953_ _05994_ VPWR VGND sg13g2_xnor2_1
X_11918_ VPWR _03339_ u_LMS.w\[2\]\[6\] VGND sg13g2_inv_1
X_18474_ _09584_ _09583_ _09570_ VPWR VGND sg13g2_xnor2_1
X_15686_ _06917_ VPWR _06938_ VGND _06918_ _06926_ sg13g2_o21ai_1
X_12898_ _04256_ _04257_ _04258_ VPWR VGND sg13g2_nor2_1
X_17425_ _08563_ _08564_ _00296_ VPWR VGND sg13g2_nor2_1
XFILLER_127_1037 VPWR VGND sg13g2_decap_8
X_14637_ VGND VPWR _05890_ _05919_ _05928_ _05918_ sg13g2_a21oi_1
X_11849_ VPWR _03270_ net691 VGND sg13g2_inv_1
Xclkbuf_0_clkA clknet_0_clkA clkA VPWR VGND sg13g2_buf_16
XFILLER_20_228 VPWR VGND sg13g2_fill_1
X_17356_ _08406_ u_LMS.w\[0\]\[15\] _08509_ VPWR VGND sg13g2_xor2_1
X_14568_ _05861_ net770 net862 VPWR VGND sg13g2_nand2_1
X_16307_ _07542_ _07519_ _07540_ VPWR VGND sg13g2_xnor2_1
XFILLER_118_105 VPWR VGND sg13g2_fill_2
X_13519_ _04852_ _04843_ _04850_ VPWR VGND sg13g2_xnor2_1
XFILLER_118_116 VPWR VGND sg13g2_decap_8
X_17287_ _08424_ u_LMS.w\[0\]\[6\] _08443_ VPWR VGND sg13g2_xor2_1
X_14499_ VGND VPWR _05795_ _05794_ _05785_ sg13g2_or2_1
XFILLER_9_284 VPWR VGND sg13g2_fill_2
XFILLER_118_127 VPWR VGND sg13g2_fill_2
Xclkload10 clknet_4_12_0_clkA clkload10/X VPWR VGND sg13g2_buf_8
Xclkload21 clknet_leaf_55_clkA clkload21/Y VPWR VGND sg13g2_inv_4
X_19026_ _10111_ _10067_ _10113_ VPWR VGND sg13g2_xor2_1
Xclkload32 clknet_leaf_7_clkA clkload32/Y VPWR VGND sg13g2_inv_4
X_16238_ _07474_ _07442_ _07475_ VPWR VGND sg13g2_nor2b_1
X_23309__1293 VPWR VGND net1292 sg13g2_tiehi
Xclkload43 VPWR clkload43/Y clknet_leaf_36_clkA VGND sg13g2_inv_1
XFILLER_86_1010 VPWR VGND sg13g2_decap_4
Xclkload54 VPWR clkload54/Y clknet_3_3__leaf_spi_sclk VGND sg13g2_inv_1
XFILLER_6_980 VPWR VGND sg13g2_fill_1
X_16169_ _07407_ net795 net846 VPWR VGND sg13g2_nand2_1
XFILLER_127_694 VPWR VGND sg13g2_fill_1
XFILLER_126_182 VPWR VGND sg13g2_decap_8
XFILLER_114_322 VPWR VGND sg13g2_fill_2
XFILLER_88_707 VPWR VGND sg13g2_fill_2
XFILLER_48_0 VPWR VGND sg13g2_decap_8
XFILLER_47_1038 VPWR VGND sg13g2_fill_1
X_19928_ _10966_ _10968_ _10969_ VPWR VGND sg13g2_nor2_1
X_19859_ _10909_ _10771_ _10773_ VPWR VGND sg13g2_xnor2_1
XFILLER_95_261 VPWR VGND sg13g2_fill_1
XFILLER_110_572 VPWR VGND sg13g2_decap_8
XFILLER_18_28 VPWR VGND sg13g2_fill_1
XFILLER_84_946 VPWR VGND sg13g2_fill_1
XFILLER_55_114 VPWR VGND sg13g2_fill_1
X_22870_ net951 VPWR _03161_ VGND u_p2s_output.reg_sh\[6\] net299 sg13g2_o21ai_1
XFILLER_84_957 VPWR VGND sg13g2_fill_2
X_23022__1174 VPWR VGND net1173 sg13g2_tiehi
XFILLER_37_840 VPWR VGND sg13g2_fill_2
XFILLER_37_851 VPWR VGND sg13g2_decap_8
X_21821_ _02415_ _02362_ _02414_ VPWR VGND sg13g2_xnor2_1
XFILLER_55_158 VPWR VGND sg13g2_fill_2
XFILLER_43_309 VPWR VGND sg13g2_decap_8
XFILLER_52_832 VPWR VGND sg13g2_decap_4
X_21752_ _02346_ _02341_ _02344_ VPWR VGND sg13g2_xnor2_1
XFILLER_51_331 VPWR VGND sg13g2_fill_1
X_20703_ _01339_ _01338_ _01342_ _01343_ VPWR VGND sg13g2_a21o_1
X_21683_ net12 VPWR _02291_ VGND net11 _02290_ sg13g2_o21ai_1
XFILLER_51_364 VPWR VGND sg13g2_decap_8
XFILLER_51_375 VPWR VGND sg13g2_fill_1
X_23422_ net1082 VGND VPWR _00484_ u_LMS.w\[8\]\[9\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
X_20634_ _01274_ net197 net606 net227 net609 VPWR VGND sg13g2_a22oi_1
Xclkload4 clknet_4_5_0_clkA clkload4/X VPWR VGND sg13g2_buf_8
X_23353_ net1248 VGND VPWR _00415_ u_LMS.w\[5\]\[9\] clknet_leaf_11_clkA sg13g2_dfrbpq_1
X_20565_ _01205_ net88 net608 net102 net606 VPWR VGND sg13g2_a22oi_1
XFILLER_126_7 VPWR VGND sg13g2_decap_8
X_22304_ net8 VPWR _02888_ VGND net7 _02887_ sg13g2_o21ai_1
X_23284_ net1325 VGND VPWR _00346_ u_LMS.w\[2\]\[9\] clknet_leaf_64_clkA sg13g2_dfrbpq_1
XFILLER_4_906 VPWR VGND sg13g2_fill_1
X_20496_ net365 VPWR _01140_ VGND u_LMS.w\[5\]\[8\] net383 sg13g2_o21ai_1
X_22235_ _02828_ VPWR _02829_ VGND _02753_ _02827_ sg13g2_o21ai_1
X_22166_ _02728_ _02729_ _02760_ VPWR VGND sg13g2_xor2_1
XFILLER_59_35 VPWR VGND sg13g2_decap_8
XFILLER_105_388 VPWR VGND sg13g2_decap_4
X_21117_ VGND VPWR _01657_ _01735_ _01736_ _01710_ sg13g2_a21oi_1
XFILLER_59_79 VPWR VGND sg13g2_decap_4
XFILLER_132_185 VPWR VGND sg13g2_decap_8
X_22097_ _02680_ _02687_ _02691_ VPWR VGND sg13g2_nor2_1
Xfanout230 net232 net230 VPWR VGND sg13g2_buf_1
Xfanout241 net242 net241 VPWR VGND sg13g2_buf_1
XFILLER_59_431 VPWR VGND sg13g2_decap_4
XFILLER_115_30 VPWR VGND sg13g2_decap_8
Xfanout252 _07923_ net252 VPWR VGND sg13g2_buf_1
XFILLER_8_1054 VPWR VGND sg13g2_decap_8
X_21048_ _01637_ _01638_ _01566_ _01682_ VPWR VGND sg13g2_nand3_1
Xfanout263 net265 net263 VPWR VGND sg13g2_buf_1
XFILLER_87_762 VPWR VGND sg13g2_fill_1
Xfanout274 _07069_ net274 VPWR VGND sg13g2_buf_1
XFILLER_59_464 VPWR VGND sg13g2_fill_2
Xfanout285 _03441_ net285 VPWR VGND sg13g2_buf_1
XFILLER_75_924 VPWR VGND sg13g2_fill_1
XFILLER_75_23 VPWR VGND sg13g2_fill_2
Xfanout296 _03424_ net296 VPWR VGND sg13g2_buf_1
XFILLER_74_412 VPWR VGND sg13g2_decap_4
XFILLER_101_594 VPWR VGND sg13g2_fill_2
X_13870_ _05193_ _05087_ _05191_ VPWR VGND sg13g2_xnor2_1
XFILLER_74_456 VPWR VGND sg13g2_fill_2
Xclkbuf_4_9_0_clkA clknet_0_clkA clknet_4_9_0_clkA VPWR VGND sg13g2_buf_8
X_12821_ net734 net814 net732 _04183_ VPWR VGND sg13g2_nand3_1
XFILLER_62_607 VPWR VGND sg13g2_decap_4
X_22999_ net1207 VGND VPWR _00061_ u_FIR.sum\[0\]\[11\] clknet_leaf_29_clkA sg13g2_dfrbpq_1
X_15540_ _06796_ net789 net858 VPWR VGND sg13g2_nand2_1
X_12752_ _04116_ u_FIR.sum\[0\]\[7\] net407 VPWR VGND sg13g2_nand2_1
XFILLER_42_320 VPWR VGND sg13g2_fill_1
XFILLER_43_854 VPWR VGND sg13g2_decap_8
XFILLER_42_331 VPWR VGND sg13g2_fill_1
XFILLER_91_44 VPWR VGND sg13g2_fill_1
XFILLER_131_95 VPWR VGND sg13g2_decap_8
X_15471_ VGND VPWR net500 _06731_ _00174_ _06732_ sg13g2_a21oi_1
X_12683_ _04013_ _04012_ _04049_ VPWR VGND sg13g2_nor2b_1
X_17210_ _08160_ _08156_ _08366_ VPWR VGND sg13g2_xor2_1
X_14422_ _05673_ _05703_ _05722_ _05724_ VPWR VGND sg13g2_or3_1
X_18190_ _09300_ _09265_ _09267_ VPWR VGND sg13g2_xnor2_1
XFILLER_11_751 VPWR VGND sg13g2_decap_4
X_17141_ _08295_ _08294_ _08297_ VPWR VGND sg13g2_xor2_1
X_14353_ _05658_ _05636_ _05656_ VPWR VGND sg13g2_xnor2_1
X_13304_ net843 net739 _04647_ _04649_ VPWR VGND sg13g2_a21o_1
XFILLER_7_744 VPWR VGND sg13g2_fill_1
X_17072_ _08227_ _08221_ _08228_ VPWR VGND sg13g2_xor2_1
XFILLER_6_232 VPWR VGND sg13g2_fill_2
XFILLER_128_458 VPWR VGND sg13g2_fill_1
X_23262__1370 VPWR VGND net1369 sg13g2_tiehi
X_14284_ _05591_ _05582_ _05589_ VPWR VGND sg13g2_xnor2_1
X_23477__1494 VPWR VGND net1493 sg13g2_tiehi
X_16023_ _07264_ _07263_ _07256_ VPWR VGND sg13g2_nand2b_1
X_13235_ _04582_ _04578_ _04581_ VPWR VGND sg13g2_xnor2_1
X_13166_ _04514_ _04513_ _00087_ VPWR VGND sg13g2_nor2b_1
XFILLER_3_972 VPWR VGND sg13g2_decap_8
X_12117_ _03525_ _03526_ _03523_ _03528_ VPWR VGND _03527_ sg13g2_nand4_1
XFILLER_123_174 VPWR VGND sg13g2_fill_1
X_17974_ net41 VPWR _09105_ VGND net39 _09104_ sg13g2_o21ai_1
X_13097_ _04444_ _04446_ _04447_ VPWR VGND sg13g2_nor2_1
XFILLER_123_196 VPWR VGND sg13g2_fill_1
X_19713_ VGND VPWR u_LMS.w\[4\]\[4\] _10767_ _10777_ _10776_ sg13g2_a21oi_1
X_16925_ VGND VPWR _08081_ _08080_ _08079_ sg13g2_or2_1
X_12048_ _03458_ _03462_ _03463_ VPWR VGND sg13g2_nor2_1
XFILLER_38_615 VPWR VGND sg13g2_decap_8
XFILLER_65_412 VPWR VGND sg13g2_fill_1
XFILLER_38_637 VPWR VGND sg13g2_fill_1
X_19644_ _10708_ _10681_ _10707_ VPWR VGND sg13g2_xnor2_1
X_16856_ _08009_ _08011_ _08012_ VPWR VGND sg13g2_nor2_1
XFILLER_65_434 VPWR VGND sg13g2_fill_1
XFILLER_1_42 VPWR VGND sg13g2_decap_8
XFILLER_93_754 VPWR VGND sg13g2_fill_1
X_15807_ _07031_ VPWR _07056_ VGND net275 _07032_ sg13g2_o21ai_1
XFILLER_37_158 VPWR VGND sg13g2_fill_2
X_19575_ _10632_ VPWR _10639_ VGND _10601_ _10630_ sg13g2_o21ai_1
XFILLER_53_618 VPWR VGND sg13g2_decap_8
X_16787_ net418 _03276_ net193 net160 _07943_ VPWR VGND sg13g2_nor4_1
X_13999_ VGND VPWR _05310_ _05312_ _05314_ _05298_ sg13g2_a21oi_1
X_18526_ _09604_ u_LMS.w\[2\]\[9\] _09636_ VPWR VGND sg13g2_xor2_1
X_15738_ _06989_ net819 u_FIR.w\[1\]\[3\] net803 u_FIR.w\[1\]\[2\] VPWR VGND sg13g2_a22oi_1
XFILLER_33_320 VPWR VGND sg13g2_decap_8
XFILLER_61_640 VPWR VGND sg13g2_decap_8
XFILLER_34_876 VPWR VGND sg13g2_decap_8
X_18457_ _09565_ VPWR _09567_ VGND _09566_ _09563_ sg13g2_o21ai_1
X_15669_ _06922_ u_FIR.sum\[6\]\[7\] net392 VPWR VGND sg13g2_nand2_1
X_17408_ _08551_ u_LMS.w\[0\]\[2\] _08332_ VPWR VGND sg13g2_xnor2_1
X_23414__1107 VPWR VGND net1106 sg13g2_tiehi
X_18388_ _09498_ _09497_ _09496_ VPWR VGND sg13g2_nand2b_1
X_17339_ net59 net321 _08495_ VPWR VGND sg13g2_and2_1
XFILLER_14_1048 VPWR VGND sg13g2_decap_8
XFILLER_101_1007 VPWR VGND sg13g2_decap_8
XFILLER_14_1059 VPWR VGND sg13g2_fill_2
X_20350_ _00999_ _01012_ _01013_ VPWR VGND sg13g2_nor2_1
XFILLER_119_469 VPWR VGND sg13g2_fill_1
XFILLER_128_970 VPWR VGND sg13g2_decap_8
X_19009_ _10096_ net668 net202 VPWR VGND sg13g2_nand2_1
X_20281_ _00944_ _00940_ _00941_ VPWR VGND sg13g2_xnor2_1
X_22020_ _02614_ _02609_ _02612_ VPWR VGND sg13g2_xnor2_1
XFILLER_88_515 VPWR VGND sg13g2_fill_1
XFILLER_29_38 VPWR VGND sg13g2_fill_1
XFILLER_69_762 VPWR VGND sg13g2_decap_8
XFILLER_102_369 VPWR VGND sg13g2_fill_1
XFILLER_68_250 VPWR VGND sg13g2_fill_1
XFILLER_60_1035 VPWR VGND sg13g2_decap_8
XFILLER_29_615 VPWR VGND sg13g2_fill_2
XFILLER_68_261 VPWR VGND sg13g2_fill_2
XFILLER_96_581 VPWR VGND sg13g2_decap_8
XFILLER_68_272 VPWR VGND sg13g2_decap_4
X_22922_ VPWR _00790_ _03189_ VGND sg13g2_inv_1
XFILLER_84_732 VPWR VGND sg13g2_decap_4
XFILLER_56_434 VPWR VGND sg13g2_fill_1
XFILLER_29_648 VPWR VGND sg13g2_fill_2
XFILLER_110_391 VPWR VGND sg13g2_fill_2
XFILLER_56_445 VPWR VGND sg13g2_fill_2
XFILLER_28_147 VPWR VGND sg13g2_decap_8
X_22853_ VGND VPWR net299 _03147_ _00762_ _03148_ sg13g2_a21oi_1
X_21804_ _02397_ _02387_ _02398_ VPWR VGND sg13g2_xor2_1
X_22784_ u_debug_unit.mon_w5_sync\[1\] net346 _03110_ VPWR VGND sg13g2_nor2_1
X_21735_ net366 VPWR _02331_ VGND u_LMS.w\[7\]\[10\] net377 sg13g2_o21ai_1
XFILLER_24_353 VPWR VGND sg13g2_decap_8
XFILLER_40_813 VPWR VGND sg13g2_fill_1
XFILLER_101_54 VPWR VGND sg13g2_decap_8
XFILLER_25_898 VPWR VGND sg13g2_fill_1
XFILLER_12_515 VPWR VGND sg13g2_fill_2
X_21666_ net313 _02276_ _02277_ VPWR VGND sg13g2_nor2_1
X_23405_ net1133 VGND VPWR _00467_ u_LMS.w\[8\]\[15\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_20617_ _01257_ _01256_ net117 VPWR VGND sg13g2_nand2b_1
X_21597_ u_LMS.w\[7\]\[11\] _02172_ _02214_ VPWR VGND sg13g2_nor2_1
X_22992__1219 VPWR VGND net1218 sg13g2_tiehi
X_23336_ net1265 VGND VPWR _00398_ u_LMS.w\[5\]\[15\] clknet_leaf_20_clkA sg13g2_dfrbpq_1
X_20548_ _01172_ _01187_ _01188_ VPWR VGND sg13g2_nor2_1
XFILLER_126_929 VPWR VGND sg13g2_fill_1
XFILLER_4_703 VPWR VGND sg13g2_decap_8
X_23224__1438 VPWR VGND net1437 sg13g2_tiehi
X_23267_ net1359 VGND VPWR _00329_ u_LMS.w\[2\]\[15\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
X_20479_ VGND VPWR net51 _01126_ _01127_ net19 sg13g2_a21oi_1
X_13020_ _04374_ _04368_ _04373_ VPWR VGND sg13g2_xnor2_1
XFILLER_105_130 VPWR VGND sg13g2_decap_8
X_22218_ _02812_ _03297_ _02767_ VPWR VGND sg13g2_nand2_1
XFILLER_105_141 VPWR VGND sg13g2_fill_2
X_23198_ net1484 VGND VPWR _00260_ u_FIR.w\[6\]\[1\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
XFILLER_121_601 VPWR VGND sg13g2_decap_4
XFILLER_105_163 VPWR VGND sg13g2_decap_4
XFILLER_117_1025 VPWR VGND sg13g2_fill_1
X_22149_ net576 net149 net573 _02743_ VPWR VGND sg13g2_nand3_1
Xfanout1003 net1009 net1003 VPWR VGND sg13g2_buf_1
Xfanout1014 net1018 net1014 VPWR VGND sg13g2_buf_1
Xfanout1025 net1026 net1025 VPWR VGND sg13g2_buf_1
XFILLER_117_1058 VPWR VGND sg13g2_fill_2
XFILLER_0_964 VPWR VGND sg13g2_decap_8
Xfanout1036 net1042 net1036 VPWR VGND sg13g2_buf_1
X_14971_ _06242_ _06238_ _06236_ _06251_ VPWR VGND sg13g2_mux2_1
XFILLER_48_935 VPWR VGND sg13g2_decap_8
XFILLER_19_103 VPWR VGND sg13g2_decap_4
X_16710_ u_LMS.w\[8\]\[24\] _07872_ _07873_ VPWR VGND sg13g2_nor2_1
XFILLER_75_732 VPWR VGND sg13g2_fill_1
XFILLER_48_946 VPWR VGND sg13g2_fill_2
X_13922_ _05230_ _05242_ _05243_ VPWR VGND sg13g2_nor2b_1
X_17690_ VGND VPWR _08811_ _08822_ _08823_ _08810_ sg13g2_a21oi_1
XFILLER_47_434 VPWR VGND sg13g2_decap_8
XFILLER_47_445 VPWR VGND sg13g2_fill_1
XFILLER_75_776 VPWR VGND sg13g2_fill_1
X_16641_ VGND VPWR net518 _07820_ _00255_ _07821_ sg13g2_a21oi_1
X_13853_ _05151_ _05176_ _05177_ VPWR VGND sg13g2_nor2_1
XFILLER_90_724 VPWR VGND sg13g2_decap_8
XFILLER_63_938 VPWR VGND sg13g2_decap_4
XFILLER_16_821 VPWR VGND sg13g2_fill_2
X_19360_ _10423_ _10417_ _10424_ VPWR VGND sg13g2_xor2_1
X_12804_ _04167_ _04130_ _04165_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_1020 VPWR VGND sg13g2_fill_2
X_16572_ _07770_ _07768_ _07769_ VPWR VGND sg13g2_nand2_1
XFILLER_34_139 VPWR VGND sg13g2_decap_8
XFILLER_16_843 VPWR VGND sg13g2_fill_2
X_13784_ _05110_ _05083_ _05108_ VPWR VGND sg13g2_xnor2_1
X_18311_ VGND VPWR _09417_ _09420_ _09421_ _09388_ sg13g2_a21oi_1
XFILLER_71_960 VPWR VGND sg13g2_fill_1
X_15523_ _06780_ net787 net887 VPWR VGND sg13g2_nand2_1
X_19291_ _10355_ _10351_ _10354_ VPWR VGND sg13g2_nand2_1
X_12735_ _04099_ _04098_ _04094_ VPWR VGND sg13g2_nand2b_1
XFILLER_42_150 VPWR VGND sg13g2_fill_1
X_23142__1577 VPWR VGND net1576 sg13g2_tiehi
X_18242_ _09313_ _09316_ _09352_ VPWR VGND sg13g2_xor2_1
X_15454_ _06717_ _06704_ _06716_ VPWR VGND sg13g2_xnor2_1
X_12666_ _04030_ _04023_ _04032_ VPWR VGND sg13g2_xor2_1
XFILLER_42_194 VPWR VGND sg13g2_fill_2
XFILLER_129_701 VPWR VGND sg13g2_decap_8
X_14405_ _05695_ _05707_ _05708_ VPWR VGND sg13g2_nor2_1
X_18173_ _09283_ net120 _09281_ VPWR VGND sg13g2_xnor2_1
X_15385_ _06651_ net276 _06650_ VPWR VGND sg13g2_xnor2_1
X_12597_ _03964_ _03965_ _03966_ VPWR VGND sg13g2_nor2b_1
X_17124_ _08280_ _08231_ _08232_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_244 VPWR VGND sg13g2_decap_8
X_14336_ _05641_ _05640_ _05639_ VPWR VGND sg13g2_nand2b_1
X_17055_ net135 _08210_ net711 _08211_ VPWR VGND sg13g2_nand3_1
X_14267_ net838 _05573_ net757 _05574_ VPWR VGND sg13g2_nand3_1
Xrebuffer2208 u_FIR.sum\[8\]\[18\] net2207 VPWR VGND sg13g2_buf_1
Xrebuffer2219 _01998_ net2218 VPWR VGND sg13g2_buf_1
X_16006_ _07247_ _07240_ _07245_ VPWR VGND sg13g2_xnor2_1
X_13218_ _04565_ _04564_ _04560_ VPWR VGND sg13g2_nand2b_1
XFILLER_131_409 VPWR VGND sg13g2_decap_8
X_14198_ _05460_ VPWR _05507_ VGND _05417_ _05458_ sg13g2_o21ai_1
XFILLER_98_824 VPWR VGND sg13g2_decap_8
X_13149_ VGND VPWR net747 net829 _04498_ u_FIR.sum\[1\]\[6\] sg13g2_a21oi_1
XFILLER_111_133 VPWR VGND sg13g2_fill_1
XFILLER_100_807 VPWR VGND sg13g2_decap_8
XFILLER_100_818 VPWR VGND sg13g2_fill_2
XFILLER_97_367 VPWR VGND sg13g2_decap_4
X_17957_ _09090_ u_LMS.w\[1\]\[24\] net78 VPWR VGND sg13g2_nand2_1
XFILLER_111_166 VPWR VGND sg13g2_decap_8
XFILLER_111_177 VPWR VGND sg13g2_fill_2
X_16908_ _08064_ _08027_ _08063_ VPWR VGND sg13g2_xnor2_1
X_17888_ _09020_ VPWR _09021_ VGND _03345_ _09002_ sg13g2_o21ai_1
XFILLER_65_231 VPWR VGND sg13g2_fill_1
XFILLER_39_979 VPWR VGND sg13g2_fill_1
XFILLER_54_916 VPWR VGND sg13g2_fill_2
X_19627_ _10691_ _10667_ _10668_ VPWR VGND sg13g2_xnor2_1
X_16839_ _07995_ net86 _07994_ VPWR VGND sg13g2_nand2_1
XFILLER_93_584 VPWR VGND sg13g2_fill_2
XFILLER_93_595 VPWR VGND sg13g2_fill_2
XFILLER_20_1052 VPWR VGND sg13g2_decap_8
X_19558_ _10621_ VPWR _10622_ VGND _10613_ _10616_ sg13g2_o21ai_1
X_18509_ _09615_ VPWR _09619_ VGND _09616_ _09617_ sg13g2_o21ai_1
XFILLER_62_971 VPWR VGND sg13g2_decap_8
X_19489_ _10549_ _10552_ _10553_ VPWR VGND sg13g2_and2_1
XFILLER_33_150 VPWR VGND sg13g2_fill_2
X_21520_ _02135_ _02136_ _02137_ VPWR VGND sg13g2_nor2_1
XFILLER_22_879 VPWR VGND sg13g2_fill_1
XFILLER_21_367 VPWR VGND sg13g2_fill_2
XFILLER_119_200 VPWR VGND sg13g2_fill_2
X_21451_ net604 net229 net602 _02068_ VPWR VGND net211 sg13g2_nand4_1
X_20402_ _01065_ u_LMS.w\[5\]\[23\] net76 VPWR VGND sg13g2_xnor2_1
X_21382_ _01997_ net2213 _01999_ VPWR VGND sg13g2_nor2_1
XFILLER_119_277 VPWR VGND sg13g2_fill_1
X_23121_ net1607 VGND VPWR _00183_ u_FIR.sum\[7\]\[7\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
X_20333_ _00996_ _00926_ _00927_ VPWR VGND sg13g2_xnor2_1
XFILLER_116_962 VPWR VGND sg13g2_fill_1
X_23052_ net1128 VGND VPWR _00114_ u_FIR.sum\[3\]\[14\] clknet_leaf_33_clkA sg13g2_dfrbpq_1
X_20264_ _00916_ _00908_ _00927_ VPWR VGND sg13g2_xor2_1
XFILLER_116_973 VPWR VGND sg13g2_fill_2
XFILLER_103_601 VPWR VGND sg13g2_fill_1
XFILLER_116_995 VPWR VGND sg13g2_decap_4
X_22003_ _02567_ VPWR _02597_ VGND _02500_ _02543_ sg13g2_o21ai_1
XFILLER_88_312 VPWR VGND sg13g2_decap_8
XFILLER_131_932 VPWR VGND sg13g2_decap_8
X_20195_ VGND VPWR _00839_ _00847_ _00858_ _00857_ sg13g2_a21oi_1
XFILLER_88_345 VPWR VGND sg13g2_decap_8
XFILLER_0_249 VPWR VGND sg13g2_decap_8
XFILLER_89_879 VPWR VGND sg13g2_decap_8
XFILLER_131_976 VPWR VGND sg13g2_fill_1
XFILLER_5_1002 VPWR VGND sg13g2_decap_8
XFILLER_45_905 VPWR VGND sg13g2_decap_4
XFILLER_72_702 VPWR VGND sg13g2_decap_8
XFILLER_56_69 VPWR VGND sg13g2_fill_1
X_22905_ net1028 VPWR _03181_ VGND net553 u_s2p_input.reg_sh\[1\] sg13g2_o21ai_1
XFILLER_112_31 VPWR VGND sg13g2_fill_2
X_23071__1100 VPWR VGND net1099 sg13g2_tiehi
XFILLER_72_746 VPWR VGND sg13g2_decap_8
X_22836_ u_debug_unit.mon_w8_sync\[6\] net339 _03136_ VPWR VGND sg13g2_nor2_1
XFILLER_72_757 VPWR VGND sg13g2_fill_1
XFILLER_71_256 VPWR VGND sg13g2_decap_8
X_22767_ VGND VPWR _03333_ net339 _00723_ _03101_ sg13g2_a21oi_1
XFILLER_53_993 VPWR VGND sg13g2_fill_1
XFILLER_12_301 VPWR VGND sg13g2_decap_8
X_12520_ _03894_ u_FIR.w\[8\]\[5\] net811 VPWR VGND sg13g2_nand2_1
X_21718_ VGND VPWR net50 _02317_ _02318_ _02304_ sg13g2_a21oi_1
XFILLER_12_323 VPWR VGND sg13g2_decap_8
X_22698_ coeff_force_packed\[62\] net460 _03069_ _00686_ VPWR VGND sg13g2_mux2_1
XFILLER_8_305 VPWR VGND sg13g2_decap_8
XFILLER_8_316 VPWR VGND sg13g2_fill_1
X_12451_ VPWR _03827_ _03826_ VGND sg13g2_inv_1
X_21649_ net13 VPWR _02263_ VGND _02252_ _02262_ sg13g2_o21ai_1
XFILLER_21_890 VPWR VGND sg13g2_decap_4
X_15170_ _06441_ _06433_ _06442_ VPWR VGND sg13g2_xor2_1
X_12382_ net881 net718 _03760_ VPWR VGND sg13g2_nor2b_1
X_14121_ _05432_ _05389_ _05430_ VPWR VGND sg13g2_xnor2_1
X_23319_ net1282 VGND VPWR _00381_ u_LMS.w\[4\]\[21\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
XFILLER_115_0 VPWR VGND sg13g2_decap_8
XFILLER_21_61 VPWR VGND sg13g2_decap_8
XFILLER_67_1019 VPWR VGND sg13g2_fill_1
XFILLER_21_72 VPWR VGND sg13g2_fill_1
X_14052_ _05365_ _05337_ _05364_ VPWR VGND sg13g2_nand2_1
X_23757__1625 VPWR VGND net1624 sg13g2_tiehi
XFILLER_106_461 VPWR VGND sg13g2_fill_2
X_13003_ VGND VPWR u_FIR.sum\[0\]\[14\] _04265_ _04359_ _04358_ sg13g2_a21oi_1
XFILLER_4_588 VPWR VGND sg13g2_fill_1
XFILLER_79_323 VPWR VGND sg13g2_fill_2
X_18860_ _09945_ _09944_ _09947_ VPWR VGND sg13g2_xor2_1
XFILLER_122_954 VPWR VGND sg13g2_fill_1
XFILLER_95_805 VPWR VGND sg13g2_decap_8
X_17811_ VPWR _08944_ _08943_ VGND sg13g2_inv_1
XFILLER_122_976 VPWR VGND sg13g2_decap_4
XFILLER_95_827 VPWR VGND sg13g2_decap_8
X_18791_ _09878_ _09865_ _09871_ VPWR VGND sg13g2_xnor2_1
XFILLER_88_890 VPWR VGND sg13g2_decap_4
X_17742_ _08875_ _08869_ _08874_ VPWR VGND sg13g2_xnor2_1
XFILLER_130_1011 VPWR VGND sg13g2_decap_8
X_14954_ _06231_ VPWR _06235_ VGND _06218_ _06232_ sg13g2_o21ai_1
X_13905_ _05225_ _05210_ _05227_ VPWR VGND sg13g2_xor2_1
X_17673_ _08806_ _08800_ _08804_ VPWR VGND sg13g2_xnor2_1
X_14885_ _06170_ _06163_ _06168_ VPWR VGND sg13g2_xnor2_1
XFILLER_90_521 VPWR VGND sg13g2_decap_8
X_19412_ _10476_ net647 net85 VPWR VGND sg13g2_nand2_1
X_16624_ u_LMS.w\[5\]\[19\] u_LMS.w\[5\]\[18\] u_LMS.w\[5\]\[20\] _07808_ VPWR VGND
+ sg13g2_nand3_1
X_13836_ _05160_ _05123_ _05159_ VPWR VGND sg13g2_nand2_1
XFILLER_63_757 VPWR VGND sg13g2_fill_2
XFILLER_46_91 VPWR VGND sg13g2_decap_8
XFILLER_16_640 VPWR VGND sg13g2_fill_2
XFILLER_90_565 VPWR VGND sg13g2_decap_8
XFILLER_51_919 VPWR VGND sg13g2_decap_4
XFILLER_16_651 VPWR VGND sg13g2_fill_2
X_19343_ _10407_ _10399_ _10405_ VPWR VGND sg13g2_xnor2_1
XFILLER_62_267 VPWR VGND sg13g2_fill_2
X_16555_ VGND VPWR net488 _07757_ _00232_ _07758_ sg13g2_a21oi_1
XFILLER_22_109 VPWR VGND sg13g2_decap_8
X_13767_ _05091_ _05092_ _05093_ VPWR VGND sg13g2_and2_1
X_15506_ VGND VPWR _06764_ _06763_ _06754_ sg13g2_or2_1
X_19274_ VGND VPWR net27 _10339_ _00369_ _10340_ sg13g2_a21oi_1
X_12718_ _04083_ _04054_ _04082_ VPWR VGND sg13g2_xnor2_1
X_16486_ _07706_ u_FIR.x\[7\] net526 VPWR VGND sg13g2_nand2_1
X_13698_ _05026_ u_FIR.sum\[2\]\[8\] net404 VPWR VGND sg13g2_nand2_1
XFILLER_30_131 VPWR VGND sg13g2_fill_1
X_18225_ _09335_ net676 net164 VPWR VGND sg13g2_nand2_1
X_15437_ _06683_ _06700_ _06701_ VPWR VGND sg13g2_nor2b_1
X_12649_ net1037 VPWR _04016_ VGND net540 u_FIR.sum\[1\]\[4\] sg13g2_o21ai_1
X_18156_ VGND VPWR net670 net182 _09266_ _09262_ sg13g2_a21oi_1
XFILLER_8_861 VPWR VGND sg13g2_decap_8
XFILLER_129_564 VPWR VGND sg13g2_decap_8
XFILLER_117_704 VPWR VGND sg13g2_decap_4
X_15368_ VGND VPWR net502 _06633_ _00169_ _06634_ sg13g2_a21oi_1
XFILLER_7_63 VPWR VGND sg13g2_decap_8
X_17107_ _08263_ net712 net192 VPWR VGND sg13g2_nand2_1
X_14319_ _05603_ _05624_ _05625_ VPWR VGND sg13g2_nor2b_1
X_18087_ _09197_ _03262_ _03263_ VPWR VGND sg13g2_nand2_1
X_15299_ net1003 VPWR _06568_ VGND net496 u_FIR.sum\[6\]\[10\] sg13g2_o21ai_1
XFILLER_104_409 VPWR VGND sg13g2_decap_4
X_17038_ _08194_ _08186_ _08192_ VPWR VGND sg13g2_xnor2_1
Xfanout807 net808 net807 VPWR VGND sg13g2_buf_1
XFILLER_98_632 VPWR VGND sg13g2_decap_8
XFILLER_113_943 VPWR VGND sg13g2_decap_8
Xfanout818 net821 net818 VPWR VGND sg13g2_buf_1
Xfanout829 net831 net829 VPWR VGND sg13g2_buf_1
XFILLER_30_0 VPWR VGND sg13g2_decap_8
XFILLER_112_464 VPWR VGND sg13g2_decap_8
X_23346__1256 VPWR VGND net1255 sg13g2_tiehi
XFILLER_113_987 VPWR VGND sg13g2_fill_2
X_18989_ _10068_ _10075_ _10076_ VPWR VGND sg13g2_nor2b_1
XFILLER_39_754 VPWR VGND sg13g2_fill_1
X_20951_ _01591_ _01507_ _01512_ VPWR VGND sg13g2_xnor2_1
XFILLER_93_381 VPWR VGND sg13g2_fill_1
X_23670_ net1023 VGND VPWR _00732_ u_debug_unit.mon_w5_sync\[1\] clknet_leaf_35_clkA
+ sg13g2_dfrbpq_1
XFILLER_26_448 VPWR VGND sg13g2_decap_8
X_20882_ _01474_ VPWR _01522_ VGND _01519_ _01520_ sg13g2_o21ai_1
XFILLER_26_459 VPWR VGND sg13g2_fill_2
XFILLER_42_919 VPWR VGND sg13g2_decap_8
X_22621_ coeff_force_packed\[1\] net471 _03061_ _00617_ VPWR VGND sg13g2_mux2_1
XFILLER_35_971 VPWR VGND sg13g2_fill_1
XFILLER_41_418 VPWR VGND sg13g2_decap_8
X_22552_ VGND VPWR u_LMS.count\[17\] _03030_ _03033_ u_LMS.count\[18\] sg13g2_a21oi_1
XFILLER_50_963 VPWR VGND sg13g2_fill_1
XFILLER_22_665 VPWR VGND sg13g2_fill_2
X_21503_ _02120_ _02117_ _02118_ VPWR VGND sg13g2_xnor2_1
X_22483_ net960 VPWR _02991_ VGND net446 net590 sg13g2_o21ai_1
XFILLER_21_164 VPWR VGND sg13g2_decap_8
X_21434_ _02051_ _02049_ _02050_ VPWR VGND sg13g2_nand2_1
XFILLER_107_225 VPWR VGND sg13g2_fill_2
X_21365_ _01949_ VPWR _01982_ VGND _01927_ _01947_ sg13g2_o21ai_1
X_23104_ net1050 VGND VPWR _00166_ u_FIR.sum\[6\]\[9\] clknet_leaf_42_clkA sg13g2_dfrbpq_1
X_20316_ _00979_ u_LMS.w\[5\]\[15\] _00978_ VPWR VGND sg13g2_nand2b_1
X_21296_ _01913_ _01910_ _01911_ VPWR VGND sg13g2_xnor2_1
X_23035_ net1153 VGND VPWR _00097_ u_FIR.sum\[2\]\[16\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
XFILLER_66_1052 VPWR VGND sg13g2_decap_8
X_20247_ _00892_ _00909_ _00910_ VPWR VGND sg13g2_nor2_1
XFILLER_1_536 VPWR VGND sg13g2_fill_1
XFILLER_103_431 VPWR VGND sg13g2_decap_8
XFILLER_107_75 VPWR VGND sg13g2_fill_2
XFILLER_88_164 VPWR VGND sg13g2_fill_2
XFILLER_77_827 VPWR VGND sg13g2_decap_8
X_20178_ _00841_ net630 net247 VPWR VGND sg13g2_nand2_1
XFILLER_92_819 VPWR VGND sg13g2_decap_8
XFILLER_85_871 VPWR VGND sg13g2_decap_8
XFILLER_29_253 VPWR VGND sg13g2_fill_2
X_11951_ VPWR _03372_ net781 VGND sg13g2_inv_1
XFILLER_45_746 VPWR VGND sg13g2_decap_8
XFILLER_17_437 VPWR VGND sg13g2_decap_4
X_14670_ _05961_ _05929_ _05959_ VPWR VGND sg13g2_xnor2_1
X_11882_ VPWR _03303_ u_LMS.w\[6\]\[10\] VGND sg13g2_inv_1
XFILLER_83_78 VPWR VGND sg13g2_decap_8
XFILLER_72_576 VPWR VGND sg13g2_decap_4
XFILLER_60_716 VPWR VGND sg13g2_decap_8
XFILLER_32_407 VPWR VGND sg13g2_fill_1
X_13621_ _04951_ _04941_ _04949_ VPWR VGND sg13g2_xnor2_1
X_22819_ VGND VPWR _07862_ net342 _00749_ _03127_ sg13g2_a21oi_1
XFILLER_16_83 VPWR VGND sg13g2_fill_1
X_16340_ _07574_ _07550_ _07573_ VPWR VGND sg13g2_xnor2_1
X_13552_ VGND VPWR _04884_ _04883_ _04856_ sg13g2_or2_1
X_12503_ _03878_ _03863_ _03876_ VPWR VGND sg13g2_xnor2_1
X_16271_ _07507_ _07498_ _07505_ VPWR VGND sg13g2_xnor2_1
X_13483_ _04818_ _04817_ _04810_ VPWR VGND sg13g2_nand2b_1
X_18010_ _09134_ _09132_ _09133_ VPWR VGND sg13g2_xnor2_1
X_15222_ _06479_ VPWR _06492_ VGND _06475_ _06477_ sg13g2_o21ai_1
X_12434_ _03811_ _03793_ _03809_ VPWR VGND sg13g2_xnor2_1
X_15153_ _06425_ net780 net834 VPWR VGND sg13g2_nand2_1
X_12365_ _03743_ _03714_ _03744_ VPWR VGND sg13g2_xor2_1
XFILLER_126_545 VPWR VGND sg13g2_decap_8
X_14104_ _05415_ _05373_ _05414_ VPWR VGND sg13g2_xnor2_1
X_19961_ _11002_ _10982_ _11000_ VPWR VGND sg13g2_xnor2_1
X_15084_ _06358_ _06356_ _06357_ VPWR VGND sg13g2_nand2_1
XFILLER_107_770 VPWR VGND sg13g2_decap_8
X_12296_ net1037 VPWR _03677_ VGND net540 u_FIR.sum\[0\]\[5\] sg13g2_o21ai_1
X_18912_ VGND VPWR _09995_ _09996_ _09999_ _09998_ sg13g2_a21oi_1
X_14035_ _05346_ _05328_ _05348_ VPWR VGND sg13g2_xor2_1
X_19892_ VGND VPWR net54 _10933_ _10934_ _10905_ sg13g2_a21oi_1
X_18843_ _09930_ _09927_ _09928_ VPWR VGND sg13g2_xnor2_1
XFILLER_80_1038 VPWR VGND sg13g2_fill_1
XFILLER_95_646 VPWR VGND sg13g2_fill_1
X_18774_ VGND VPWR _09852_ _09853_ _09861_ _09860_ sg13g2_a21oi_1
X_15986_ _07228_ _07225_ _07227_ VPWR VGND sg13g2_xnor2_1
X_17725_ _08837_ _08835_ _08858_ VPWR VGND sg13g2_xor2_1
X_14937_ _06219_ _06207_ _06211_ VPWR VGND sg13g2_nand2_1
X_17656_ VPWR _08789_ _08788_ VGND sg13g2_inv_1
X_14868_ VGND VPWR _06122_ _06133_ _06153_ _06140_ sg13g2_a21oi_1
XFILLER_36_779 VPWR VGND sg13g2_fill_2
X_16607_ VGND VPWR u_LMS.w\[4\]\[13\] _07793_ _07797_ _07794_ sg13g2_a21oi_1
X_13819_ _05144_ _05119_ _05143_ VPWR VGND sg13g2_xnor2_1
X_17587_ _08720_ _08718_ _08719_ VPWR VGND sg13g2_nand2_1
X_14799_ VGND VPWR _06049_ _06078_ _06086_ _06077_ sg13g2_a21oi_1
XFILLER_50_226 VPWR VGND sg13g2_fill_1
X_19326_ _10390_ _10389_ _10388_ VPWR VGND sg13g2_nand2b_1
X_16538_ VGND VPWR u_LMS.w\[1\]\[17\] _07733_ _07745_ _07734_ sg13g2_a21oi_1
XFILLER_31_451 VPWR VGND sg13g2_decap_8
X_19257_ _10327_ _10328_ _00364_ VPWR VGND sg13g2_nor2_1
X_16469_ _07695_ net413 net894 VPWR VGND sg13g2_nand2_1
X_18208_ _09284_ _09283_ _09318_ VPWR VGND sg13g2_xor2_1
XFILLER_78_0 VPWR VGND sg13g2_decap_8
XFILLER_129_350 VPWR VGND sg13g2_decap_8
X_19188_ VGND VPWR _10272_ _10273_ _00350_ net927 sg13g2_a21oi_1
XFILLER_89_1030 VPWR VGND sg13g2_fill_1
X_23234__1421 VPWR VGND net1420 sg13g2_tiehi
X_18139_ _09249_ _09226_ _09247_ VPWR VGND sg13g2_xnor2_1
XFILLER_89_1052 VPWR VGND sg13g2_decap_8
X_21150_ VPWR _01767_ _01766_ VGND sg13g2_inv_1
XFILLER_132_515 VPWR VGND sg13g2_decap_8
X_20101_ _11140_ _11141_ _11142_ VPWR VGND sg13g2_nor2_1
X_21081_ _01709_ net318 u_LMS.w\[6\]\[24\] coeff_force_packed\[48\] net565 VPWR VGND
+ sg13g2_a22oi_1
Xfanout604 net605 net604 VPWR VGND sg13g2_buf_1
XFILLER_99_963 VPWR VGND sg13g2_fill_1
Xfanout615 u_LMS.x_r\[6\]\[3\] net615 VPWR VGND sg13g2_buf_1
Xfanout626 u_LMS.x_r\[5\]\[5\] net626 VPWR VGND sg13g2_buf_1
XFILLER_98_451 VPWR VGND sg13g2_fill_1
X_20032_ _11073_ _11072_ _11068_ VPWR VGND sg13g2_nand2b_1
XFILLER_113_773 VPWR VGND sg13g2_fill_2
XFILLER_101_924 VPWR VGND sg13g2_decap_4
Xfanout637 net638 net637 VPWR VGND sg13g2_buf_1
XFILLER_100_401 VPWR VGND sg13g2_decap_4
XFILLER_112_261 VPWR VGND sg13g2_decap_8
Xfanout648 u_LMS.x_r\[4\]\[2\] net648 VPWR VGND sg13g2_buf_1
XFILLER_59_838 VPWR VGND sg13g2_fill_2
Xfanout659 u_LMS.x_r\[3\]\[4\] net659 VPWR VGND sg13g2_buf_1
XFILLER_101_979 VPWR VGND sg13g2_fill_2
XFILLER_86_679 VPWR VGND sg13g2_decap_8
XFILLER_39_551 VPWR VGND sg13g2_decap_4
X_21983_ _02545_ VPWR _02577_ VGND _02522_ _02543_ sg13g2_o21ai_1
XFILLER_27_724 VPWR VGND sg13g2_decap_4
XFILLER_2_1027 VPWR VGND sg13g2_decap_8
XFILLER_82_830 VPWR VGND sg13g2_decap_8
XFILLER_66_381 VPWR VGND sg13g2_fill_1
XFILLER_66_392 VPWR VGND sg13g2_decap_8
XFILLER_27_746 VPWR VGND sg13g2_decap_8
X_20934_ _01536_ _01535_ _01574_ VPWR VGND sg13g2_xor2_1
X_23722_ net1366 VGND VPWR _00784_ u_s2p_input.reg_sh\[3\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
XFILLER_54_543 VPWR VGND sg13g2_fill_1
XFILLER_27_757 VPWR VGND sg13g2_fill_2
XFILLER_27_768 VPWR VGND sg13g2_decap_8
XFILLER_82_896 VPWR VGND sg13g2_decap_8
X_20865_ _01503_ _01499_ _01504_ _01505_ VPWR VGND sg13g2_a21o_1
X_23653_ net977 VGND VPWR _00715_ u_debug_unit.mon_w2_sync\[5\] clknet_leaf_49_clkA
+ sg13g2_dfrbpq_1
XFILLER_41_215 VPWR VGND sg13g2_decap_8
X_23756__1624 VPWR VGND net1623 sg13g2_tiehi
X_22604_ net468 debug_load_bus\[2\] _03059_ _00602_ VPWR VGND sg13g2_mux2_1
XFILLER_41_248 VPWR VGND sg13g2_fill_2
X_23584_ net954 VGND VPWR _00646_ coeff_force_packed\[27\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
X_20796_ _01436_ _01431_ _01434_ VPWR VGND sg13g2_xnor2_1
XFILLER_23_974 VPWR VGND sg13g2_fill_2
X_22535_ net916 _03021_ _03022_ _00570_ VPWR VGND sg13g2_nor3_1
XFILLER_10_635 VPWR VGND sg13g2_fill_2
X_22466_ VGND VPWR net449 _03236_ _00541_ _02982_ sg13g2_a21oi_1
XFILLER_108_501 VPWR VGND sg13g2_fill_1
XFILLER_5_105 VPWR VGND sg13g2_decap_8
X_21417_ _02027_ VPWR _02034_ VGND net2156 _02028_ sg13g2_o21ai_1
XFILLER_108_545 VPWR VGND sg13g2_fill_2
X_22397_ net947 VPWR _02948_ VGND net433 net675 sg13g2_o21ai_1
XFILLER_120_1054 VPWR VGND sg13g2_decap_8
X_12150_ _03559_ net289 coeff_force_packed\[21\] _03416_ u_debug_unit.mon_w8_sync\[0\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_123_504 VPWR VGND sg13g2_fill_1
X_21348_ net2138 _01964_ _01965_ VPWR VGND sg13g2_nor2_1
X_12081_ _03494_ net294 debug_load_bus\[4\] net296 coeff_force_packed\[11\] VPWR VGND
+ sg13g2_a22oi_1
XFILLER_78_45 VPWR VGND sg13g2_decap_8
XFILLER_104_740 VPWR VGND sg13g2_fill_1
X_21279_ net592 net237 net590 _01896_ VPWR VGND net208 sg13g2_nand4_1
X_23018_ net1179 VGND VPWR _00080_ u_FIR.sum\[1\]\[15\] clknet_leaf_29_clkA sg13g2_dfrbpq_1
XFILLER_77_602 VPWR VGND sg13g2_decap_8
X_15840_ VGND VPWR _07056_ _07067_ _07088_ _07075_ sg13g2_a21oi_1
XFILLER_49_359 VPWR VGND sg13g2_decap_8
XFILLER_94_44 VPWR VGND sg13g2_fill_1
XFILLER_40_1022 VPWR VGND sg13g2_decap_8
XFILLER_58_882 VPWR VGND sg13g2_fill_2
X_15771_ _06990_ _07020_ _07021_ VPWR VGND sg13g2_nor2_1
X_12983_ _04327_ VPWR _04340_ VGND net284 _04325_ sg13g2_o21ai_1
XFILLER_92_649 VPWR VGND sg13g2_fill_2
XFILLER_58_893 VPWR VGND sg13g2_decap_8
XFILLER_91_126 VPWR VGND sg13g2_decap_4
X_17510_ _08643_ _08635_ _08641_ VPWR VGND sg13g2_xnor2_1
XFILLER_73_841 VPWR VGND sg13g2_fill_1
X_14722_ _06011_ _05974_ _05977_ VPWR VGND sg13g2_nand2_1
X_18490_ _09600_ _09548_ net2095 VPWR VGND sg13g2_xnor2_1
X_11934_ VPWR _03355_ u_LMS.w\[0\]\[18\] VGND sg13g2_inv_1
X_17441_ _08575_ _08576_ _00300_ VPWR VGND sg13g2_nor2_1
X_14653_ net823 u_FIR.w\[3\]\[1\] _05942_ _05944_ VPWR VGND sg13g2_a21o_1
XFILLER_72_373 VPWR VGND sg13g2_fill_1
X_11865_ VPWR _03286_ u_LMS.x\[4\] VGND sg13g2_inv_1
XFILLER_32_215 VPWR VGND sg13g2_decap_4
XFILLER_14_941 VPWR VGND sg13g2_decap_8
X_13604_ _04934_ net751 net852 VPWR VGND sg13g2_nand2_1
XFILLER_60_557 VPWR VGND sg13g2_decap_4
XFILLER_32_248 VPWR VGND sg13g2_decap_8
X_17372_ net2194 _08521_ _08522_ VPWR VGND sg13g2_and2_1
X_14584_ _05877_ _05837_ _05875_ VPWR VGND sg13g2_xnor2_1
X_11796_ VPWR _03217_ net570 VGND sg13g2_inv_1
X_19111_ _10198_ _10092_ _10122_ VPWR VGND sg13g2_xnor2_1
X_16323_ _07557_ _07554_ _07555_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_411 VPWR VGND sg13g2_fill_1
XFILLER_41_771 VPWR VGND sg13g2_fill_1
X_13535_ _04867_ _04861_ _04865_ VPWR VGND sg13g2_xnor2_1
X_19042_ VGND VPWR _10103_ _10105_ _10129_ _10102_ sg13g2_a21oi_1
X_16254_ net834 _07489_ net793 _07490_ VPWR VGND sg13g2_nand3_1
X_13466_ _04788_ _04787_ _04786_ _04805_ VPWR VGND sg13g2_mux2_1
X_15205_ _06476_ u_FIR.sum\[5\]\[8\] net395 VPWR VGND sg13g2_nand2_1
X_23724__1351 VPWR VGND net1350 sg13g2_tiehi
X_12417_ _03794_ _03761_ _03764_ VPWR VGND sg13g2_nand2_1
X_16185_ _07405_ _07422_ _07423_ VPWR VGND sg13g2_nor2b_1
X_13397_ _04726_ VPWR _04739_ VGND net283 _04724_ sg13g2_o21ai_1
X_15136_ net484 VPWR _06409_ VGND _06407_ _06408_ sg13g2_o21ai_1
X_12348_ net882 net720 _03725_ _03727_ VPWR VGND sg13g2_a21o_1
XFILLER_126_375 VPWR VGND sg13g2_decap_8
X_23386__1191 VPWR VGND net1190 sg13g2_tiehi
XFILLER_114_526 VPWR VGND sg13g2_decap_8
X_19944_ _10977_ _10983_ _10985_ VPWR VGND sg13g2_nor2_1
X_15067_ VGND VPWR _06341_ _06339_ _06310_ sg13g2_or2_1
X_12279_ _03660_ _03625_ _03659_ VPWR VGND sg13g2_xnor2_1
XFILLER_4_42 VPWR VGND sg13g2_decap_8
X_14018_ _05332_ _05331_ _05327_ VPWR VGND sg13g2_nand2b_1
X_19875_ _10921_ _10783_ _10784_ VPWR VGND sg13g2_xnor2_1
X_18826_ net655 net235 u_LMS.x_r\[3\]\[7\] _09913_ VPWR VGND net201 sg13g2_nand4_1
X_23506__1392 VPWR VGND net1391 sg13g2_tiehi
X_18757_ _09826_ _09843_ _09844_ VPWR VGND sg13g2_nor2_1
XFILLER_82_104 VPWR VGND sg13g2_decap_8
X_15969_ _07212_ _07205_ _07210_ VPWR VGND sg13g2_xnor2_1
XFILLER_83_638 VPWR VGND sg13g2_decap_8
X_17708_ _08839_ _08838_ _08841_ VPWR VGND sg13g2_xor2_1
XFILLER_82_148 VPWR VGND sg13g2_fill_1
XFILLER_36_543 VPWR VGND sg13g2_decap_8
X_18688_ net90 _09774_ _09775_ VPWR VGND sg13g2_nor2_1
X_17639_ _08768_ _08767_ _08771_ _08772_ VPWR VGND sg13g2_a21o_1
XFILLER_17_790 VPWR VGND sg13g2_fill_2
XFILLER_56_1040 VPWR VGND sg13g2_decap_4
X_20650_ _01290_ _01246_ _01251_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_900 VPWR VGND sg13g2_fill_2
X_19309_ VPWR _10373_ _10372_ VGND sg13g2_inv_1
X_20581_ net608 net151 net606 _01221_ VPWR VGND net94 sg13g2_nand4_1
XFILLER_109_309 VPWR VGND sg13g2_decap_4
X_22320_ _02899_ _02900_ _00477_ VPWR VGND sg13g2_nor2_1
X_22251_ net321 net48 _02845_ VPWR VGND sg13g2_and2_1
X_21202_ _01767_ _01818_ _01819_ VPWR VGND sg13g2_and2_1
XFILLER_118_876 VPWR VGND sg13g2_fill_1
X_22182_ _03292_ _02775_ _02776_ VPWR VGND sg13g2_nor2_1
XFILLER_118_898 VPWR VGND sg13g2_fill_1
XFILLER_117_375 VPWR VGND sg13g2_fill_2
XFILLER_2_119 VPWR VGND sg13g2_decap_8
X_21133_ _01750_ _01746_ _01749_ VPWR VGND sg13g2_nand2_1
XFILLER_132_356 VPWR VGND sg13g2_decap_8
Xfanout401 _05469_ net401 VPWR VGND sg13g2_buf_1
Xfanout412 _03357_ net412 VPWR VGND sg13g2_buf_1
X_21064_ _01695_ u_LMS.w\[6\]\[21\] net73 VPWR VGND sg13g2_xnor2_1
Xfanout423 _03251_ net423 VPWR VGND sg13g2_buf_1
Xfanout434 net435 net434 VPWR VGND sg13g2_buf_1
Xfanout445 net451 net445 VPWR VGND sg13g2_buf_1
XFILLER_98_281 VPWR VGND sg13g2_decap_4
XFILLER_48_48 VPWR VGND sg13g2_fill_1
X_20015_ _11026_ _11055_ _11056_ VPWR VGND sg13g2_nor2_1
Xfanout456 net457 net456 VPWR VGND sg13g2_buf_1
Xfanout467 spi_wdata\[3\] net467 VPWR VGND sg13g2_buf_1
Xfanout478 net487 net478 VPWR VGND sg13g2_buf_1
XFILLER_100_242 VPWR VGND sg13g2_decap_8
Xfanout489 net494 net489 VPWR VGND sg13g2_buf_1
XFILLER_87_988 VPWR VGND sg13g2_fill_2
XFILLER_86_465 VPWR VGND sg13g2_fill_1
XFILLER_58_156 VPWR VGND sg13g2_decap_8
XFILLER_58_178 VPWR VGND sg13g2_decap_4
XFILLER_86_498 VPWR VGND sg13g2_decap_4
XFILLER_55_830 VPWR VGND sg13g2_decap_4
XFILLER_73_137 VPWR VGND sg13g2_fill_1
XFILLER_73_148 VPWR VGND sg13g2_decap_8
XFILLER_27_554 VPWR VGND sg13g2_fill_2
XFILLER_104_98 VPWR VGND sg13g2_fill_2
X_21966_ _02558_ _02553_ _02560_ VPWR VGND sg13g2_xor2_1
X_23705_ net1481 VGND VPWR _00767_ u_p2s_output.reg_sh\[6\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
XFILLER_64_69 VPWR VGND sg13g2_decap_8
X_20917_ _01557_ _01548_ _01556_ VPWR VGND sg13g2_xnor2_1
X_21897_ _02491_ net574 net204 VPWR VGND sg13g2_nand2_1
XFILLER_42_546 VPWR VGND sg13g2_decap_8
X_20848_ _01459_ _01487_ _01488_ VPWR VGND sg13g2_and2_1
X_23636_ net1011 VGND VPWR _00698_ u_debug_unit.mon_w0_sync\[2\] clknet_leaf_17_clkA
+ sg13g2_dfrbpq_1
XFILLER_42_568 VPWR VGND sg13g2_fill_1
XFILLER_120_53 VPWR VGND sg13g2_fill_1
Xfanout30 _10264_ net30 VPWR VGND sg13g2_buf_1
XFILLER_120_64 VPWR VGND sg13g2_fill_1
XFILLER_11_900 VPWR VGND sg13g2_decap_8
Xfanout41 _09094_ net41 VPWR VGND sg13g2_buf_1
XFILLER_70_1004 VPWR VGND sg13g2_decap_4
Xfanout52 _01070_ net52 VPWR VGND sg13g2_buf_2
Xfanout63 net64 net63 VPWR VGND sg13g2_buf_1
X_20779_ _01418_ _01417_ _01419_ VPWR VGND sg13g2_xor2_1
X_23567_ net953 VGND VPWR _00629_ coeff_force_packed\[12\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
Xfanout74 net74 net2061 VPWR VGND sg13g2_buf_4
XFILLER_80_57 VPWR VGND sg13g2_decap_8
Xfanout85 net89 net85 VPWR VGND sg13g2_buf_2
Xfanout96 net96 net97 VPWR VGND sg13g2_buf_4
X_13320_ _04665_ _04656_ _04663_ VPWR VGND sg13g2_xnor2_1
XFILLER_70_1059 VPWR VGND sg13g2_fill_2
X_22518_ VGND VPWR u_LMS.count\[5\] _03009_ _03012_ net916 sg13g2_a21oi_1
X_23498_ net1419 VGND VPWR _00560_ u_LMS.count\[1\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
XFILLER_10_465 VPWR VGND sg13g2_decap_8
XFILLER_10_476 VPWR VGND sg13g2_fill_1
XFILLER_13_84 VPWR VGND sg13g2_decap_8
X_22449_ net959 VPWR _02974_ VGND net444 net624 sg13g2_o21ai_1
X_13251_ VGND VPWR _04577_ _04584_ _04597_ _04576_ sg13g2_a21oi_1
X_23341__1261 VPWR VGND net1260 sg13g2_tiehi
XFILLER_109_876 VPWR VGND sg13g2_fill_2
XFILLER_129_84 VPWR VGND sg13g2_decap_8
XFILLER_109_887 VPWR VGND sg13g2_decap_4
X_12202_ u_LMS.count\[30\] u_LMS.count\[29\] u_LMS.count\[28\] u_LMS.count\[27\] _03590_
+ VPWR VGND sg13g2_nor4_1
X_13182_ _04529_ _04488_ _04530_ VPWR VGND sg13g2_xor2_1
XFILLER_89_66 VPWR VGND sg13g2_decap_4
XFILLER_124_835 VPWR VGND sg13g2_decap_8
X_12133_ _03543_ net290 coeff_force_packed\[1\] _03404_ u_debug_unit.mon_w7_sync\[1\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_8_0 VPWR VGND sg13g2_decap_8
X_17990_ _09118_ net303 u_LMS.w\[1\]\[17\] coeff_force_packed\[12\] net558 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_123_345 VPWR VGND sg13g2_decap_8
X_16941_ _08097_ _08020_ _08045_ VPWR VGND sg13g2_xnor2_1
X_12064_ _03478_ _03416_ u_debug_unit.mon_w8_sync\[5\] _03400_ u_debug_unit.mon_w3_sync\[5\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_96_229 VPWR VGND sg13g2_decap_8
XFILLER_123_389 VPWR VGND sg13g2_decap_8
XFILLER_77_410 VPWR VGND sg13g2_decap_4
XFILLER_77_432 VPWR VGND sg13g2_decap_8
X_19660_ VPWR _10724_ _10723_ VGND sg13g2_inv_1
XFILLER_77_443 VPWR VGND sg13g2_fill_2
X_16872_ _08003_ net122 _07993_ _08028_ VPWR VGND sg13g2_nand3_1
XFILLER_38_819 VPWR VGND sg13g2_fill_1
Xfanout990 net1000 net990 VPWR VGND sg13g2_buf_1
X_18611_ _09712_ u_LMS.w\[2\]\[21\] net70 VPWR VGND sg13g2_xnor2_1
XFILLER_93_925 VPWR VGND sg13g2_decap_8
XFILLER_65_616 VPWR VGND sg13g2_fill_2
XFILLER_49_167 VPWR VGND sg13g2_fill_1
X_15823_ _07071_ net274 _07072_ VPWR VGND sg13g2_xor2_1
XFILLER_64_104 VPWR VGND sg13g2_fill_2
X_19591_ _10654_ _10629_ _10655_ VPWR VGND sg13g2_xor2_1
X_23709__1454 VPWR VGND net1453 sg13g2_tiehi
X_18542_ u_LMS.w\[2\]\[15\] _09591_ _09652_ VPWR VGND sg13g2_xor2_1
XFILLER_64_148 VPWR VGND sg13g2_decap_4
X_15754_ _07005_ _06996_ _07003_ VPWR VGND sg13g2_xnor2_1
X_12966_ u_FIR.sum\[0\]\[13\] net408 _04324_ VPWR VGND sg13g2_nor2b_1
XFILLER_61_811 VPWR VGND sg13g2_fill_2
XFILLER_45_362 VPWR VGND sg13g2_fill_2
X_14705_ _05995_ _05994_ _05953_ VPWR VGND sg13g2_nand2b_1
X_18473_ _09583_ _09571_ _09582_ VPWR VGND sg13g2_xnor2_1
X_11917_ VPWR _03338_ u_LMS.w\[2\]\[7\] VGND sg13g2_inv_1
X_15685_ VGND VPWR _06919_ _06925_ _06937_ _06924_ sg13g2_a21oi_1
X_23448__1588 VPWR VGND net1587 sg13g2_tiehi
X_12897_ _04257_ net729 net830 VPWR VGND sg13g2_nand2_1
XFILLER_60_321 VPWR VGND sg13g2_decap_8
XFILLER_127_1016 VPWR VGND sg13g2_decap_8
X_17424_ net364 VPWR _08564_ VGND u_LMS.w\[0\]\[5\] net382 sg13g2_o21ai_1
X_14636_ _05921_ _05924_ _05927_ VPWR VGND sg13g2_nor2_1
X_11848_ VPWR _03269_ net689 VGND sg13g2_inv_1
XFILLER_54_91 VPWR VGND sg13g2_fill_1
XFILLER_14_760 VPWR VGND sg13g2_fill_1
X_17355_ VGND VPWR _08507_ _08508_ _00282_ net934 sg13g2_a21oi_1
X_14567_ _05860_ net772 net849 VPWR VGND sg13g2_nand2_1
X_16306_ _07519_ _07540_ _07541_ VPWR VGND sg13g2_nor2b_1
X_13518_ _04851_ _04843_ _04850_ VPWR VGND sg13g2_nand2_1
X_17286_ u_LMS.w\[0\]\[6\] _08424_ _08442_ VPWR VGND sg13g2_nor2_1
X_14498_ _05794_ net771 net890 VPWR VGND sg13g2_nand2_1
X_19025_ _10112_ net665 net243 VPWR VGND sg13g2_nand2_1
XFILLER_118_139 VPWR VGND sg13g2_fill_1
Xclkload11 clknet_4_13_0_clkA clkload11/X VPWR VGND sg13g2_buf_8
X_16237_ _07474_ _07443_ _07473_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_296 VPWR VGND sg13g2_decap_8
Xclkload22 clknet_leaf_56_clkA clkload22/Y VPWR VGND sg13g2_inv_4
X_13449_ VGND VPWR _04789_ _04788_ _04787_ sg13g2_or2_1
Xclkload33 clknet_leaf_8_clkA clkload33/X VPWR VGND sg13g2_buf_8
Xclkload44 VPWR clkload44/Y clknet_leaf_37_clkA VGND sg13g2_inv_1
Xclkload55 VPWR clkload55/Y clknet_3_4__leaf_spi_sclk VGND sg13g2_inv_1
X_16168_ _07406_ _07370_ _07373_ VPWR VGND sg13g2_nand2_1
XFILLER_114_312 VPWR VGND sg13g2_fill_1
XFILLER_86_1055 VPWR VGND sg13g2_decap_4
XFILLER_126_172 VPWR VGND sg13g2_decap_4
X_15119_ _06347_ _06349_ _06392_ VPWR VGND sg13g2_and2_1
XFILLER_5_491 VPWR VGND sg13g2_fill_1
XFILLER_115_868 VPWR VGND sg13g2_fill_2
X_16099_ VGND VPWR _07339_ _07337_ _07300_ sg13g2_or2_1
X_19927_ VGND VPWR net624 net113 _10968_ _10965_ sg13g2_a21oi_1
XFILLER_68_432 VPWR VGND sg13g2_decap_8
X_19858_ _10907_ _10908_ _00385_ VPWR VGND sg13g2_nor2_1
XFILLER_69_999 VPWR VGND sg13g2_fill_1
XFILLER_56_627 VPWR VGND sg13g2_fill_2
X_18809_ _09886_ VPWR _09896_ VGND _09887_ _09895_ sg13g2_o21ai_1
X_19789_ _10853_ _10798_ _10800_ VPWR VGND sg13g2_xnor2_1
XFILLER_110_1020 VPWR VGND sg13g2_fill_1
XFILLER_83_457 VPWR VGND sg13g2_decap_8
X_21820_ _02412_ _02406_ _02414_ VPWR VGND sg13g2_xor2_1
XFILLER_52_811 VPWR VGND sg13g2_fill_1
X_21751_ _02345_ _02341_ _02344_ VPWR VGND sg13g2_nand2_1
XFILLER_24_513 VPWR VGND sg13g2_fill_1
XFILLER_36_384 VPWR VGND sg13g2_fill_1
XFILLER_24_546 VPWR VGND sg13g2_fill_2
X_20702_ _01340_ _01341_ _01342_ VPWR VGND sg13g2_and2_1
XFILLER_34_39 VPWR VGND sg13g2_fill_1
X_21682_ _02290_ _02288_ _02289_ VPWR VGND sg13g2_xnor2_1
XFILLER_52_877 VPWR VGND sg13g2_fill_1
XFILLER_12_708 VPWR VGND sg13g2_fill_2
X_20633_ _01273_ net610 net190 VPWR VGND sg13g2_nand2_1
X_23421_ net1085 VGND VPWR _00483_ u_LMS.w\[8\]\[8\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
XFILLER_51_387 VPWR VGND sg13g2_decap_4
X_23352_ net1249 VGND VPWR _00414_ u_LMS.w\[5\]\[8\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
Xclkload5 clknet_4_6_0_clkA clkload5/X VPWR VGND sg13g2_buf_8
XFILLER_20_752 VPWR VGND sg13g2_decap_4
X_20564_ net426 _03228_ net111 net94 _01204_ VPWR VGND sg13g2_nor4_1
XFILLER_20_774 VPWR VGND sg13g2_fill_1
X_22303_ _02887_ _02835_ _02837_ VPWR VGND sg13g2_xnor2_1
X_23283_ net1327 VGND VPWR _00345_ u_LMS.w\[2\]\[8\] clknet_leaf_64_clkA sg13g2_dfrbpq_1
X_20495_ VGND VPWR net52 _01138_ _01139_ _01119_ sg13g2_a21oi_1
XFILLER_119_7 VPWR VGND sg13g2_decap_8
XFILLER_118_662 VPWR VGND sg13g2_decap_8
X_22234_ net61 VPWR _02828_ VGND u_LMS.w\[8\]\[19\] u_LMS.w\[8\]\[18\] sg13g2_o21ai_1
X_22165_ _02759_ u_LMS.w\[8\]\[16\] _02757_ VPWR VGND sg13g2_xnor2_1
XFILLER_1_7 VPWR VGND sg13g2_decap_8
XFILLER_132_131 VPWR VGND sg13g2_decap_8
X_21116_ _01735_ _01618_ _01620_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_164 VPWR VGND sg13g2_decap_8
X_22096_ _02658_ _02689_ _02690_ VPWR VGND sg13g2_nor2b_1
XFILLER_59_410 VPWR VGND sg13g2_decap_8
Xfanout220 net234 net220 VPWR VGND sg13g2_buf_2
Xfanout231 net232 net231 VPWR VGND sg13g2_buf_2
XFILLER_8_1033 VPWR VGND sg13g2_decap_8
Xfanout242 net243 net242 VPWR VGND sg13g2_buf_1
XFILLER_120_348 VPWR VGND sg13g2_fill_1
X_21047_ VGND VPWR _01680_ _01681_ _00423_ net936 sg13g2_a21oi_1
Xfanout253 net260 net253 VPWR VGND sg13g2_buf_1
Xfanout264 net265 net264 VPWR VGND sg13g2_buf_1
Xfanout275 _07022_ net275 VPWR VGND sg13g2_buf_1
Xfanout286 _03440_ net286 VPWR VGND sg13g2_buf_1
XFILLER_59_476 VPWR VGND sg13g2_decap_8
XFILLER_115_75 VPWR VGND sg13g2_fill_2
Xfanout297 _03171_ net297 VPWR VGND sg13g2_buf_1
X_12820_ _04182_ net830 net732 net814 net733 VPWR VGND sg13g2_a22oi_1
XFILLER_90_928 VPWR VGND sg13g2_decap_8
X_22998_ net1209 VGND VPWR _00060_ u_FIR.sum\[0\]\[10\] clknet_leaf_29_clkA sg13g2_dfrbpq_1
XFILLER_61_107 VPWR VGND sg13g2_decap_8
XFILLER_43_811 VPWR VGND sg13g2_decap_8
XFILLER_27_362 VPWR VGND sg13g2_decap_8
X_23359__1243 VPWR VGND net1242 sg13g2_tiehi
XFILLER_27_373 VPWR VGND sg13g2_fill_1
X_12751_ net737 net814 _04115_ VPWR VGND sg13g2_and2_1
X_21949_ _02543_ net580 net186 VPWR VGND sg13g2_nand2_1
XFILLER_131_74 VPWR VGND sg13g2_decap_8
X_23705__1482 VPWR VGND net1481 sg13g2_tiehi
XFILLER_43_866 VPWR VGND sg13g2_decap_8
X_15470_ net1004 VPWR _06732_ VGND net500 u_FIR.sum\[6\]\[17\] sg13g2_o21ai_1
X_12682_ _04048_ _04017_ _04046_ VPWR VGND sg13g2_xnor2_1
X_14421_ _05722_ VPWR _05723_ VGND _05673_ _05703_ sg13g2_o21ai_1
X_23619_ net963 VGND VPWR _00681_ coeff_force_packed\[57\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
Xclkbuf_leaf_27_clkA clknet_4_14_0_clkA clknet_leaf_27_clkA VPWR VGND sg13g2_buf_8
XFILLER_126_1060 VPWR VGND sg13g2_fill_1
XFILLER_11_730 VPWR VGND sg13g2_fill_1
X_17140_ _08290_ VPWR _08296_ VGND _08283_ _08291_ sg13g2_o21ai_1
XFILLER_24_94 VPWR VGND sg13g2_decap_4
X_14352_ _05636_ _05656_ _05657_ VPWR VGND sg13g2_nor2b_1
XFILLER_10_251 VPWR VGND sg13g2_fill_1
XFILLER_10_262 VPWR VGND sg13g2_decap_8
XFILLER_128_437 VPWR VGND sg13g2_decap_8
X_13303_ net843 _04647_ net739 _04648_ VPWR VGND sg13g2_nand3_1
X_17071_ _08227_ _08226_ _08225_ VPWR VGND sg13g2_xnor2_1
XFILLER_109_640 VPWR VGND sg13g2_decap_4
X_14283_ _05582_ _05589_ _05590_ VPWR VGND sg13g2_nor2b_1
X_16022_ _07263_ _07257_ _07261_ VPWR VGND sg13g2_xnor2_1
X_13234_ _04581_ u_FIR.sum\[1\]\[8\] net405 VPWR VGND sg13g2_xnor2_1
XFILLER_6_288 VPWR VGND sg13g2_decap_8
XFILLER_40_93 VPWR VGND sg13g2_decap_4
XFILLER_124_643 VPWR VGND sg13g2_fill_2
X_13165_ net1033 VPWR _04514_ VGND net533 u_FIR.sum\[2\]\[6\] sg13g2_o21ai_1
XFILLER_3_951 VPWR VGND sg13g2_decap_8
X_12116_ _03527_ _03434_ u_debug_unit.mon_w0_sync\[2\] net291 coeff_force_packed\[44\]
+ VPWR VGND sg13g2_a22oi_1
X_17973_ _09104_ net2210 _09043_ VPWR VGND sg13g2_xnor2_1
X_13096_ _04446_ net909 net740 net896 net741 VPWR VGND sg13g2_a22oi_1
XFILLER_97_538 VPWR VGND sg13g2_fill_2
X_19712_ _10775_ _10774_ _10776_ VPWR VGND sg13g2_nor2b_1
X_16924_ _08080_ net708 net87 VPWR VGND sg13g2_nand2_1
X_12047_ _03459_ _03460_ _03454_ _03462_ VPWR VGND _03461_ sg13g2_nand4_1
XFILLER_49_80 VPWR VGND sg13g2_fill_2
XFILLER_120_871 VPWR VGND sg13g2_decap_8
XFILLER_1_21 VPWR VGND sg13g2_decap_8
XFILLER_120_882 VPWR VGND sg13g2_fill_2
X_19643_ _10698_ _10706_ _10707_ VPWR VGND sg13g2_nor2b_1
X_16855_ VGND VPWR net703 net112 _08011_ _08008_ sg13g2_a21oi_1
XFILLER_37_115 VPWR VGND sg13g2_fill_2
XFILLER_120_893 VPWR VGND sg13g2_decap_8
XFILLER_92_221 VPWR VGND sg13g2_decap_8
X_15806_ VGND VPWR _07019_ _07033_ _07055_ _07042_ sg13g2_a21oi_1
X_19574_ _10638_ _10613_ _10637_ VPWR VGND sg13g2_nand2_1
X_16786_ _07927_ _07940_ _07942_ VPWR VGND sg13g2_xor2_1
X_13998_ _05313_ _05298_ _05310_ _05312_ VPWR VGND sg13g2_and3_1
XFILLER_46_660 VPWR VGND sg13g2_fill_1
XFILLER_19_874 VPWR VGND sg13g2_fill_2
XFILLER_81_939 VPWR VGND sg13g2_decap_8
XFILLER_1_98 VPWR VGND sg13g2_decap_8
X_18525_ u_LMS.w\[2\]\[9\] _09604_ _09635_ VPWR VGND sg13g2_nor2_1
X_15737_ _06988_ _06980_ _06987_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_90 VPWR VGND sg13g2_fill_2
X_12949_ _04282_ _04307_ _04308_ VPWR VGND sg13g2_nor2_1
X_18456_ _09566_ _09324_ _09323_ VPWR VGND sg13g2_nand2b_1
XFILLER_61_652 VPWR VGND sg13g2_decap_8
X_15668_ net792 net805 _06921_ VPWR VGND sg13g2_and2_1
XFILLER_21_516 VPWR VGND sg13g2_fill_2
X_17407_ _08550_ net384 _08497_ VPWR VGND sg13g2_nand2_1
X_14619_ _05909_ _05910_ _05911_ VPWR VGND sg13g2_nor2_1
XFILLER_21_538 VPWR VGND sg13g2_fill_1
X_18387_ _09475_ _09473_ _09497_ VPWR VGND sg13g2_xor2_1
X_15599_ _06819_ _06853_ _06817_ _06854_ VPWR VGND sg13g2_nand3_1
X_17338_ _08494_ net375 net557 VPWR VGND sg13g2_nand2b_1
XFILLER_14_1027 VPWR VGND sg13g2_decap_8
XFILLER_101_1019 VPWR VGND sg13g2_decap_8
X_17269_ _08425_ u_LMS.w\[0\]\[6\] _08424_ VPWR VGND sg13g2_nand2_1
XFILLER_60_0 VPWR VGND sg13g2_decap_4
X_19008_ _10095_ _10091_ _10093_ VPWR VGND sg13g2_xnor2_1
X_20280_ _00940_ _00941_ _00943_ VPWR VGND sg13g2_nor2b_1
XFILLER_127_481 VPWR VGND sg13g2_decap_8
XFILLER_130_635 VPWR VGND sg13g2_fill_2
X_22921_ _03171_ VPWR _03189_ VGND u_s2p_input.reg_cnt\[2\] _03170_ sg13g2_o21ai_1
XFILLER_84_755 VPWR VGND sg13g2_fill_1
X_22852_ net971 VPWR _03148_ VGND u_p2s_output.reg_sh\[1\] net299 sg13g2_o21ai_1
XFILLER_25_800 VPWR VGND sg13g2_fill_1
X_21803_ _02397_ _02362_ _02396_ VPWR VGND sg13g2_xnor2_1
X_22783_ VGND VPWR _07814_ net346 _00731_ _03109_ sg13g2_a21oi_1
XFILLER_71_449 VPWR VGND sg13g2_decap_8
XFILLER_101_22 VPWR VGND sg13g2_decap_8
XFILLER_24_343 VPWR VGND sg13g2_fill_1
X_21734_ VGND VPWR net49 _02329_ _02330_ net10 sg13g2_a21oi_1
XFILLER_52_674 VPWR VGND sg13g2_fill_1
XFILLER_40_847 VPWR VGND sg13g2_decap_8
X_21665_ net563 coeff_force_packed\[55\] _02276_ VPWR VGND sg13g2_and2_1
XFILLER_40_858 VPWR VGND sg13g2_fill_2
X_23404_ net1136 VGND VPWR _00466_ u_LMS.w\[8\]\[14\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_20616_ _01249_ VPWR _01256_ VGND _01164_ _01250_ sg13g2_o21ai_1
X_21596_ VGND VPWR _02210_ _02211_ _02213_ _02175_ sg13g2_a21oi_1
X_20547_ _01187_ _01175_ _01186_ VPWR VGND sg13g2_xnor2_1
X_23335_ net1266 VGND VPWR _00397_ u_LMS.w\[5\]\[14\] clknet_leaf_20_clkA sg13g2_dfrbpq_1
XFILLER_119_982 VPWR VGND sg13g2_decap_4
XFILLER_106_610 VPWR VGND sg13g2_decap_4
XFILLER_125_429 VPWR VGND sg13g2_fill_2
X_20478_ _01126_ _01007_ _01008_ VPWR VGND sg13g2_xnor2_1
X_23266_ net1361 VGND VPWR _00328_ u_LMS.w\[2\]\[14\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
XFILLER_4_737 VPWR VGND sg13g2_fill_1
X_22217_ _02770_ VPWR _02811_ VGND _02809_ _02808_ sg13g2_o21ai_1
X_23197_ net1485 VGND VPWR _00259_ u_FIR.w\[6\]\[0\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
XFILLER_106_665 VPWR VGND sg13g2_fill_2
X_23060__1117 VPWR VGND net1116 sg13g2_tiehi
XFILLER_106_687 VPWR VGND sg13g2_decap_8
XFILLER_0_910 VPWR VGND sg13g2_decap_4
XFILLER_10_85 VPWR VGND sg13g2_fill_1
X_22148_ _02742_ _02413_ _02741_ _02412_ _02361_ VPWR VGND sg13g2_a22oi_1
XFILLER_126_63 VPWR VGND sg13g2_decap_8
Xfanout1004 net1009 net1004 VPWR VGND sg13g2_buf_1
XFILLER_117_1037 VPWR VGND sg13g2_decap_8
XFILLER_0_943 VPWR VGND sg13g2_decap_8
Xfanout1015 net1016 net1015 VPWR VGND sg13g2_buf_1
Xfanout1026 net1032 net1026 VPWR VGND sg13g2_buf_1
X_22079_ _02671_ _02672_ _02673_ VPWR VGND sg13g2_nor2_1
Xfanout1037 net1041 net1037 VPWR VGND sg13g2_buf_1
X_14970_ VGND VPWR _06235_ _06247_ _06250_ _06246_ sg13g2_a21oi_1
X_23265__1364 VPWR VGND net1363 sg13g2_tiehi
XFILLER_48_925 VPWR VGND sg13g2_fill_2
X_13921_ _05241_ _05240_ _05242_ VPWR VGND sg13g2_xor2_1
XFILLER_47_413 VPWR VGND sg13g2_decap_8
X_16640_ net1023 VPWR _07821_ VGND net518 net751 sg13g2_o21ai_1
XFILLER_47_457 VPWR VGND sg13g2_fill_1
X_13852_ _05176_ _05152_ _05175_ VPWR VGND sg13g2_xnor2_1
X_12803_ _04130_ _04165_ _04166_ VPWR VGND sg13g2_and2_1
XFILLER_34_118 VPWR VGND sg13g2_decap_8
X_16571_ net717 u_LMS.w\[3\]\[23\] u_LMS.w\[3\]\[22\] u_LMS.w\[3\]\[21\] _07769_ VPWR
+ VGND sg13g2_nor4_1
X_13783_ _05083_ _05108_ _05109_ VPWR VGND sg13g2_nor2b_1
XFILLER_76_1032 VPWR VGND sg13g2_fill_2
X_18310_ _09420_ _09418_ _09419_ VPWR VGND sg13g2_nand2_1
X_15522_ _06779_ net789 net872 VPWR VGND sg13g2_nand2_1
X_19290_ _10353_ _10352_ _10354_ VPWR VGND sg13g2_xor2_1
X_12734_ _04096_ _04097_ _04098_ VPWR VGND sg13g2_and2_1
XFILLER_37_1016 VPWR VGND sg13g2_fill_1
XFILLER_43_685 VPWR VGND sg13g2_fill_2
XFILLER_35_93 VPWR VGND sg13g2_decap_8
X_18241_ _09343_ VPWR _09351_ VGND _09344_ _09350_ sg13g2_o21ai_1
XFILLER_31_836 VPWR VGND sg13g2_fill_1
X_15453_ _06714_ _06713_ _06716_ VPWR VGND sg13g2_xor2_1
X_12665_ _04031_ _04023_ _04030_ VPWR VGND sg13g2_nand2_1
XFILLER_31_858 VPWR VGND sg13g2_decap_8
XFILLER_124_1019 VPWR VGND sg13g2_decap_8
XFILLER_30_346 VPWR VGND sg13g2_fill_2
X_14404_ _05707_ _05696_ _05706_ VPWR VGND sg13g2_xnor2_1
X_18172_ net120 _09281_ _09282_ VPWR VGND sg13g2_nor2b_1
XFILLER_30_368 VPWR VGND sg13g2_decap_8
X_15384_ _06650_ u_FIR.sum\[5\]\[13\] net393 VPWR VGND sg13g2_xnor2_1
X_12596_ _03948_ VPWR _03965_ VGND _03944_ _03949_ sg13g2_o21ai_1
XFILLER_128_223 VPWR VGND sg13g2_decap_8
X_17123_ _08275_ _08278_ _08279_ VPWR VGND sg13g2_nor2_1
XFILLER_7_520 VPWR VGND sg13g2_fill_2
X_14335_ _03365_ net825 _05640_ VPWR VGND sg13g2_nor2_1
XFILLER_117_908 VPWR VGND sg13g2_fill_1
XFILLER_13_1060 VPWR VGND sg13g2_fill_1
X_17054_ _08210_ _08142_ _08188_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_289 VPWR VGND sg13g2_fill_2
X_14266_ _03365_ net851 _05573_ VPWR VGND sg13g2_nor2_1
XFILLER_7_586 VPWR VGND sg13g2_decap_8
Xrebuffer2209 u_FIR.sum\[8\]\[18\] net2208 VPWR VGND sg13g2_buf_1
XFILLER_125_941 VPWR VGND sg13g2_decap_8
X_16005_ _07246_ _07245_ _07240_ VPWR VGND sg13g2_nand2b_1
X_13217_ _04562_ _04563_ _04564_ VPWR VGND sg13g2_and2_1
X_14197_ _05506_ _05487_ _05504_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_462 VPWR VGND sg13g2_fill_2
X_13148_ _04497_ net747 net829 u_FIR.sum\[1\]\[6\] VPWR VGND sg13g2_and3_1
XFILLER_98_858 VPWR VGND sg13g2_decap_8
X_17956_ _09089_ _09087_ _09088_ VPWR VGND sg13g2_nand2_1
X_13079_ _04430_ _04392_ _04428_ VPWR VGND sg13g2_xnor2_1
XFILLER_39_914 VPWR VGND sg13g2_decap_8
X_16907_ _08063_ _08047_ _08061_ VPWR VGND sg13g2_xnor2_1
X_17887_ _09020_ _09019_ _09018_ VPWR VGND sg13g2_nand2b_1
XFILLER_65_221 VPWR VGND sg13g2_decap_4
XFILLER_65_243 VPWR VGND sg13g2_decap_4
XFILLER_38_457 VPWR VGND sg13g2_decap_4
X_19626_ VGND VPWR _10688_ _10689_ _10690_ _10687_ sg13g2_a21oi_1
XFILLER_38_468 VPWR VGND sg13g2_fill_1
X_16838_ VPWR _07994_ _07993_ VGND sg13g2_inv_1
XFILLER_20_1031 VPWR VGND sg13g2_decap_8
XFILLER_65_276 VPWR VGND sg13g2_fill_2
XFILLER_19_671 VPWR VGND sg13g2_fill_1
XFILLER_65_287 VPWR VGND sg13g2_fill_2
XFILLER_25_129 VPWR VGND sg13g2_fill_2
X_19557_ _10621_ _10615_ _10614_ VPWR VGND sg13g2_nand2b_1
X_16769_ _07925_ net913 net2098 net260 VPWR VGND sg13g2_and3_1
XFILLER_53_449 VPWR VGND sg13g2_decap_4
XFILLER_62_950 VPWR VGND sg13g2_fill_1
XFILLER_80_257 VPWR VGND sg13g2_fill_1
X_18508_ _09614_ u_LMS.w\[2\]\[3\] _09618_ VPWR VGND sg13g2_xor2_1
X_19488_ _10551_ _10550_ _10552_ VPWR VGND sg13g2_xor2_1
XFILLER_34_674 VPWR VGND sg13g2_fill_1
X_18439_ _09451_ _09452_ _09549_ VPWR VGND sg13g2_xor2_1
X_21450_ _02067_ net604 net211 VPWR VGND sg13g2_nand2_1
X_20401_ _01064_ u_LMS.w\[5\]\[22\] net76 VPWR VGND sg13g2_xnor2_1
XFILLER_108_908 VPWR VGND sg13g2_fill_1
X_21381_ _01998_ _01909_ _01908_ VPWR VGND sg13g2_xnor2_1
X_20332_ _00995_ _00907_ _00928_ VPWR VGND sg13g2_xnor2_1
X_23120_ net1609 VGND VPWR _00182_ u_FIR.sum\[7\]\[6\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
X_23051_ net1129 VGND VPWR _00113_ u_FIR.sum\[3\]\[13\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
X_20263_ VPWR _00926_ _00925_ VGND sg13g2_inv_1
XFILLER_89_803 VPWR VGND sg13g2_fill_1
X_22002_ _02594_ _02593_ _02596_ VPWR VGND sg13g2_xor2_1
XFILLER_89_836 VPWR VGND sg13g2_decap_8
XFILLER_0_228 VPWR VGND sg13g2_decap_8
X_20194_ _00848_ net2131 _00857_ VPWR VGND sg13g2_nor2b_1
X_23220__1445 VPWR VGND net1444 sg13g2_tiehi
XFILLER_76_508 VPWR VGND sg13g2_decap_8
XFILLER_131_988 VPWR VGND sg13g2_decap_8
XFILLER_56_37 VPWR VGND sg13g2_decap_4
XFILLER_5_1058 VPWR VGND sg13g2_fill_2
X_22904_ VGND VPWR net553 _03211_ _00781_ _03180_ sg13g2_a21oi_1
XFILLER_84_552 VPWR VGND sg13g2_decap_8
XFILLER_17_619 VPWR VGND sg13g2_decap_4
XFILLER_72_725 VPWR VGND sg13g2_fill_2
XFILLER_56_276 VPWR VGND sg13g2_decap_8
XFILLER_38_980 VPWR VGND sg13g2_fill_1
XFILLER_56_287 VPWR VGND sg13g2_fill_1
X_22835_ VGND VPWR _07884_ net338 _00757_ _03135_ sg13g2_a21oi_1
XFILLER_72_14 VPWR VGND sg13g2_fill_2
XFILLER_72_25 VPWR VGND sg13g2_decap_8
XFILLER_13_803 VPWR VGND sg13g2_fill_2
X_22766_ u_debug_unit.mon_w3_sync\[6\] net339 _03101_ VPWR VGND sg13g2_nor2_1
XFILLER_71_279 VPWR VGND sg13g2_decap_8
XFILLER_25_674 VPWR VGND sg13g2_decap_8
XFILLER_80_780 VPWR VGND sg13g2_fill_2
XFILLER_72_58 VPWR VGND sg13g2_fill_1
XFILLER_25_685 VPWR VGND sg13g2_fill_1
XFILLER_52_482 VPWR VGND sg13g2_fill_1
XFILLER_25_696 VPWR VGND sg13g2_decap_8
X_21717_ _02317_ _02198_ _02200_ VPWR VGND sg13g2_xnor2_1
XFILLER_24_184 VPWR VGND sg13g2_fill_2
XFILLER_40_644 VPWR VGND sg13g2_fill_1
X_22697_ coeff_force_packed\[61\] net462 _03069_ _00685_ VPWR VGND sg13g2_mux2_1
XFILLER_36_1060 VPWR VGND sg13g2_fill_1
X_12450_ _03826_ _03717_ _03824_ VPWR VGND sg13g2_xnor2_1
X_21648_ _02262_ _02224_ _02261_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_339 VPWR VGND sg13g2_decap_8
XFILLER_123_1052 VPWR VGND sg13g2_decap_8
X_24367_ _11197_ u_spi_slave.tx_shift\[15\] spi_miso VPWR VGND sg13g2_ebufn_2
X_12381_ _03759_ net721 net854 VPWR VGND sg13g2_nand2_1
X_21579_ _02196_ _03300_ _02183_ VPWR VGND sg13g2_nand2_1
X_14120_ _05431_ _05430_ _05389_ VPWR VGND sg13g2_nand2b_1
XFILLER_126_727 VPWR VGND sg13g2_decap_4
X_23318_ net1283 VGND VPWR _00380_ u_LMS.w\[4\]\[20\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
XFILLER_108_0 VPWR VGND sg13g2_decap_4
X_14051_ _05364_ _05342_ _05362_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_259 VPWR VGND sg13g2_decap_8
X_23249_ net1393 VGND VPWR _00311_ u_LMS.w\[1\]\[20\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
X_13002_ _04343_ VPWR _04358_ VGND net284 _04324_ sg13g2_o21ai_1
X_17810_ _08935_ _08942_ _08943_ VPWR VGND sg13g2_nor2b_1
XFILLER_0_751 VPWR VGND sg13g2_decap_8
X_18790_ VPWR _09877_ _09876_ VGND sg13g2_inv_1
XFILLER_79_379 VPWR VGND sg13g2_decap_4
XFILLER_94_316 VPWR VGND sg13g2_decap_8
X_17741_ _08874_ _08870_ _08872_ VPWR VGND sg13g2_xnor2_1
X_14953_ VGND VPWR net509 _06233_ _00154_ _06234_ sg13g2_a21oi_1
XFILLER_47_210 VPWR VGND sg13g2_decap_8
X_13904_ _05210_ _05225_ _05226_ VPWR VGND sg13g2_nor2b_1
X_17672_ _08805_ _08804_ _08800_ VPWR VGND sg13g2_nand2b_1
XFILLER_36_917 VPWR VGND sg13g2_decap_8
X_14884_ _06163_ _06168_ _06169_ VPWR VGND sg13g2_nor2b_1
XFILLER_47_265 VPWR VGND sg13g2_fill_2
XFILLER_90_511 VPWR VGND sg13g2_decap_4
XFILLER_29_980 VPWR VGND sg13g2_decap_8
X_19411_ _10475_ _10473_ _10474_ VPWR VGND sg13g2_xnor2_1
X_16623_ VGND VPWR _03324_ net517 _00251_ _07807_ sg13g2_a21oi_1
X_13835_ _05159_ _05156_ _05157_ VPWR VGND sg13g2_xnor2_1
XFILLER_46_70 VPWR VGND sg13g2_fill_1
XFILLER_62_235 VPWR VGND sg13g2_decap_4
XFILLER_62_246 VPWR VGND sg13g2_fill_1
X_19342_ _10406_ _10399_ _10405_ VPWR VGND sg13g2_nand2_1
X_16554_ net982 VPWR _07758_ VGND net488 net781 sg13g2_o21ai_1
X_13766_ net839 net748 _05090_ _05092_ VPWR VGND sg13g2_a21o_1
X_15505_ _06763_ net788 net887 VPWR VGND sg13g2_nand2_1
X_19273_ net355 VPWR _10340_ VGND u_LMS.w\[3\]\[9\] net371 sg13g2_o21ai_1
X_12717_ _04080_ _04055_ _04082_ VPWR VGND sg13g2_xor2_1
X_16485_ VGND VPWR _07704_ _07705_ _00215_ net941 sg13g2_a21oi_1
XFILLER_43_493 VPWR VGND sg13g2_fill_1
X_13697_ VPWR _05025_ _05024_ VGND sg13g2_inv_1
XFILLER_70_290 VPWR VGND sg13g2_decap_8
X_18224_ _09334_ net678 net106 VPWR VGND sg13g2_nand2_1
X_15436_ _06700_ _06684_ _06698_ VPWR VGND sg13g2_xnor2_1
X_12648_ VGND VPWR _04012_ _04013_ _04015_ _04014_ sg13g2_a21oi_1
XFILLER_129_543 VPWR VGND sg13g2_decap_8
X_18155_ _09265_ net672 net164 VPWR VGND sg13g2_nand2_1
XFILLER_12_891 VPWR VGND sg13g2_decap_8
X_15367_ net1002 VPWR _06634_ VGND net502 u_FIR.sum\[6\]\[12\] sg13g2_o21ai_1
X_12579_ _03947_ _03940_ _03949_ VPWR VGND sg13g2_xor2_1
XFILLER_7_42 VPWR VGND sg13g2_decap_8
X_17106_ _08262_ _08253_ _08261_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_350 VPWR VGND sg13g2_decap_8
XFILLER_129_587 VPWR VGND sg13g2_fill_1
X_14318_ _05624_ _05616_ _05622_ VPWR VGND sg13g2_xnor2_1
X_18086_ VGND VPWR _09187_ _09195_ _09196_ _09185_ sg13g2_a21oi_1
XFILLER_117_749 VPWR VGND sg13g2_fill_2
X_15298_ _06565_ _06531_ _06567_ VPWR VGND sg13g2_xor2_1
X_17037_ _08186_ _08192_ _08193_ VPWR VGND sg13g2_and2_1
X_14249_ _05556_ _05524_ _05557_ VPWR VGND sg13g2_nor2b_1
XFILLER_98_611 VPWR VGND sg13g2_decap_8
XFILLER_113_922 VPWR VGND sg13g2_decap_4
XFILLER_131_229 VPWR VGND sg13g2_decap_8
Xfanout808 u_FIR.x_reg\[7\] net808 VPWR VGND sg13g2_buf_1
Xfanout819 net820 net819 VPWR VGND sg13g2_buf_1
X_18988_ _10074_ _10072_ _10075_ VPWR VGND sg13g2_xor2_1
XFILLER_23_0 VPWR VGND sg13g2_fill_2
XFILLER_112_498 VPWR VGND sg13g2_fill_2
XFILLER_85_338 VPWR VGND sg13g2_fill_2
XFILLER_39_733 VPWR VGND sg13g2_fill_1
X_17939_ VPWR _09072_ _09071_ VGND sg13g2_inv_1
XFILLER_85_349 VPWR VGND sg13g2_fill_2
X_20950_ _01590_ _01514_ _01515_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_872 VPWR VGND sg13g2_decap_4
XFILLER_93_360 VPWR VGND sg13g2_decap_4
XFILLER_94_894 VPWR VGND sg13g2_fill_1
XFILLER_53_213 VPWR VGND sg13g2_fill_1
XFILLER_38_287 VPWR VGND sg13g2_fill_2
X_19609_ _10673_ net647 net255 VPWR VGND sg13g2_nand2_1
XFILLER_54_747 VPWR VGND sg13g2_decap_8
X_20881_ _01521_ _01472_ _01473_ VPWR VGND sg13g2_xnor2_1
X_22620_ coeff_force_packed\[0\] net473 _03061_ _00616_ VPWR VGND sg13g2_mux2_1
XFILLER_62_780 VPWR VGND sg13g2_decap_4
X_22551_ VGND VPWR u_LMS.count\[17\] _03030_ _00576_ _03032_ sg13g2_a21oi_1
XFILLER_107_1025 VPWR VGND sg13g2_fill_1
X_21502_ _02117_ _02118_ _02119_ VPWR VGND sg13g2_nor2_1
XFILLER_107_1058 VPWR VGND sg13g2_fill_2
XFILLER_50_986 VPWR VGND sg13g2_fill_2
X_22482_ VGND VPWR net447 _03228_ _00549_ _02990_ sg13g2_a21oi_1
XFILLER_21_187 VPWR VGND sg13g2_fill_1
X_21433_ _02050_ _01934_ _02019_ VPWR VGND sg13g2_xnor2_1
X_23479__1487 VPWR VGND net1486 sg13g2_tiehi
X_21364_ VGND VPWR _01958_ _01959_ _01981_ _01961_ sg13g2_a21oi_1
X_20315_ _00978_ _00949_ _00952_ VPWR VGND sg13g2_xnor2_1
X_23103_ net1051 VGND VPWR _00165_ u_FIR.sum\[6\]\[8\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
XFILLER_107_259 VPWR VGND sg13g2_decap_8
X_21295_ _01912_ _01910_ _01911_ VPWR VGND sg13g2_nand2_1
XFILLER_66_1020 VPWR VGND sg13g2_fill_2
XFILLER_122_218 VPWR VGND sg13g2_fill_2
XFILLER_104_922 VPWR VGND sg13g2_fill_1
X_20246_ _00909_ net264 net630 net247 net632 VPWR VGND sg13g2_a22oi_1
X_23034_ net1155 VGND VPWR _00096_ u_FIR.sum\[2\]\[15\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
XFILLER_27_1015 VPWR VGND sg13g2_decap_8
XFILLER_88_132 VPWR VGND sg13g2_decap_4
XFILLER_27_1026 VPWR VGND sg13g2_fill_2
XFILLER_104_966 VPWR VGND sg13g2_fill_1
XFILLER_67_14 VPWR VGND sg13g2_decap_4
X_20177_ _00840_ net631 net230 VPWR VGND sg13g2_nand2_1
XFILLER_130_262 VPWR VGND sg13g2_decap_8
XFILLER_103_498 VPWR VGND sg13g2_decap_8
XFILLER_18_917 VPWR VGND sg13g2_fill_2
X_11950_ VPWR _03371_ net778 VGND sg13g2_inv_1
XFILLER_29_276 VPWR VGND sg13g2_decap_4
XFILLER_84_371 VPWR VGND sg13g2_fill_2
XFILLER_44_202 VPWR VGND sg13g2_decap_8
X_11881_ VPWR _03302_ u_LMS.w\[7\]\[12\] VGND sg13g2_inv_1
X_23381__1206 VPWR VGND net1205 sg13g2_tiehi
X_13620_ _04950_ _04941_ _04949_ VPWR VGND sg13g2_nand2_1
X_22818_ u_debug_unit.mon_w7_sync\[4\] net342 _03127_ VPWR VGND sg13g2_nor2_1
XFILLER_25_471 VPWR VGND sg13g2_decap_4
XFILLER_25_482 VPWR VGND sg13g2_fill_1
X_13551_ _04883_ _04854_ _04881_ VPWR VGND sg13g2_xnor2_1
XFILLER_73_1035 VPWR VGND sg13g2_decap_4
X_22749_ VGND VPWR _07763_ net329 _00714_ _03092_ sg13g2_a21oi_1
XFILLER_12_121 VPWR VGND sg13g2_decap_4
X_12502_ _03877_ _03863_ _03876_ VPWR VGND sg13g2_nand2_1
XFILLER_12_143 VPWR VGND sg13g2_decap_8
X_16270_ _07498_ _07505_ _07506_ VPWR VGND sg13g2_nor2b_1
X_13482_ _04815_ _04816_ _04817_ VPWR VGND sg13g2_nor2_1
XFILLER_8_114 VPWR VGND sg13g2_decap_8
XFILLER_40_474 VPWR VGND sg13g2_fill_1
X_15221_ _06482_ VPWR _06491_ VGND _06452_ _06483_ sg13g2_o21ai_1
X_12433_ _03810_ _03793_ _03809_ VPWR VGND sg13g2_nand2_1
XFILLER_5_810 VPWR VGND sg13g2_decap_8
X_15152_ _06424_ _06416_ _06423_ VPWR VGND sg13g2_xnor2_1
XFILLER_126_524 VPWR VGND sg13g2_decap_8
X_12364_ _03743_ _03715_ _03741_ VPWR VGND sg13g2_xnor2_1
X_14103_ _05412_ _05409_ _05414_ VPWR VGND sg13g2_xor2_1
X_19960_ _10982_ _11000_ _11001_ VPWR VGND sg13g2_nor2b_1
X_15083_ net833 net783 u_FIR.sum\[5\]\[5\] _06357_ VPWR VGND sg13g2_a21o_1
X_12295_ _03676_ _03643_ _03674_ VPWR VGND sg13g2_xnor2_1
X_18911_ _03251_ _09997_ _09998_ VPWR VGND sg13g2_nor2_1
X_14034_ VGND VPWR _05347_ _05345_ _05305_ sg13g2_or2_1
X_19891_ _10933_ _10795_ _10797_ VPWR VGND sg13g2_xnor2_1
XFILLER_79_143 VPWR VGND sg13g2_decap_4
X_18842_ _09929_ _09927_ _09928_ VPWR VGND sg13g2_nand2_1
XFILLER_79_154 VPWR VGND sg13g2_fill_1
XFILLER_110_925 VPWR VGND sg13g2_fill_2
XFILLER_67_327 VPWR VGND sg13g2_fill_2
XFILLER_121_273 VPWR VGND sg13g2_decap_4
XFILLER_0_592 VPWR VGND sg13g2_decap_4
X_18773_ _09854_ _09859_ _09860_ VPWR VGND sg13g2_nor2b_1
X_15985_ _07227_ _07214_ _07226_ VPWR VGND sg13g2_nand2_1
X_17724_ VGND VPWR _08857_ _08856_ _08855_ sg13g2_or2_1
X_14936_ _06213_ _06215_ _06218_ VPWR VGND sg13g2_nor2_1
XFILLER_36_725 VPWR VGND sg13g2_decap_4
XFILLER_35_213 VPWR VGND sg13g2_decap_8
XFILLER_35_224 VPWR VGND sg13g2_fill_1
X_17655_ _08788_ _08769_ _08770_ VPWR VGND sg13g2_xnor2_1
X_14867_ _06138_ VPWR _06152_ VGND net267 _06136_ sg13g2_o21ai_1
X_16606_ VGND VPWR net517 _07795_ _00245_ _07796_ sg13g2_a21oi_1
X_13818_ _05143_ _05120_ _05141_ VPWR VGND sg13g2_xnor2_1
XFILLER_35_268 VPWR VGND sg13g2_decap_8
X_17586_ _08719_ _08679_ _08684_ VPWR VGND sg13g2_xnor2_1
XFILLER_23_419 VPWR VGND sg13g2_decap_8
X_14798_ _06080_ _06082_ _06085_ VPWR VGND sg13g2_nor2_1
XFILLER_17_983 VPWR VGND sg13g2_decap_8
XFILLER_90_385 VPWR VGND sg13g2_fill_1
X_19325_ _10366_ net118 _10363_ _10389_ VPWR VGND sg13g2_nand3_1
X_16537_ VGND VPWR net479 _07743_ _00228_ _07744_ sg13g2_a21oi_1
X_13749_ _05076_ _05035_ _05038_ _05075_ VPWR VGND sg13g2_and3_1
XFILLER_32_964 VPWR VGND sg13g2_fill_1
X_19256_ net355 VPWR _10328_ VGND u_LMS.w\[3\]\[4\] net371 sg13g2_o21ai_1
X_16468_ _07694_ u_FIR.x\[1\] net524 VPWR VGND sg13g2_nand2_1
XFILLER_31_485 VPWR VGND sg13g2_fill_2
X_18207_ _09312_ VPWR _09317_ VGND net2094 _09316_ sg13g2_o21ai_1
X_15419_ _06678_ _06680_ _06683_ VPWR VGND sg13g2_nor2_1
X_19187_ _10273_ net304 u_LMS.w\[3\]\[13\] coeff_force_packed\[22\] net559 VPWR VGND
+ sg13g2_a22oi_1
X_16399_ _07630_ u_FIR.sum\[7\]\[15\] net388 VPWR VGND sg13g2_xnor2_1
X_18138_ _09248_ _09247_ _09226_ VPWR VGND sg13g2_nand2b_1
XFILLER_8_670 VPWR VGND sg13g2_decap_4
X_23252__1389 VPWR VGND net1388 sg13g2_tiehi
X_18069_ _03261_ net98 _09179_ VPWR VGND sg13g2_nor2_1
X_20100_ _11141_ _11138_ _11139_ VPWR VGND sg13g2_xnor2_1
XFILLER_99_931 VPWR VGND sg13g2_fill_2
X_21080_ _01708_ _01706_ _01707_ VPWR VGND sg13g2_nand2b_1
Xfanout605 u_LMS.x_r\[7\]\[0\] net605 VPWR VGND sg13g2_buf_1
X_20031_ _11072_ _11036_ _11070_ VPWR VGND sg13g2_xnor2_1
Xfanout616 u_LMS.x_r\[6\]\[2\] net616 VPWR VGND sg13g2_buf_1
Xfanout627 u_LMS.x_r\[5\]\[4\] net627 VPWR VGND sg13g2_buf_1
XFILLER_86_603 VPWR VGND sg13g2_decap_8
XFILLER_59_817 VPWR VGND sg13g2_fill_1
Xfanout638 u_LMS.x_r\[5\]\[0\] net638 VPWR VGND sg13g2_buf_1
Xfanout649 u_LMS.x_r\[4\]\[1\] net649 VPWR VGND sg13g2_buf_1
X_23105__1049 VPWR VGND net1048 sg13g2_tiehi
XFILLER_85_102 VPWR VGND sg13g2_decap_4
XFILLER_86_647 VPWR VGND sg13g2_fill_2
XFILLER_86_669 VPWR VGND sg13g2_fill_1
XFILLER_85_157 VPWR VGND sg13g2_fill_2
XFILLER_100_468 VPWR VGND sg13g2_decap_8
XFILLER_27_703 VPWR VGND sg13g2_fill_2
XFILLER_2_1006 VPWR VGND sg13g2_decap_4
X_21982_ VGND VPWR _02554_ _02555_ _02576_ _02557_ sg13g2_a21oi_1
XFILLER_96_1013 VPWR VGND sg13g2_decap_8
XFILLER_66_371 VPWR VGND sg13g2_fill_1
X_23721_ net1374 VGND VPWR _00783_ u_s2p_input.reg_sh\[2\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
X_20933_ VGND VPWR _01573_ _01571_ u_LMS.w\[6\]\[15\] sg13g2_or2_1
XFILLER_26_224 VPWR VGND sg13g2_fill_1
XFILLER_82_853 VPWR VGND sg13g2_fill_1
XFILLER_54_555 VPWR VGND sg13g2_fill_2
XFILLER_26_246 VPWR VGND sg13g2_fill_2
X_23652_ net974 VGND VPWR _00714_ u_debug_unit.mon_w2_sync\[4\] clknet_leaf_49_clkA
+ sg13g2_dfrbpq_1
XFILLER_81_363 VPWR VGND sg13g2_decap_8
X_20864_ _03233_ net228 net197 _01500_ _01504_ VPWR VGND sg13g2_nor4_1
XFILLER_53_27 VPWR VGND sg13g2_decap_8
XFILLER_81_385 VPWR VGND sg13g2_fill_2
X_22603_ net470 debug_load_bus\[1\] _03059_ _00601_ VPWR VGND sg13g2_mux2_1
X_23583_ net985 VGND VPWR _00645_ coeff_force_packed\[26\] clknet_leaf_53_clkA sg13g2_dfrbpq_1
XFILLER_34_290 VPWR VGND sg13g2_fill_2
X_20795_ _01435_ _01434_ _01431_ VPWR VGND sg13g2_nand2b_1
X_22534_ _03022_ u_LMS.count\[11\] u_LMS.count\[10\] _03019_ VPWR VGND sg13g2_and3_1
X_22465_ net961 VPWR _02982_ VGND net449 u_LMS.x_r\[6\]\[6\] sg13g2_o21ai_1
Xclkbuf_leaf_60_clkA clknet_4_1_0_clkA clknet_leaf_60_clkA VPWR VGND sg13g2_buf_8
XFILLER_6_618 VPWR VGND sg13g2_fill_1
X_21416_ _02031_ _02032_ _02033_ VPWR VGND sg13g2_nor2_1
XFILLER_120_1033 VPWR VGND sg13g2_decap_8
X_22396_ VGND VPWR net433 _03271_ _00506_ _02947_ sg13g2_a21oi_1
XFILLER_118_42 VPWR VGND sg13g2_fill_1
X_21347_ _01962_ _01957_ _01964_ VPWR VGND sg13g2_xor2_1
XFILLER_123_516 VPWR VGND sg13g2_fill_1
XFILLER_78_24 VPWR VGND sg13g2_decap_8
XFILLER_1_312 VPWR VGND sg13g2_fill_2
X_12080_ VPWR VGND u_debug_unit.sw_reset\[4\] _03486_ net286 u_debug_unit.mon_w0_sync\[4\]
+ _03493_ _03434_ sg13g2_a221oi_1
X_21278_ _01895_ net589 net237 VPWR VGND sg13g2_nand2_1
XFILLER_89_441 VPWR VGND sg13g2_fill_2
X_23017_ net1180 VGND VPWR _00079_ u_FIR.sum\[1\]\[14\] clknet_leaf_29_clkA sg13g2_dfrbpq_1
X_20229_ VPWR _00892_ _00891_ VGND sg13g2_inv_1
XFILLER_103_251 VPWR VGND sg13g2_fill_2
XFILLER_131_582 VPWR VGND sg13g2_decap_8
XFILLER_103_295 VPWR VGND sg13g2_fill_2
XFILLER_77_658 VPWR VGND sg13g2_decap_8
XFILLER_77_669 VPWR VGND sg13g2_fill_1
X_15770_ net803 VPWR _07020_ VGND u_FIR.w\[1\]\[3\] u_FIR.w\[1\]\[2\] sg13g2_o21ai_1
XFILLER_58_872 VPWR VGND sg13g2_decap_4
X_12982_ VGND VPWR _04314_ _04332_ _04339_ _04331_ sg13g2_a21oi_1
XFILLER_45_511 VPWR VGND sg13g2_decap_8
XFILLER_94_78 VPWR VGND sg13g2_decap_4
X_14721_ _05978_ _05971_ _05986_ _06010_ VPWR VGND sg13g2_a21o_1
X_11933_ VPWR _03354_ u_LMS.w\[0\]\[23\] VGND sg13g2_inv_1
XFILLER_27_83 VPWR VGND sg13g2_decap_8
X_17440_ net364 VPWR _08576_ VGND u_LMS.w\[0\]\[9\] net382 sg13g2_o21ai_1
XFILLER_73_875 VPWR VGND sg13g2_fill_2
X_14652_ net823 _05942_ u_FIR.w\[3\]\[1\] _05943_ VPWR VGND sg13g2_nand3_1
XFILLER_73_886 VPWR VGND sg13g2_decap_8
X_11864_ VPWR _03285_ u_LMS.x\[5\] VGND sg13g2_inv_1
XFILLER_60_525 VPWR VGND sg13g2_fill_2
XFILLER_72_385 VPWR VGND sg13g2_fill_2
X_13603_ _04933_ net753 net838 VPWR VGND sg13g2_nand2_1
X_17371_ _08401_ _08471_ _08472_ _08521_ VPWR VGND sg13g2_or3_1
X_14583_ _05876_ _05875_ _05837_ VPWR VGND sg13g2_nand2b_1
X_11795_ VPWR _03216_ u_LMS.count\[2\] VGND sg13g2_inv_1
X_19110_ _03332_ _10196_ _10197_ VPWR VGND sg13g2_nor2_1
X_16322_ _07556_ _07555_ _07554_ VPWR VGND sg13g2_nand2b_1
X_13534_ _04866_ _04865_ _04861_ VPWR VGND sg13g2_nand2b_1
XFILLER_13_485 VPWR VGND sg13g2_fill_1
X_19041_ _10106_ _10127_ _10128_ VPWR VGND sg13g2_nor2b_1
X_16253_ _03375_ net847 _07489_ VPWR VGND sg13g2_nor2_1
XFILLER_40_293 VPWR VGND sg13g2_decap_8
X_13465_ VGND VPWR _04784_ _04795_ _04804_ _04794_ sg13g2_a21oi_1
X_15204_ VPWR _06475_ _06474_ VGND sg13g2_inv_1
X_12416_ _03765_ _03758_ _03773_ _03793_ VPWR VGND sg13g2_a21o_1
X_16184_ _07422_ _07414_ _07420_ VPWR VGND sg13g2_xnor2_1
X_13396_ VGND VPWR _04709_ _04731_ _04738_ _04730_ sg13g2_a21oi_1
XFILLER_126_332 VPWR VGND sg13g2_decap_4
X_15135_ VGND VPWR _06367_ _06370_ _06408_ _06406_ sg13g2_a21oi_1
X_12347_ net881 _03725_ net720 _03726_ VPWR VGND sg13g2_nand3_1
XFILLER_99_205 VPWR VGND sg13g2_decap_8
XFILLER_99_216 VPWR VGND sg13g2_fill_2
XFILLER_114_516 VPWR VGND sg13g2_fill_1
X_19943_ _10977_ _10983_ _10984_ VPWR VGND sg13g2_and2_1
X_15066_ _06310_ _06339_ _06340_ VPWR VGND sg13g2_nor2_1
XFILLER_4_21 VPWR VGND sg13g2_decap_8
X_12278_ _03659_ net724 net870 VPWR VGND sg13g2_nand2_1
X_14017_ _05329_ _05305_ _05331_ VPWR VGND sg13g2_xor2_1
XFILLER_96_901 VPWR VGND sg13g2_fill_2
X_19874_ _10919_ _10920_ _00389_ VPWR VGND sg13g2_nor2_1
XFILLER_4_98 VPWR VGND sg13g2_decap_8
X_18825_ _09912_ u_LMS.x_r\[3\]\[7\] net235 VPWR VGND sg13g2_nand2_1
X_23237__1415 VPWR VGND net1414 sg13g2_tiehi
XFILLER_83_606 VPWR VGND sg13g2_fill_2
XFILLER_49_861 VPWR VGND sg13g2_decap_4
X_18756_ _09842_ _09807_ _09843_ VPWR VGND sg13g2_xor2_1
XFILLER_95_488 VPWR VGND sg13g2_fill_2
XFILLER_67_179 VPWR VGND sg13g2_decap_8
X_15968_ _07211_ _07210_ _07205_ VPWR VGND sg13g2_nand2b_1
XFILLER_95_499 VPWR VGND sg13g2_decap_8
X_23101__1055 VPWR VGND net1054 sg13g2_tiehi
XFILLER_76_680 VPWR VGND sg13g2_fill_1
XFILLER_49_894 VPWR VGND sg13g2_decap_8
X_17707_ _08838_ _08839_ _08840_ VPWR VGND sg13g2_nor2_1
X_14919_ net267 _06201_ _06202_ VPWR VGND sg13g2_nor2_1
X_18687_ net660 net145 net658 _09774_ VPWR VGND sg13g2_nand3_1
X_15899_ VGND VPWR net498 _07144_ _00189_ _07145_ sg13g2_a21oi_1
XFILLER_24_706 VPWR VGND sg13g2_decap_8
X_17638_ _08769_ _08770_ _08771_ VPWR VGND sg13g2_and2_1
XFILLER_90_193 VPWR VGND sg13g2_fill_2
X_17569_ _08702_ net689 net184 VPWR VGND sg13g2_nand2_1
XFILLER_90_0 VPWR VGND sg13g2_fill_2
XFILLER_32_761 VPWR VGND sg13g2_decap_8
X_19308_ _10370_ _10371_ _10372_ VPWR VGND sg13g2_nor2b_1
XFILLER_20_912 VPWR VGND sg13g2_fill_1
X_20580_ _01220_ net608 net151 VPWR VGND sg13g2_nand2_1
XFILLER_32_783 VPWR VGND sg13g2_decap_8
XFILLER_20_923 VPWR VGND sg13g2_fill_2
XFILLER_104_1028 VPWR VGND sg13g2_decap_8
X_19239_ _10261_ VPWR _10314_ VGND _10257_ _10260_ sg13g2_o21ai_1
X_22250_ net60 _02840_ net716 _02844_ VPWR VGND _02841_ sg13g2_nand4_1
XFILLER_129_170 VPWR VGND sg13g2_fill_1
XFILLER_118_866 VPWR VGND sg13g2_fill_1
X_21201_ VGND VPWR _01818_ _01797_ _01795_ sg13g2_or2_1
X_22181_ _02775_ _02697_ _02698_ VPWR VGND sg13g2_xnor2_1
X_21132_ _01748_ _01747_ _01749_ VPWR VGND sg13g2_xor2_1
XFILLER_132_324 VPWR VGND sg13g2_decap_8
Xfanout402 net404 net402 VPWR VGND sg13g2_buf_1
X_21063_ VGND VPWR _01685_ _01693_ _00426_ _01694_ sg13g2_a21oi_1
Xfanout413 net415 net413 VPWR VGND sg13g2_buf_1
XFILLER_48_16 VPWR VGND sg13g2_fill_1
Xfanout424 _03243_ net424 VPWR VGND sg13g2_buf_1
Xfanout435 net439 net435 VPWR VGND sg13g2_buf_1
XFILLER_58_102 VPWR VGND sg13g2_decap_4
X_20014_ VGND VPWR _11048_ _11054_ _11055_ _11053_ sg13g2_a21oi_1
Xfanout446 net447 net446 VPWR VGND sg13g2_buf_1
XFILLER_58_113 VPWR VGND sg13g2_decap_8
XFILLER_113_582 VPWR VGND sg13g2_decap_8
XFILLER_100_210 VPWR VGND sg13g2_decap_4
XFILLER_101_733 VPWR VGND sg13g2_fill_2
Xfanout457 u_LMS.i_enable net457 VPWR VGND sg13g2_buf_1
XFILLER_86_433 VPWR VGND sg13g2_fill_2
XFILLER_113_593 VPWR VGND sg13g2_fill_1
XFILLER_100_221 VPWR VGND sg13g2_fill_2
Xfanout468 net469 net468 VPWR VGND sg13g2_buf_1
XFILLER_101_766 VPWR VGND sg13g2_decap_8
Xfanout479 net481 net479 VPWR VGND sg13g2_buf_1
XFILLER_101_777 VPWR VGND sg13g2_fill_2
XFILLER_58_168 VPWR VGND sg13g2_decap_4
XFILLER_101_788 VPWR VGND sg13g2_fill_1
XFILLER_100_276 VPWR VGND sg13g2_fill_1
XFILLER_100_287 VPWR VGND sg13g2_decap_8
X_21965_ _02558_ _02553_ _02559_ VPWR VGND sg13g2_nor2b_1
X_23704_ net1488 VGND VPWR _00766_ u_p2s_output.reg_sh\[5\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
XFILLER_55_886 VPWR VGND sg13g2_fill_2
X_20916_ _01556_ _01550_ _01555_ VPWR VGND sg13g2_xnor2_1
XFILLER_82_672 VPWR VGND sg13g2_fill_1
X_21896_ _02490_ net570 _07917_ VPWR VGND sg13g2_nand2_1
XFILLER_54_385 VPWR VGND sg13g2_decap_8
XFILLER_15_739 VPWR VGND sg13g2_decap_4
XFILLER_81_171 VPWR VGND sg13g2_fill_2
XFILLER_54_396 VPWR VGND sg13g2_fill_2
XFILLER_14_227 VPWR VGND sg13g2_fill_1
XFILLER_120_21 VPWR VGND sg13g2_decap_4
XFILLER_81_182 VPWR VGND sg13g2_decap_8
XFILLER_14_238 VPWR VGND sg13g2_decap_8
X_23635_ net1014 VGND VPWR _00697_ u_debug_unit.mon_w0_sync\[1\] clknet_leaf_37_clkA
+ sg13g2_dfrbpq_1
XFILLER_81_193 VPWR VGND sg13g2_fill_2
X_20847_ net210 net617 _01458_ _01487_ VPWR VGND sg13g2_a21o_1
XFILLER_70_867 VPWR VGND sg13g2_decap_4
Xfanout20 _01073_ net20 VPWR VGND sg13g2_buf_2
Xfanout31 _10264_ net31 VPWR VGND sg13g2_buf_1
XFILLER_70_889 VPWR VGND sg13g2_fill_2
Xfanout42 _08550_ net42 VPWR VGND sg13g2_buf_2
Xfanout53 _10850_ net53 VPWR VGND sg13g2_buf_2
X_23566_ net953 VGND VPWR _00628_ coeff_force_packed\[11\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
XFILLER_11_923 VPWR VGND sg13g2_fill_1
X_20778_ _01407_ VPWR _01418_ VGND _01372_ _01405_ sg13g2_o21ai_1
Xfanout64 _02154_ net64 VPWR VGND sg13g2_buf_8
Xfanout75 net76 net75 VPWR VGND sg13g2_buf_2
Xfanout86 net87 net86 VPWR VGND sg13g2_buf_1
X_22517_ u_LMS.count\[5\] _03009_ _03011_ VPWR VGND sg13g2_nor2_1
Xfanout97 _07991_ net97 VPWR VGND sg13g2_buf_2
XFILLER_7_905 VPWR VGND sg13g2_fill_1
XFILLER_109_800 VPWR VGND sg13g2_fill_1
X_23497_ net1422 VGND VPWR _00559_ u_LMS.count\[0\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
XFILLER_13_63 VPWR VGND sg13g2_decap_8
X_13250_ _04583_ VPWR _04596_ VGND _04579_ _04581_ sg13g2_o21ai_1
XFILLER_109_844 VPWR VGND sg13g2_fill_1
XFILLER_10_488 VPWR VGND sg13g2_fill_2
X_22448_ VGND VPWR net444 _03245_ _00532_ _02973_ sg13g2_a21oi_1
XFILLER_129_63 VPWR VGND sg13g2_decap_8
X_12201_ u_LMS.count\[31\] net440 _03589_ VPWR VGND sg13g2_nor2b_1
XFILLER_108_365 VPWR VGND sg13g2_fill_2
X_13181_ _04529_ net744 net842 VPWR VGND sg13g2_nand2_1
X_22379_ net962 VPWR _02939_ VGND net453 net695 sg13g2_o21ai_1
X_12132_ _03542_ net295 coeff_force_packed\[36\] _03424_ coeff_force_packed\[8\] VPWR
+ VGND sg13g2_a22oi_1
XFILLER_2_621 VPWR VGND sg13g2_fill_1
XFILLER_2_632 VPWR VGND sg13g2_fill_2
XFILLER_2_643 VPWR VGND sg13g2_fill_2
XFILLER_78_901 VPWR VGND sg13g2_fill_1
XFILLER_2_654 VPWR VGND sg13g2_fill_2
X_16940_ VGND VPWR _08089_ _08095_ _08096_ _08094_ sg13g2_a21oi_1
X_12063_ VPWR VGND u_debug_unit.sw_reset\[5\] _03468_ net286 coeff_force_packed\[33\]
+ _03477_ net287 sg13g2_a221oi_1
XFILLER_1_164 VPWR VGND sg13g2_decap_8
XFILLER_1_175 VPWR VGND sg13g2_fill_1
XFILLER_78_956 VPWR VGND sg13g2_fill_2
X_16871_ VPWR _08027_ _08026_ VGND sg13g2_inv_1
XFILLER_49_146 VPWR VGND sg13g2_decap_8
Xfanout980 net1000 net980 VPWR VGND sg13g2_buf_1
X_18610_ VGND VPWR _09710_ _09711_ _00334_ net921 sg13g2_a21oi_1
Xfanout991 net992 net991 VPWR VGND sg13g2_buf_1
X_15822_ _07071_ u_FIR.sum\[6\]\[11\] net391 VPWR VGND sg13g2_xnor2_1
X_19590_ _10654_ net645 net258 VPWR VGND sg13g2_nand2_1
XFILLER_64_116 VPWR VGND sg13g2_decap_8
XFILLER_46_820 VPWR VGND sg13g2_fill_2
X_18541_ VGND VPWR _09648_ _09649_ _09651_ _09594_ sg13g2_a21oi_1
X_15753_ _06996_ _07003_ _07004_ VPWR VGND sg13g2_nor2b_1
X_12965_ _04323_ _04316_ _04322_ VPWR VGND sg13g2_xnor2_1
XFILLER_18_544 VPWR VGND sg13g2_decap_8
X_14704_ _05994_ _05990_ _05993_ VPWR VGND sg13g2_xnor2_1
X_11916_ VPWR _03337_ u_LMS.w\[2\]\[8\] VGND sg13g2_inv_1
X_18472_ _09582_ _09222_ _09581_ VPWR VGND sg13g2_xnor2_1
X_15684_ VGND VPWR _06899_ _06927_ _06936_ _06929_ sg13g2_a21oi_1
XFILLER_46_897 VPWR VGND sg13g2_decap_8
XFILLER_45_374 VPWR VGND sg13g2_decap_8
XFILLER_33_514 VPWR VGND sg13g2_fill_1
X_12896_ _04256_ u_FIR.w\[7\]\[6\] net844 VPWR VGND sg13g2_nand2b_1
X_17423_ VGND VPWR net58 _08562_ _08563_ net42 sg13g2_a21oi_1
X_14635_ _05926_ _05925_ _00144_ VPWR VGND sg13g2_nor2b_1
X_11847_ VPWR _03268_ net686 VGND sg13g2_inv_1
XFILLER_60_344 VPWR VGND sg13g2_fill_1
XFILLER_14_750 VPWR VGND sg13g2_fill_1
X_17354_ _08508_ net315 u_LMS.w\[0\]\[14\] coeff_force_packed\[2\] net564 VPWR VGND
+ sg13g2_a22oi_1
X_14566_ _05856_ _05858_ _05859_ VPWR VGND sg13g2_nor2_1
XFILLER_14_794 VPWR VGND sg13g2_decap_4
XFILLER_13_271 VPWR VGND sg13g2_fill_2
XFILLER_13_282 VPWR VGND sg13g2_fill_2
X_16305_ _07540_ _07532_ _07538_ VPWR VGND sg13g2_xnor2_1
X_13517_ _04850_ _04844_ _04848_ VPWR VGND sg13g2_xnor2_1
X_17285_ _08427_ _08440_ _08441_ VPWR VGND sg13g2_nor2_1
X_14497_ _05791_ _05792_ _05793_ VPWR VGND sg13g2_nor2_1
XFILLER_118_107 VPWR VGND sg13g2_fill_1
XFILLER_9_275 VPWR VGND sg13g2_fill_1
X_19024_ net207 _10110_ net665 _10111_ VPWR VGND sg13g2_nand3_1
X_16236_ _07473_ _07444_ _07471_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_286 VPWR VGND sg13g2_fill_1
Xclkload12 clknet_4_14_0_clkA clkload12/X VPWR VGND sg13g2_buf_8
X_13448_ u_FIR.sum\[1\]\[15\] _04691_ _04788_ VPWR VGND sg13g2_nor2b_1
Xclkload23 clkload23/Y clknet_leaf_46_clkA VPWR VGND sg13g2_inv_2
Xclkload34 clknet_leaf_14_clkA clkload34/X VPWR VGND sg13g2_buf_8
Xclkload45 clknet_leaf_32_clkA clkload45/X VPWR VGND sg13g2_buf_8
Xclkload56 VPWR clkload56/Y clknet_3_5__leaf_spi_sclk VGND sg13g2_inv_1
X_16167_ VGND VPWR _07367_ _07374_ _07405_ _07381_ sg13g2_a21oi_1
XFILLER_127_674 VPWR VGND sg13g2_decap_8
X_13379_ _04722_ _04711_ _04721_ VPWR VGND sg13g2_xnor2_1
X_23125__1602 VPWR VGND net1601 sg13g2_tiehi
X_15118_ _06390_ _06351_ _06391_ VPWR VGND sg13g2_xor2_1
XFILLER_47_1007 VPWR VGND sg13g2_decap_8
XFILLER_114_324 VPWR VGND sg13g2_fill_1
X_16098_ _07338_ net797 net845 VPWR VGND sg13g2_nand2_1
XFILLER_130_806 VPWR VGND sg13g2_fill_1
XFILLER_130_817 VPWR VGND sg13g2_fill_2
X_19926_ net113 _10965_ net624 _10967_ VPWR VGND sg13g2_nand3_1
X_15049_ _06323_ _06320_ _06324_ VPWR VGND sg13g2_xor2_1
X_19857_ net358 VPWR _10908_ VGND u_LMS.w\[4\]\[2\] net373 sg13g2_o21ai_1
XFILLER_68_444 VPWR VGND sg13g2_decap_8
XFILLER_95_230 VPWR VGND sg13g2_decap_4
XFILLER_84_904 VPWR VGND sg13g2_decap_4
XFILLER_68_455 VPWR VGND sg13g2_fill_2
X_18808_ VPWR _09895_ _09894_ VGND sg13g2_inv_1
XFILLER_96_797 VPWR VGND sg13g2_decap_8
X_19788_ _10852_ net321 net53 VPWR VGND sg13g2_nand2_1
X_23411__1116 VPWR VGND net1115 sg13g2_tiehi
XFILLER_84_959 VPWR VGND sg13g2_fill_1
XFILLER_49_691 VPWR VGND sg13g2_decap_8
XFILLER_37_842 VPWR VGND sg13g2_fill_1
X_18739_ _09823_ _09825_ _09826_ VPWR VGND sg13g2_and2_1
XFILLER_70_108 VPWR VGND sg13g2_fill_2
XFILLER_37_886 VPWR VGND sg13g2_fill_2
X_21750_ _02343_ _02342_ _02344_ VPWR VGND sg13g2_xor2_1
XFILLER_51_311 VPWR VGND sg13g2_decap_4
X_20701_ _01339_ _01338_ _01341_ VPWR VGND sg13g2_xor2_1
X_23199__1483 VPWR VGND net1482 sg13g2_tiehi
X_21681_ _02289_ _02235_ _02284_ VPWR VGND sg13g2_nand2_1
X_23420_ net1088 VGND VPWR _00482_ u_LMS.w\[8\]\[7\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
X_20632_ _03227_ _03228_ _08068_ net209 _01272_ VPWR VGND sg13g2_nor4_1
X_23351_ net1250 VGND VPWR _00413_ u_LMS.w\[5\]\[7\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
X_20563_ _01203_ net610 net151 VPWR VGND sg13g2_nand2_1
Xclkload6 clknet_4_7_0_clkA clkload6/X VPWR VGND sg13g2_buf_8
X_22302_ VGND VPWR _02885_ _02886_ _00473_ net924 sg13g2_a21oi_1
XFILLER_50_39 VPWR VGND sg13g2_decap_8
XFILLER_20_786 VPWR VGND sg13g2_decap_4
X_23282_ net1329 VGND VPWR _00344_ u_LMS.w\[2\]\[7\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
XFILLER_118_630 VPWR VGND sg13g2_fill_2
X_20494_ _01138_ _01019_ _01021_ VPWR VGND sg13g2_xnor2_1
X_23078__1090 VPWR VGND net1089 sg13g2_tiehi
XFILLER_30_1033 VPWR VGND sg13g2_fill_1
X_22233_ _02823_ _02756_ _02825_ _02827_ VPWR VGND sg13g2_a21o_1
XFILLER_105_302 VPWR VGND sg13g2_fill_1
XFILLER_105_313 VPWR VGND sg13g2_decap_8
X_22164_ u_LMS.w\[8\]\[16\] _02757_ _02758_ VPWR VGND sg13g2_and2_1
XFILLER_79_709 VPWR VGND sg13g2_fill_2
XFILLER_59_26 VPWR VGND sg13g2_fill_1
XFILLER_105_357 VPWR VGND sg13g2_fill_2
X_21115_ _01733_ _01734_ _00438_ VPWR VGND sg13g2_nor2_1
X_22095_ _02689_ _02656_ _02688_ VPWR VGND sg13g2_xnor2_1
Xfanout210 net215 net210 VPWR VGND sg13g2_buf_1
Xfanout221 net224 net221 VPWR VGND sg13g2_buf_1
XFILLER_99_580 VPWR VGND sg13g2_decap_4
Xfanout232 net233 net232 VPWR VGND sg13g2_buf_2
X_21046_ _01681_ net317 u_LMS.w\[6\]\[17\] coeff_force_packed\[47\] net565 VPWR VGND
+ sg13g2_a22oi_1
Xfanout243 net243 _07916_ VPWR VGND sg13g2_buf_4
Xfanout254 net260 net254 VPWR VGND sg13g2_buf_1
Xfanout265 net266 net265 VPWR VGND sg13g2_buf_1
Xfanout276 _06587_ net276 VPWR VGND sg13g2_buf_1
Xfanout287 _03439_ net287 VPWR VGND sg13g2_buf_1
Xfanout298 _00772_ net298 VPWR VGND sg13g2_buf_1
XFILLER_101_596 VPWR VGND sg13g2_fill_1
X_22997_ net1210 VGND VPWR _00059_ u_FIR.sum\[0\]\[9\] clknet_leaf_29_clkA sg13g2_dfrbpq_1
X_12750_ _04065_ VPWR _04114_ VGND _04063_ _04066_ sg13g2_o21ai_1
X_21948_ _02542_ net578 net186 VPWR VGND sg13g2_nand2_1
XFILLER_131_53 VPWR VGND sg13g2_decap_8
XFILLER_55_694 VPWR VGND sg13g2_fill_1
XFILLER_43_834 VPWR VGND sg13g2_decap_8
XFILLER_91_35 VPWR VGND sg13g2_decap_4
XFILLER_54_193 VPWR VGND sg13g2_decap_8
X_12681_ _04046_ _04017_ _04047_ VPWR VGND sg13g2_nor2b_1
X_21879_ _02466_ _02472_ _02473_ VPWR VGND sg13g2_nor2b_1
X_14420_ _05722_ _05674_ _05720_ VPWR VGND sg13g2_xnor2_1
X_23618_ net955 VGND VPWR _00680_ coeff_force_packed\[56\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
XFILLER_24_51 VPWR VGND sg13g2_decap_4
X_14351_ _05656_ _05649_ _05654_ VPWR VGND sg13g2_xnor2_1
X_23549_ net1010 VGND VPWR _00611_ sys_enable_bus\[3\] clknet_leaf_17_clkA sg13g2_dfrbpq_1
XFILLER_129_939 VPWR VGND sg13g2_fill_2
X_13302_ _03361_ net856 _04647_ VPWR VGND sg13g2_nor2_1
X_17070_ _08191_ VPWR _08226_ VGND _08167_ _08189_ sg13g2_o21ai_1
XFILLER_11_786 VPWR VGND sg13g2_decap_8
X_14282_ _05589_ _05547_ _05587_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_757 VPWR VGND sg13g2_fill_2
XFILLER_6_234 VPWR VGND sg13g2_fill_1
X_16021_ _07262_ _07261_ _07257_ VPWR VGND sg13g2_nand2b_1
XFILLER_109_663 VPWR VGND sg13g2_decap_8
X_13233_ _04580_ u_FIR.sum\[1\]\[8\] net405 VPWR VGND sg13g2_nand2_1
XFILLER_40_72 VPWR VGND sg13g2_decap_8
XFILLER_108_162 VPWR VGND sg13g2_fill_1
XFILLER_109_696 VPWR VGND sg13g2_decap_8
XFILLER_123_110 VPWR VGND sg13g2_decap_8
X_13164_ net533 VPWR _04513_ VGND _04511_ _04512_ sg13g2_o21ai_1
X_12115_ _03526_ net290 coeff_force_packed\[2\] _03416_ u_debug_unit.mon_w8_sync\[2\]
+ VPWR VGND sg13g2_a22oi_1
X_17972_ VGND VPWR _09102_ _09103_ _00304_ net923 sg13g2_a21oi_1
X_13095_ VGND VPWR _04445_ _04443_ _04414_ sg13g2_or2_1
X_19711_ _10775_ u_LMS.w\[4\]\[4\] _10767_ VPWR VGND sg13g2_xnor2_1
X_16923_ _08079_ net706 net112 VPWR VGND sg13g2_nand2_1
X_12046_ _03461_ net285 sys_enable_bus\[6\] net289 coeff_force_packed\[27\] VPWR VGND
+ sg13g2_a22oi_1
XFILLER_78_742 VPWR VGND sg13g2_fill_2
XFILLER_27_7 VPWR VGND sg13g2_decap_4
XFILLER_120_850 VPWR VGND sg13g2_decap_8
XFILLER_66_915 VPWR VGND sg13g2_fill_2
XFILLER_78_786 VPWR VGND sg13g2_fill_2
X_19642_ _10706_ net651 net256 VPWR VGND sg13g2_nand2_1
XFILLER_65_403 VPWR VGND sg13g2_decap_8
XFILLER_38_628 VPWR VGND sg13g2_decap_8
X_16854_ net112 _08008_ net703 _08010_ VPWR VGND sg13g2_nand3_1
XFILLER_93_723 VPWR VGND sg13g2_fill_1
XFILLER_92_200 VPWR VGND sg13g2_fill_1
XFILLER_93_745 VPWR VGND sg13g2_fill_1
XFILLER_19_831 VPWR VGND sg13g2_fill_2
X_15805_ _07040_ VPWR _07054_ VGND _07036_ _07038_ sg13g2_o21ai_1
X_19573_ _10612_ VPWR _10637_ VGND _03250_ net140 sg13g2_o21ai_1
X_16785_ _07941_ _07940_ _07927_ VPWR VGND sg13g2_xnor2_1
X_13997_ net880 net765 u_FIR.sum\[3\]\[2\] _05312_ VPWR VGND sg13g2_a21o_1
XFILLER_1_77 VPWR VGND sg13g2_decap_8
XFILLER_18_341 VPWR VGND sg13g2_fill_2
X_18524_ VGND VPWR _09631_ _09632_ _09634_ _09607_ sg13g2_a21oi_1
XFILLER_46_672 VPWR VGND sg13g2_decap_8
X_15736_ _06987_ _06981_ _06985_ VPWR VGND sg13g2_xnor2_1
X_12948_ _04307_ _04283_ _04306_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_288 VPWR VGND sg13g2_fill_2
XFILLER_80_428 VPWR VGND sg13g2_fill_2
XFILLER_46_683 VPWR VGND sg13g2_fill_2
XFILLER_19_897 VPWR VGND sg13g2_fill_2
XFILLER_80_439 VPWR VGND sg13g2_decap_8
X_18455_ VGND VPWR _09324_ _09356_ _09565_ _09323_ sg13g2_a21oi_1
X_15667_ _06871_ VPWR _06920_ VGND _06868_ _06872_ sg13g2_o21ai_1
X_12879_ _04240_ _04211_ _04238_ VPWR VGND sg13g2_xnor2_1
XFILLER_60_130 VPWR VGND sg13g2_decap_4
X_17406_ net936 _08549_ _00292_ VPWR VGND sg13g2_nor2_1
XFILLER_61_686 VPWR VGND sg13g2_fill_1
X_14618_ VGND VPWR net774 net822 _05910_ u_FIR.sum\[4\]\[6\] sg13g2_a21oi_1
XFILLER_92_1060 VPWR VGND sg13g2_fill_1
X_18386_ VGND VPWR _09494_ net2116 _09496_ _09493_ sg13g2_a21oi_1
X_15598_ _06851_ _06822_ _06853_ VPWR VGND sg13g2_xor2_1
X_23025__1169 VPWR VGND net1168 sg13g2_tiehi
X_17337_ net557 net368 _08493_ VPWR VGND sg13g2_nor2_1
X_14549_ _05843_ _05835_ _05842_ VPWR VGND sg13g2_nand2_1
X_17268_ _08424_ _08330_ _08337_ VPWR VGND sg13g2_xnor2_1
X_19007_ VPWR _10094_ _10093_ VGND sg13g2_inv_1
X_16219_ _07456_ u_FIR.w\[0\]\[3\] net798 net805 VPWR VGND sg13g2_and3_1
X_17199_ _08244_ VPWR _08355_ VGND _08223_ _08245_ sg13g2_o21ai_1
XFILLER_53_0 VPWR VGND sg13g2_decap_8
XFILLER_115_666 VPWR VGND sg13g2_fill_2
XFILLER_88_528 VPWR VGND sg13g2_fill_1
XFILLER_88_539 VPWR VGND sg13g2_decap_4
X_19909_ _10950_ net631 net154 VPWR VGND sg13g2_nand2_1
XFILLER_130_669 VPWR VGND sg13g2_decap_8
XFILLER_96_550 VPWR VGND sg13g2_decap_4
X_22920_ net939 _03170_ _03188_ _00789_ VPWR VGND sg13g2_nor3_1
XFILLER_68_263 VPWR VGND sg13g2_fill_1
X_22851_ _03147_ _07895_ _03137_ net551 u_p2s_output.reg_sh\[0\] VPWR VGND sg13g2_a22oi_1
X_21802_ _02396_ _02388_ _02394_ VPWR VGND sg13g2_xnor2_1
XFILLER_83_277 VPWR VGND sg13g2_decap_4
XFILLER_45_39 VPWR VGND sg13g2_decap_8
X_22782_ u_debug_unit.mon_w5_sync\[0\] net346 _03109_ VPWR VGND sg13g2_nor2_1
X_21733_ _02329_ _02210_ _02212_ VPWR VGND sg13g2_xnor2_1
XFILLER_40_804 VPWR VGND sg13g2_decap_8
X_21664_ net12 VPWR _02275_ VGND net11 _02274_ sg13g2_o21ai_1
X_23403_ net1139 VGND VPWR _00465_ u_LMS.w\[8\]\[13\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
XFILLER_61_49 VPWR VGND sg13g2_decap_8
X_20615_ _01253_ _01254_ _01255_ VPWR VGND sg13g2_nor2_1
X_21595_ _02212_ _02211_ _02175_ VPWR VGND sg13g2_nand2b_1
XFILLER_20_550 VPWR VGND sg13g2_fill_2
X_23334_ net1267 VGND VPWR _00396_ u_LMS.w\[5\]\[13\] clknet_leaf_20_clkA sg13g2_dfrbpq_1
X_20546_ _01184_ _01177_ _01186_ VPWR VGND sg13g2_xor2_1
XFILLER_125_408 VPWR VGND sg13g2_fill_1
X_23265_ net1363 VGND VPWR _00327_ u_LMS.w\[2\]\[13\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
X_20477_ _01124_ _01125_ _00409_ VPWR VGND sg13g2_nor2_1
X_22216_ _02769_ u_LMS.w\[8\]\[11\] _02810_ VPWR VGND sg13g2_xor2_1
X_23196_ net1487 VGND VPWR _00258_ u_FIR.w\[5\]\[6\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
XFILLER_10_53 VPWR VGND sg13g2_decap_8
X_22147_ VGND VPWR _02741_ _02406_ _02362_ sg13g2_or2_1
XFILLER_126_42 VPWR VGND sg13g2_decap_8
XFILLER_117_1016 VPWR VGND sg13g2_decap_8
Xfanout1005 net1008 net1005 VPWR VGND sg13g2_buf_1
Xfanout1016 net1018 net1016 VPWR VGND sg13g2_buf_1
X_23508__1385 VPWR VGND net1384 sg13g2_tiehi
Xfanout1027 net1028 net1027 VPWR VGND sg13g2_buf_1
X_22078_ _02672_ _02649_ _02650_ VPWR VGND sg13g2_xnor2_1
Xfanout1038 net1041 net1038 VPWR VGND sg13g2_buf_1
XFILLER_94_509 VPWR VGND sg13g2_decap_8
XFILLER_120_146 VPWR VGND sg13g2_decap_8
XFILLER_120_168 VPWR VGND sg13g2_decap_8
XFILLER_0_999 VPWR VGND sg13g2_decap_8
X_21029_ VGND VPWR _01666_ _01667_ _00419_ net937 sg13g2_a21oi_1
X_13920_ _05217_ VPWR _05241_ VGND net281 _05215_ sg13g2_o21ai_1
XFILLER_120_179 VPWR VGND sg13g2_fill_1
XFILLER_102_894 VPWR VGND sg13g2_decap_8
X_13851_ _05175_ _05153_ _05173_ VPWR VGND sg13g2_xnor2_1
XFILLER_75_767 VPWR VGND sg13g2_decap_8
XFILLER_63_918 VPWR VGND sg13g2_fill_2
XFILLER_35_609 VPWR VGND sg13g2_fill_2
XFILLER_47_469 VPWR VGND sg13g2_fill_1
XFILLER_28_661 VPWR VGND sg13g2_fill_2
X_12802_ _04165_ _04131_ _04163_ VPWR VGND sg13g2_xnor2_1
X_23308__1294 VPWR VGND net1293 sg13g2_tiehi
X_16570_ u_LMS.w\[3\]\[20\] u_LMS.w\[3\]\[19\] u_LMS.w\[3\]\[18\] _07768_ VPWR VGND
+ sg13g2_nor3_1
X_13782_ _05108_ _05099_ _05106_ VPWR VGND sg13g2_xnor2_1
XFILLER_15_300 VPWR VGND sg13g2_fill_1
XFILLER_55_480 VPWR VGND sg13g2_decap_8
XFILLER_43_620 VPWR VGND sg13g2_fill_1
X_15521_ _06778_ _06757_ _06777_ VPWR VGND sg13g2_xnor2_1
X_12733_ net884 net730 _04095_ _04097_ VPWR VGND sg13g2_a21o_1
XFILLER_35_72 VPWR VGND sg13g2_decap_8
XFILLER_16_889 VPWR VGND sg13g2_decap_8
X_18240_ _09350_ _09345_ _09348_ VPWR VGND sg13g2_xnor2_1
X_15452_ _06715_ _06714_ _06713_ VPWR VGND sg13g2_nand2b_1
XFILLER_42_163 VPWR VGND sg13g2_fill_2
X_12664_ _04030_ _04024_ _04028_ VPWR VGND sg13g2_xnor2_1
XFILLER_42_174 VPWR VGND sg13g2_fill_1
X_14403_ _05706_ _05697_ _05704_ VPWR VGND sg13g2_xnor2_1
XFILLER_42_196 VPWR VGND sg13g2_fill_1
X_18171_ _09274_ VPWR _09281_ VGND _09188_ _09275_ sg13g2_o21ai_1
X_15383_ _06649_ u_FIR.sum\[5\]\[13\] net393 VPWR VGND sg13g2_nand2_1
X_12595_ _03964_ _03956_ _03962_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_747 VPWR VGND sg13g2_fill_2
XFILLER_128_213 VPWR VGND sg13g2_fill_1
X_17122_ _08277_ _08276_ _08278_ VPWR VGND sg13g2_nor2b_1
X_14334_ _05639_ net758 net809 VPWR VGND sg13g2_nand2_1
X_17053_ VGND VPWR _08177_ _08185_ _08209_ _08193_ sg13g2_a21oi_1
XFILLER_109_460 VPWR VGND sg13g2_decap_8
X_23021__1175 VPWR VGND net1174 sg13g2_tiehi
X_14265_ _05572_ net760 net824 VPWR VGND sg13g2_nand2_1
XFILLER_128_279 VPWR VGND sg13g2_fill_1
XFILLER_109_471 VPWR VGND sg13g2_fill_2
X_16004_ _07243_ _07242_ _07245_ VPWR VGND sg13g2_xor2_1
X_13216_ net868 net739 _04561_ _04563_ VPWR VGND sg13g2_a21o_1
X_14196_ _05487_ _05504_ _05505_ VPWR VGND sg13g2_nor2b_1
XFILLER_125_986 VPWR VGND sg13g2_fill_2
X_13147_ _04451_ _04453_ _04496_ VPWR VGND sg13g2_and2_1
X_23036__1153 VPWR VGND net1152 sg13g2_tiehi
X_17955_ net78 VPWR _09088_ VGND u_LMS.w\[1\]\[23\] u_LMS.w\[1\]\[22\] sg13g2_o21ai_1
X_13078_ _04429_ _04428_ _04392_ VPWR VGND sg13g2_nand2b_1
X_16906_ _08062_ _08047_ _08061_ VPWR VGND sg13g2_nand2_1
X_12029_ _03446_ net289 u_debug_unit.force_w3\[7\] net290 u_debug_unit.force_w0\[7\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_78_572 VPWR VGND sg13g2_fill_1
X_17886_ _09019_ u_LMS.w\[1\]\[6\] _09002_ VPWR VGND sg13g2_xnor2_1
XFILLER_39_948 VPWR VGND sg13g2_decap_8
XFILLER_120_691 VPWR VGND sg13g2_fill_2
X_19625_ _10679_ VPWR _10689_ VGND _10680_ _10682_ sg13g2_o21ai_1
XFILLER_54_907 VPWR VGND sg13g2_fill_2
X_16837_ net708 net155 net706 _07993_ VPWR VGND sg13g2_nand3_1
XFILLER_76_90 VPWR VGND sg13g2_decap_8
XFILLER_20_1010 VPWR VGND sg13g2_fill_1
XFILLER_66_789 VPWR VGND sg13g2_decap_8
XFILLER_81_726 VPWR VGND sg13g2_fill_1
XFILLER_80_203 VPWR VGND sg13g2_fill_1
X_19556_ _10618_ _10619_ _10620_ VPWR VGND sg13g2_nor2_1
X_16768_ _07924_ net913 _07897_ VPWR VGND sg13g2_nand2_1
XFILLER_80_225 VPWR VGND sg13g2_decap_8
XFILLER_46_480 VPWR VGND sg13g2_decap_8
XFILLER_34_631 VPWR VGND sg13g2_fill_2
X_18507_ u_LMS.w\[2\]\[3\] _09614_ _09617_ VPWR VGND sg13g2_nor2_1
X_15719_ _06971_ _06936_ _06969_ VPWR VGND sg13g2_xnor2_1
X_19487_ _10551_ _10386_ _10521_ VPWR VGND sg13g2_xnor2_1
XFILLER_80_269 VPWR VGND sg13g2_decap_4
X_16699_ VGND VPWR u_LMS.w\[7\]\[17\] _07852_ _07864_ _07853_ sg13g2_a21oi_1
X_18438_ VGND VPWR _09478_ _09548_ _09547_ _09546_ sg13g2_a21oi_2
X_18369_ _09479_ net683 net219 VPWR VGND sg13g2_nand2_1
XFILLER_21_369 VPWR VGND sg13g2_fill_1
XFILLER_119_202 VPWR VGND sg13g2_fill_1
X_20400_ _03317_ net76 _01063_ VPWR VGND sg13g2_nor2_1
X_21380_ VGND VPWR _01975_ _01976_ _01997_ _01978_ sg13g2_a21oi_1
XFILLER_107_419 VPWR VGND sg13g2_decap_8
X_20331_ _03312_ _00993_ _00994_ VPWR VGND sg13g2_nor2_1
XFILLER_116_931 VPWR VGND sg13g2_decap_8
X_23050_ net1131 VGND VPWR _00112_ u_FIR.sum\[3\]\[12\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
X_20262_ VGND VPWR _00921_ _00924_ _00925_ _00918_ sg13g2_a21oi_1
X_22001_ _02593_ _02594_ _02595_ VPWR VGND sg13g2_nor2_1
XFILLER_1_719 VPWR VGND sg13g2_fill_2
XFILLER_131_912 VPWR VGND sg13g2_decap_8
X_20193_ _00853_ net2122 _00856_ VPWR VGND sg13g2_xor2_1
Xclkbuf_leaf_17_clkA clknet_4_9_0_clkA clknet_leaf_17_clkA VPWR VGND sg13g2_buf_8
XFILLER_97_870 VPWR VGND sg13g2_decap_8
XFILLER_69_561 VPWR VGND sg13g2_fill_1
XFILLER_56_200 VPWR VGND sg13g2_decap_8
XFILLER_130_499 VPWR VGND sg13g2_decap_8
XFILLER_99_1022 VPWR VGND sg13g2_decap_8
XFILLER_84_520 VPWR VGND sg13g2_decap_4
XFILLER_5_1037 VPWR VGND sg13g2_decap_8
XFILLER_56_211 VPWR VGND sg13g2_fill_2
X_22903_ net1028 VPWR _03180_ VGND net553 u_s2p_input.reg_sh\[0\] sg13g2_o21ai_1
XFILLER_56_49 VPWR VGND sg13g2_decap_8
XFILLER_29_458 VPWR VGND sg13g2_decap_8
XFILLER_112_22 VPWR VGND sg13g2_fill_1
X_22834_ u_debug_unit.mon_w8_sync\[5\] net338 _03135_ VPWR VGND sg13g2_nor2_1
XFILLER_84_597 VPWR VGND sg13g2_fill_1
X_22765_ VGND VPWR _07785_ net337 _00722_ _03100_ sg13g2_a21oi_1
XFILLER_13_815 VPWR VGND sg13g2_fill_1
X_23268__1358 VPWR VGND net1357 sg13g2_tiehi
X_21716_ _02315_ _02316_ _00457_ VPWR VGND sg13g2_nor2_1
X_22696_ coeff_force_packed\[60\] net464 _03069_ _00684_ VPWR VGND sg13g2_mux2_1
X_21647_ net1660 u_LMS.w\[7\]\[15\] _02261_ VPWR VGND sg13g2_xor2_1
XFILLER_12_369 VPWR VGND sg13g2_decap_8
XFILLER_123_1031 VPWR VGND sg13g2_decap_8
X_12380_ _03758_ _03726_ _03729_ VPWR VGND sg13g2_nand2_1
X_21578_ _02185_ u_LMS.w\[7\]\[4\] _02194_ _02195_ VPWR VGND sg13g2_a21o_1
XFILLER_126_706 VPWR VGND sg13g2_decap_8
X_23317_ net1284 VGND VPWR _00379_ u_LMS.w\[4\]\[19\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
X_20529_ _01166_ _01168_ _01169_ VPWR VGND sg13g2_nor2_1
XFILLER_4_524 VPWR VGND sg13g2_fill_2
XFILLER_125_238 VPWR VGND sg13g2_decap_8
X_14050_ _05363_ _05362_ _05342_ VPWR VGND sg13g2_nand2b_1
X_23248_ net1395 VGND VPWR _00310_ u_LMS.w\[1\]\[19\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
XFILLER_106_441 VPWR VGND sg13g2_decap_8
X_13001_ _04348_ VPWR _04357_ VGND _04341_ _04349_ sg13g2_o21ai_1
XFILLER_107_997 VPWR VGND sg13g2_decap_4
XFILLER_97_45 VPWR VGND sg13g2_decap_8
X_23179_ net1517 VGND VPWR _00241_ u_FIR.w\[3\]\[3\] clknet_leaf_51_clkA sg13g2_dfrbpq_1
XFILLER_79_358 VPWR VGND sg13g2_decap_8
XFILLER_79_369 VPWR VGND sg13g2_fill_1
X_17740_ _08873_ _08870_ _08872_ VPWR VGND sg13g2_nand2_1
X_14952_ net1007 VPWR _06234_ VGND net509 u_FIR.sum\[5\]\[16\] sg13g2_o21ai_1
XFILLER_87_380 VPWR VGND sg13g2_fill_2
X_13903_ _05223_ _05211_ _05225_ VPWR VGND sg13g2_xor2_1
X_17671_ _08802_ _08803_ _08804_ VPWR VGND sg13g2_nor2_1
XFILLER_48_778 VPWR VGND sg13g2_fill_2
XFILLER_47_244 VPWR VGND sg13g2_decap_8
XFILLER_130_1046 VPWR VGND sg13g2_decap_8
X_14883_ _06168_ _06135_ _06166_ VPWR VGND sg13g2_xnor2_1
XFILLER_48_789 VPWR VGND sg13g2_fill_1
X_19410_ _10474_ _10438_ _10440_ VPWR VGND sg13g2_xnor2_1
X_16622_ net1019 VPWR _07807_ VGND net517 u_FIR.w\[4\]\[6\] sg13g2_o21ai_1
XFILLER_35_428 VPWR VGND sg13g2_decap_8
X_13834_ net409 _05156_ u_FIR.w\[5\]\[6\] _05158_ VPWR VGND sg13g2_nand3_1
XFILLER_63_759 VPWR VGND sg13g2_fill_1
X_23470__1519 VPWR VGND net1518 sg13g2_tiehi
X_19341_ _10403_ _10404_ _10405_ VPWR VGND sg13g2_nor2b_1
XFILLER_16_642 VPWR VGND sg13g2_fill_1
X_16553_ VGND VPWR u_LMS.w\[2\]\[13\] _07753_ _07757_ _07754_ sg13g2_a21oi_1
X_13765_ net839 _05090_ net748 _05091_ VPWR VGND sg13g2_nand3_1
XFILLER_16_653 VPWR VGND sg13g2_fill_1
XFILLER_62_269 VPWR VGND sg13g2_fill_1
X_15504_ _06760_ _06761_ _06762_ VPWR VGND sg13g2_nor2_1
X_19272_ _10339_ net55 _10338_ VPWR VGND sg13g2_nand2_1
X_12716_ _04055_ _04080_ _04081_ VPWR VGND sg13g2_nor2_1
XFILLER_31_623 VPWR VGND sg13g2_fill_2
XFILLER_16_697 VPWR VGND sg13g2_fill_1
X_16484_ _07705_ net415 net827 VPWR VGND sg13g2_nand2_1
X_13696_ _04977_ VPWR _05024_ VGND _04934_ _04975_ sg13g2_o21ai_1
X_18223_ _09333_ _09331_ _09332_ VPWR VGND sg13g2_nand2b_1
X_15435_ _06684_ _06698_ _06699_ VPWR VGND sg13g2_nor2b_1
X_12647_ net540 VPWR _04014_ VGND _04012_ _04013_ sg13g2_o21ai_1
XFILLER_31_678 VPWR VGND sg13g2_fill_2
XFILLER_129_522 VPWR VGND sg13g2_decap_8
X_18154_ net182 _09262_ net670 _09264_ VPWR VGND sg13g2_nand3_1
X_15366_ _06631_ _06603_ _06633_ VPWR VGND sg13g2_xor2_1
XFILLER_7_21 VPWR VGND sg13g2_decap_8
X_12578_ _03948_ _03947_ _03940_ VPWR VGND sg13g2_nand2b_1
XFILLER_50_1058 VPWR VGND sg13g2_fill_2
X_17105_ _08175_ _08260_ _08261_ VPWR VGND sg13g2_nor2b_1
X_14317_ _05616_ _05622_ _05623_ VPWR VGND sg13g2_nor2b_1
X_18085_ _09195_ _09188_ _09193_ VPWR VGND sg13g2_xnor2_1
X_15297_ _06531_ _06565_ _06566_ VPWR VGND sg13g2_nor2b_1
XFILLER_7_362 VPWR VGND sg13g2_decap_8
X_17036_ _08192_ _08187_ _08190_ VPWR VGND sg13g2_xnor2_1
X_14248_ _05556_ _05525_ _05555_ VPWR VGND sg13g2_xnor2_1
XFILLER_116_249 VPWR VGND sg13g2_decap_4
XFILLER_132_709 VPWR VGND sg13g2_decap_8
XFILLER_131_208 VPWR VGND sg13g2_decap_8
X_14179_ _05488_ _05452_ _05455_ VPWR VGND sg13g2_nand2_1
Xfanout809 net816 net809 VPWR VGND sg13g2_buf_1
XFILLER_3_590 VPWR VGND sg13g2_decap_8
X_18987_ _10051_ _10073_ _10074_ VPWR VGND sg13g2_and2_1
X_17938_ net77 VPWR _09071_ VGND u_LMS.w\[1\]\[19\] u_LMS.w\[1\]\[18\] sg13g2_o21ai_1
XFILLER_39_723 VPWR VGND sg13g2_decap_4
XFILLER_38_200 VPWR VGND sg13g2_fill_2
XFILLER_16_0 VPWR VGND sg13g2_decap_4
X_23725__1343 VPWR VGND net1342 sg13g2_tiehi
X_17869_ _09002_ _08944_ _08945_ VPWR VGND sg13g2_xnor2_1
XFILLER_66_575 VPWR VGND sg13g2_fill_2
XFILLER_27_929 VPWR VGND sg13g2_decap_8
X_19608_ _10672_ _10662_ _10663_ VPWR VGND sg13g2_xnor2_1
X_20880_ _01473_ _01472_ _01520_ VPWR VGND sg13g2_nor2b_1
XFILLER_53_247 VPWR VGND sg13g2_fill_2
XFILLER_35_951 VPWR VGND sg13g2_decap_4
X_19539_ _10602_ _10571_ _10603_ VPWR VGND sg13g2_xor2_1
XFILLER_50_921 VPWR VGND sg13g2_fill_1
X_22550_ net950 VPWR _03032_ VGND u_LMS.count\[17\] _03030_ sg13g2_o21ai_1
XFILLER_50_943 VPWR VGND sg13g2_fill_1
X_21501_ VGND VPWR _01995_ _02009_ _02118_ _02008_ sg13g2_a21oi_1
XFILLER_10_818 VPWR VGND sg13g2_decap_8
X_22481_ net960 VPWR _02990_ VGND net446 net593 sg13g2_o21ai_1
X_21432_ _02049_ _02040_ _02047_ VPWR VGND sg13g2_xnor2_1
XFILLER_21_199 VPWR VGND sg13g2_decap_4
XFILLER_107_216 VPWR VGND sg13g2_fill_1
X_21363_ _01980_ _01970_ _01979_ VPWR VGND sg13g2_xnor2_1
X_23102_ net1053 VGND VPWR _00164_ u_FIR.sum\[6\]\[7\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
X_20314_ u_LMS.w\[5\]\[16\] _00976_ _00977_ VPWR VGND sg13g2_and2_1
X_21294_ _01911_ _01870_ _01877_ VPWR VGND sg13g2_xnor2_1
X_23033_ net1156 VGND VPWR _00095_ u_FIR.sum\[2\]\[14\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
X_20245_ _00908_ _00896_ _00898_ VPWR VGND sg13g2_xnor2_1
XFILLER_66_1043 VPWR VGND sg13g2_fill_1
XFILLER_107_44 VPWR VGND sg13g2_decap_8
XFILLER_88_111 VPWR VGND sg13g2_decap_8
X_23141__1578 VPWR VGND net1577 sg13g2_tiehi
XFILLER_103_455 VPWR VGND sg13g2_fill_2
X_20176_ _00839_ _11194_ _11196_ VPWR VGND sg13g2_xnor2_1
XFILLER_130_241 VPWR VGND sg13g2_decap_8
XFILLER_103_477 VPWR VGND sg13g2_decap_8
XFILLER_88_166 VPWR VGND sg13g2_fill_1
XFILLER_76_339 VPWR VGND sg13g2_fill_2
XFILLER_29_222 VPWR VGND sg13g2_decap_8
XFILLER_123_21 VPWR VGND sg13g2_decap_8
XFILLER_29_233 VPWR VGND sg13g2_fill_2
X_23156__1556 VPWR VGND net1555 sg13g2_tiehi
XFILLER_83_25 VPWR VGND sg13g2_fill_2
X_11880_ VPWR _03301_ u_LMS.w\[7\]\[24\] VGND sg13g2_inv_1
XFILLER_72_556 VPWR VGND sg13g2_fill_2
X_22817_ VGND VPWR _07860_ net346 _00748_ _03126_ sg13g2_a21oi_1
X_13550_ _04882_ _04854_ _04881_ VPWR VGND sg13g2_nand2_1
X_22748_ u_debug_unit.mon_w2_sync\[4\] net329 _03092_ VPWR VGND sg13g2_nor2_1
X_12501_ _03876_ _03832_ _03874_ VPWR VGND sg13g2_xnor2_1
X_13481_ VGND VPWR net755 net893 _04816_ u_FIR.sum\[2\]\[1\] sg13g2_a21oi_1
X_22679_ coeff_force_packed\[47\] net463 _03067_ _00669_ VPWR VGND sg13g2_mux2_1
X_15220_ _06489_ _06490_ _00165_ VPWR VGND sg13g2_nor2_1
X_12432_ _03809_ _03802_ _03807_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_159 VPWR VGND sg13g2_decap_4
XFILLER_120_0 VPWR VGND sg13g2_decap_8
X_15151_ _06423_ _06417_ _06421_ VPWR VGND sg13g2_xnor2_1
X_12363_ _03742_ _03715_ _03741_ VPWR VGND sg13g2_nand2_1
X_14102_ _05413_ _05412_ _05409_ VPWR VGND sg13g2_nand2b_1
X_15082_ net833 u_FIR.sum\[5\]\[5\] net783 _06356_ VPWR VGND sg13g2_nand3_1
XFILLER_10_1042 VPWR VGND sg13g2_decap_8
X_12294_ _03675_ _03643_ _03674_ VPWR VGND sg13g2_nand2_1
XFILLER_5_866 VPWR VGND sg13g2_fill_1
X_18910_ _09997_ _09995_ _09996_ VPWR VGND sg13g2_xnor2_1
X_14033_ _05346_ net762 net878 VPWR VGND sg13g2_nand2_1
XFILLER_106_271 VPWR VGND sg13g2_decap_8
X_19890_ _10931_ _10932_ _00393_ VPWR VGND sg13g2_nor2_1
XFILLER_4_398 VPWR VGND sg13g2_decap_8
XFILLER_106_282 VPWR VGND sg13g2_fill_1
X_18841_ _09928_ _09887_ _09894_ VPWR VGND sg13g2_xnor2_1
XFILLER_110_904 VPWR VGND sg13g2_decap_8
XFILLER_122_797 VPWR VGND sg13g2_fill_1
XFILLER_110_948 VPWR VGND sg13g2_decap_8
X_18772_ _09858_ _09773_ _09859_ VPWR VGND sg13g2_xor2_1
X_15984_ _07226_ _07202_ _07215_ VPWR VGND sg13g2_nand2_1
XFILLER_79_199 VPWR VGND sg13g2_fill_2
XFILLER_48_520 VPWR VGND sg13g2_fill_2
X_17723_ _08856_ _08826_ _08827_ VPWR VGND sg13g2_xnor2_1
X_14935_ VGND VPWR net509 _06216_ _00153_ _06217_ sg13g2_a21oi_1
XFILLER_76_884 VPWR VGND sg13g2_fill_1
X_17654_ _08785_ _08784_ _08787_ VPWR VGND sg13g2_xor2_1
XFILLER_75_383 VPWR VGND sg13g2_fill_2
X_14866_ VGND VPWR _06120_ _06143_ _06151_ _06142_ sg13g2_a21oi_1
XFILLER_90_320 VPWR VGND sg13g2_fill_1
XFILLER_35_236 VPWR VGND sg13g2_fill_2
X_16605_ net1022 VPWR _07796_ VGND net515 net765 sg13g2_o21ai_1
X_13817_ _05120_ _05141_ _05142_ VPWR VGND sg13g2_nor2b_1
X_17585_ _08708_ VPWR _08718_ VGND _08709_ _08717_ sg13g2_o21ai_1
X_14797_ VGND VPWR net508 _06083_ _00148_ _06084_ sg13g2_a21oi_1
XFILLER_50_217 VPWR VGND sg13g2_decap_8
X_19324_ VGND VPWR _10363_ _10366_ _10388_ net118 sg13g2_a21oi_1
X_16536_ net975 VPWR _07744_ VGND net479 net786 sg13g2_o21ai_1
X_13748_ _05073_ _05041_ _05075_ VPWR VGND sg13g2_xor2_1
XFILLER_32_943 VPWR VGND sg13g2_fill_2
X_19255_ VGND VPWR _10266_ _10326_ _10327_ _10319_ sg13g2_a21oi_1
X_16467_ VGND VPWR _07692_ _07693_ _00209_ net938 sg13g2_a21oi_1
XFILLER_32_987 VPWR VGND sg13g2_decap_4
X_13679_ _03363_ net879 _05007_ VPWR VGND sg13g2_nor2_1
X_18206_ _09314_ net120 _09316_ VPWR VGND sg13g2_xor2_1
X_15418_ VGND VPWR net500 _06681_ _00171_ _06682_ sg13g2_a21oi_1
XFILLER_129_330 VPWR VGND sg13g2_decap_4
X_19186_ net30 VPWR _10272_ VGND net28 _10271_ sg13g2_o21ai_1
X_16398_ u_FIR.sum\[7\]\[15\] net387 _07629_ VPWR VGND sg13g2_and2_1
X_18137_ _09245_ _09246_ _09247_ VPWR VGND sg13g2_and2_1
X_15349_ _06616_ _06608_ _06614_ VPWR VGND sg13g2_xnor2_1
XFILLER_117_525 VPWR VGND sg13g2_decap_8
XFILLER_8_693 VPWR VGND sg13g2_decap_4
X_18068_ _09177_ _09175_ _09174_ _09178_ VPWR VGND sg13g2_a21o_1
X_17019_ _08175_ u_LMS.x_r\[0\]\[5\] net263 VPWR VGND sg13g2_nand2_1
XFILLER_125_591 VPWR VGND sg13g2_decap_8
Xfanout606 net607 net606 VPWR VGND sg13g2_buf_1
X_20030_ net113 _11070_ net629 _11071_ VPWR VGND sg13g2_nand3_1
Xfanout617 u_LMS.x_r\[6\]\[2\] net617 VPWR VGND sg13g2_buf_1
Xfanout628 u_LMS.x_r\[5\]\[4\] net628 VPWR VGND sg13g2_buf_1
Xfanout639 net640 net639 VPWR VGND sg13g2_buf_1
XFILLER_58_306 VPWR VGND sg13g2_decap_8
XFILLER_100_414 VPWR VGND sg13g2_fill_2
XFILLER_101_937 VPWR VGND sg13g2_fill_2
XFILLER_26_1060 VPWR VGND sg13g2_fill_1
XFILLER_67_862 VPWR VGND sg13g2_fill_2
X_21981_ _02573_ _02564_ _02575_ VPWR VGND sg13g2_xor2_1
XFILLER_39_575 VPWR VGND sg13g2_decap_4
XFILLER_82_810 VPWR VGND sg13g2_fill_2
X_23720_ net1382 VGND VPWR _00782_ u_s2p_input.reg_sh\[1\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
XFILLER_26_203 VPWR VGND sg13g2_decap_4
X_20932_ u_LMS.w\[6\]\[15\] _01571_ _01572_ VPWR VGND sg13g2_and2_1
X_23651_ net982 VGND VPWR _00713_ u_debug_unit.mon_w2_sync\[3\] clknet_leaf_51_clkA
+ sg13g2_dfrbpq_1
XFILLER_42_707 VPWR VGND sg13g2_fill_1
X_20863_ _01501_ _01455_ _01503_ VPWR VGND sg13g2_xor2_1
XFILLER_26_269 VPWR VGND sg13g2_decap_8
XFILLER_54_589 VPWR VGND sg13g2_fill_1
XFILLER_42_729 VPWR VGND sg13g2_decap_8
X_23152__1562 VPWR VGND net1561 sg13g2_tiehi
X_22602_ net472 net568 _03059_ _00600_ VPWR VGND sg13g2_mux2_1
XFILLER_23_921 VPWR VGND sg13g2_decap_8
X_23582_ net954 VGND VPWR _00644_ coeff_force_packed\[25\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
X_20794_ _01433_ _01404_ _01434_ VPWR VGND sg13g2_xor2_1
XFILLER_22_431 VPWR VGND sg13g2_fill_1
XFILLER_50_751 VPWR VGND sg13g2_fill_2
X_22533_ VGND VPWR u_LMS.count\[10\] _03019_ _03021_ u_LMS.count\[11\] sg13g2_a21oi_1
XFILLER_10_604 VPWR VGND sg13g2_fill_2
XFILLER_10_637 VPWR VGND sg13g2_fill_1
X_22464_ VGND VPWR net449 _03237_ _00540_ _02981_ sg13g2_a21oi_1
XFILLER_10_659 VPWR VGND sg13g2_fill_2
XFILLER_120_1001 VPWR VGND sg13g2_decap_8
X_21415_ _02032_ _01954_ _01966_ VPWR VGND sg13g2_xnor2_1
X_22395_ net947 VPWR _02947_ VGND net433 net677 sg13g2_o21ai_1
X_21346_ _01962_ _01957_ _01963_ VPWR VGND sg13g2_nor2b_1
XFILLER_1_302 VPWR VGND sg13g2_decap_4
XFILLER_118_76 VPWR VGND sg13g2_fill_1
X_21277_ _01894_ _01884_ _01890_ VPWR VGND sg13g2_xnor2_1
XFILLER_89_431 VPWR VGND sg13g2_fill_1
XFILLER_78_58 VPWR VGND sg13g2_decap_8
X_23016_ net1182 VGND VPWR _00078_ u_FIR.sum\[1\]\[13\] clknet_leaf_29_clkA sg13g2_dfrbpq_1
X_20228_ net632 net247 net630 _00891_ VPWR VGND net264 sg13g2_nand4_1
XFILLER_89_453 VPWR VGND sg13g2_decap_8
XFILLER_104_764 VPWR VGND sg13g2_decap_4
XFILLER_131_561 VPWR VGND sg13g2_decap_8
XFILLER_1_379 VPWR VGND sg13g2_decap_4
XFILLER_103_263 VPWR VGND sg13g2_decap_8
XFILLER_103_274 VPWR VGND sg13g2_fill_2
Xrebuffer1670 _09551_ net1669 VPWR VGND sg13g2_buf_2
X_20159_ _00820_ _00819_ _00822_ VPWR VGND sg13g2_xor2_1
XFILLER_58_840 VPWR VGND sg13g2_decap_8
XFILLER_94_35 VPWR VGND sg13g2_decap_8
X_12981_ VGND VPWR net546 _04337_ _00078_ _04338_ sg13g2_a21oi_1
XFILLER_76_169 VPWR VGND sg13g2_decap_8
XFILLER_85_670 VPWR VGND sg13g2_fill_2
X_14720_ VGND VPWR _05989_ _05996_ _06009_ _05988_ sg13g2_a21oi_1
XFILLER_73_832 VPWR VGND sg13g2_decap_8
X_11932_ VPWR _03353_ u_LMS.w\[0\]\[24\] VGND sg13g2_inv_1
XFILLER_45_534 VPWR VGND sg13g2_decap_4
XFILLER_72_320 VPWR VGND sg13g2_decap_8
XFILLER_73_854 VPWR VGND sg13g2_decap_8
XFILLER_27_62 VPWR VGND sg13g2_decap_8
XFILLER_17_247 VPWR VGND sg13g2_fill_2
XFILLER_17_258 VPWR VGND sg13g2_fill_2
X_14651_ _05941_ _05900_ _05942_ VPWR VGND sg13g2_xor2_1
X_11863_ VPWR _03284_ u_LMS.x\[6\] VGND sg13g2_inv_1
XFILLER_45_578 VPWR VGND sg13g2_decap_8
XFILLER_45_589 VPWR VGND sg13g2_fill_2
XFILLER_26_781 VPWR VGND sg13g2_decap_8
X_13602_ _04932_ _04890_ _04931_ VPWR VGND sg13g2_xnor2_1
XFILLER_72_397 VPWR VGND sg13g2_fill_1
X_17370_ VGND VPWR _08519_ _08520_ _00285_ net934 sg13g2_a21oi_1
X_14582_ _05874_ _05871_ _05875_ VPWR VGND sg13g2_xor2_1
X_11794_ VPWR _03215_ u_LMS.count\[9\] VGND sg13g2_inv_1
XFILLER_14_965 VPWR VGND sg13g2_decap_8
X_16321_ _03375_ net819 _07555_ VPWR VGND sg13g2_nor2_1
X_13533_ _04863_ _04845_ _04865_ VPWR VGND sg13g2_xor2_1
XFILLER_43_61 VPWR VGND sg13g2_decap_4
X_23345__1257 VPWR VGND net1256 sg13g2_tiehi
X_19040_ _10116_ VPWR _10127_ VGND _10125_ _10126_ sg13g2_o21ai_1
XFILLER_40_272 VPWR VGND sg13g2_decap_8
X_16252_ _07488_ net795 net819 VPWR VGND sg13g2_nand2_1
X_13464_ _04803_ _04797_ _04800_ VPWR VGND sg13g2_nand2_1
XFILLER_127_812 VPWR VGND sg13g2_decap_8
X_15203_ _06427_ VPWR _06474_ VGND _06384_ _06425_ sg13g2_o21ai_1
X_12415_ VPWR _03792_ _03791_ VGND sg13g2_inv_1
X_16183_ _07414_ _07420_ _07421_ VPWR VGND sg13g2_nor2b_1
X_13395_ VGND VPWR net544 _04736_ _00093_ _04737_ sg13g2_a21oi_1
X_15134_ _06407_ _06367_ _06370_ _06406_ VPWR VGND sg13g2_and3_1
X_12346_ net895 net718 _03725_ VPWR VGND sg13g2_nor2b_1
XFILLER_126_344 VPWR VGND sg13g2_decap_8
XFILLER_5_652 VPWR VGND sg13g2_decap_4
X_19942_ _10952_ VPWR _10983_ VGND _03240_ _10959_ sg13g2_o21ai_1
X_15065_ _06339_ net776 net889 VPWR VGND sg13g2_nand2_1
X_12277_ _03658_ net722 net866 VPWR VGND sg13g2_nand2_1
XFILLER_99_239 VPWR VGND sg13g2_decap_8
XFILLER_5_696 VPWR VGND sg13g2_fill_1
X_14016_ VGND VPWR _05330_ _05329_ _05305_ sg13g2_or2_1
X_19873_ net358 VPWR _10920_ VGND u_LMS.w\[4\]\[6\] net373 sg13g2_o21ai_1
XFILLER_4_77 VPWR VGND sg13g2_decap_8
X_23445__1597 VPWR VGND net1596 sg13g2_tiehi
X_18824_ _09911_ _09901_ _09907_ VPWR VGND sg13g2_xnor2_1
XFILLER_95_434 VPWR VGND sg13g2_decap_4
XFILLER_110_767 VPWR VGND sg13g2_fill_2
X_18755_ VGND VPWR _09842_ _09841_ _09840_ sg13g2_or2_1
XFILLER_55_309 VPWR VGND sg13g2_fill_2
X_15967_ _07208_ _07186_ _07210_ VPWR VGND sg13g2_xor2_1
X_17706_ _08839_ _08799_ _08806_ VPWR VGND sg13g2_xnor2_1
X_14918_ _06201_ u_FIR.sum\[4\]\[15\] net396 VPWR VGND sg13g2_xnor2_1
XFILLER_76_692 VPWR VGND sg13g2_decap_8
X_18686_ _09773_ net662 net145 VPWR VGND sg13g2_nand2_1
XFILLER_82_139 VPWR VGND sg13g2_decap_4
XFILLER_48_394 VPWR VGND sg13g2_fill_2
X_15898_ net1001 VPWR _07145_ VGND net498 u_FIR.sum\[7\]\[13\] sg13g2_o21ai_1
XFILLER_75_191 VPWR VGND sg13g2_fill_1
X_17637_ _08768_ _08767_ _08770_ VPWR VGND sg13g2_xor2_1
X_14849_ _06135_ u_FIR.sum\[4\]\[12\] net397 VPWR VGND sg13g2_nand2_1
XFILLER_63_375 VPWR VGND sg13g2_decap_4
XFILLER_36_589 VPWR VGND sg13g2_decap_4
XFILLER_24_729 VPWR VGND sg13g2_decap_8
XFILLER_23_217 VPWR VGND sg13g2_decap_8
X_17568_ net419 _03268_ _08068_ net202 _08701_ VPWR VGND sg13g2_nor4_1
X_23114__1619 VPWR VGND net1618 sg13g2_tiehi
X_19307_ _10360_ VPWR _10371_ VGND _10362_ _10369_ sg13g2_o21ai_1
X_16519_ u_LMS.w\[1\]\[24\] u_LMS.w\[1\]\[23\] u_LMS.w\[1\]\[22\] u_LMS.w\[1\]\[21\]
+ _07731_ VPWR VGND sg13g2_nor4_1
X_17499_ VPWR _08632_ _08631_ VGND sg13g2_inv_1
XFILLER_17_1048 VPWR VGND sg13g2_decap_8
XFILLER_83_0 VPWR VGND sg13g2_decap_4
XFILLER_17_1059 VPWR VGND sg13g2_fill_2
X_19238_ VGND VPWR _10312_ _10313_ _00360_ net922 sg13g2_a21oi_1
XFILLER_20_946 VPWR VGND sg13g2_fill_1
XFILLER_118_812 VPWR VGND sg13g2_decap_8
X_19169_ VGND VPWR _10256_ _10255_ _10254_ sg13g2_or2_1
XFILLER_118_834 VPWR VGND sg13g2_decap_8
X_21200_ _01817_ _01794_ _01815_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_193 VPWR VGND sg13g2_decap_8
XFILLER_117_344 VPWR VGND sg13g2_decap_8
X_22180_ _02774_ u_LMS.w\[8\]\[9\] _02773_ VPWR VGND sg13g2_nand2_1
XFILLER_117_377 VPWR VGND sg13g2_fill_1
X_21131_ _01748_ net591 net131 VPWR VGND sg13g2_nand2_1
X_21062_ net969 VPWR _01694_ VGND u_LMS.w\[6\]\[20\] _08501_ sg13g2_o21ai_1
Xfanout403 net404 net403 VPWR VGND sg13g2_buf_1
Xfanout414 net415 net414 VPWR VGND sg13g2_buf_1
XFILLER_87_913 VPWR VGND sg13g2_fill_1
XFILLER_63_1024 VPWR VGND sg13g2_decap_4
Xfanout425 _03235_ net425 VPWR VGND sg13g2_buf_1
Xfanout436 net437 net436 VPWR VGND sg13g2_buf_1
XFILLER_87_935 VPWR VGND sg13g2_decap_4
XFILLER_113_572 VPWR VGND sg13g2_fill_2
X_20013_ _11052_ _11051_ _11054_ VPWR VGND sg13g2_xor2_1
XFILLER_63_1057 VPWR VGND sg13g2_decap_4
XFILLER_48_39 VPWR VGND sg13g2_fill_1
Xfanout447 net448 net447 VPWR VGND sg13g2_buf_1
Xfanout458 net459 net458 VPWR VGND sg13g2_buf_1
Xfanout469 spi_wdata\[2\] net469 VPWR VGND sg13g2_buf_1
XFILLER_87_968 VPWR VGND sg13g2_decap_8
XFILLER_46_309 VPWR VGND sg13g2_fill_1
XFILLER_39_361 VPWR VGND sg13g2_fill_1
XFILLER_27_512 VPWR VGND sg13g2_decap_8
XFILLER_73_128 VPWR VGND sg13g2_decap_8
XFILLER_39_383 VPWR VGND sg13g2_decap_8
XFILLER_27_523 VPWR VGND sg13g2_fill_1
X_21964_ _02558_ _03217_ _02556_ VPWR VGND sg13g2_xnor2_1
XFILLER_27_556 VPWR VGND sg13g2_fill_1
X_20915_ _01555_ _01198_ _01554_ VPWR VGND sg13g2_xnor2_1
X_23703_ net1495 VGND VPWR _00765_ u_p2s_output.reg_sh\[4\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
XFILLER_15_718 VPWR VGND sg13g2_decap_8
X_21895_ _02489_ _02479_ _02485_ VPWR VGND sg13g2_xnor2_1
XFILLER_70_835 VPWR VGND sg13g2_fill_1
X_23634_ net987 VGND VPWR _00696_ u_debug_unit.mon_w0_sync\[0\] clknet_leaf_54_clkA
+ sg13g2_dfrbpq_1
X_20846_ _01485_ _01483_ _01486_ VPWR VGND sg13g2_xor2_1
Xfanout10 net10 _02304_ VPWR VGND sg13g2_buf_4
Xfanout21 _01073_ net21 VPWR VGND sg13g2_buf_1
XFILLER_23_751 VPWR VGND sg13g2_fill_1
Xfanout32 _09728_ net32 VPWR VGND sg13g2_buf_1
X_23565_ net953 VGND VPWR _00627_ coeff_force_packed\[10\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
Xfanout43 _08498_ net43 VPWR VGND sg13g2_buf_2
XFILLER_120_77 VPWR VGND sg13g2_decap_4
X_20777_ _01417_ _03227_ _01385_ VPWR VGND sg13g2_xnor2_1
Xfanout54 _10850_ net54 VPWR VGND sg13g2_buf_2
XFILLER_22_250 VPWR VGND sg13g2_fill_2
Xfanout65 net66 net65 VPWR VGND sg13g2_buf_2
XFILLER_22_261 VPWR VGND sg13g2_fill_2
Xfanout76 net2125 net76 VPWR VGND sg13g2_buf_8
XFILLER_10_423 VPWR VGND sg13g2_decap_4
X_22516_ _03000_ _03009_ _03010_ _00563_ VPWR VGND sg13g2_nor3_1
Xfanout87 net87 net88 VPWR VGND sg13g2_buf_4
XFILLER_13_31 VPWR VGND sg13g2_fill_1
XFILLER_11_957 VPWR VGND sg13g2_decap_8
X_23496_ net1426 VGND VPWR _00558_ u_LMS.x_r\[8\]\[7\] clknet_leaf_7_clkA sg13g2_dfrbpq_1
Xfanout98 net105 net98 VPWR VGND sg13g2_buf_2
XFILLER_7_939 VPWR VGND sg13g2_decap_4
X_22447_ net959 VPWR _02973_ VGND net444 net626 sg13g2_o21ai_1
XFILLER_129_42 VPWR VGND sg13g2_decap_8
X_12200_ u_LMS.count\[18\] u_LMS.count\[17\] _03585_ _03587_ _03588_ VPWR VGND sg13g2_nor4_1
X_13180_ _04528_ _04520_ _04527_ VPWR VGND sg13g2_xnor2_1
X_22378_ VGND VPWR net452 _03280_ _00497_ _02938_ sg13g2_a21oi_1
X_12131_ _03541_ _03440_ u_debug_unit.sw_reset\[1\] _03418_ u_debug_unit.mon_w2_sync\[1\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_123_314 VPWR VGND sg13g2_decap_4
X_21329_ _01946_ net596 net189 VPWR VGND sg13g2_nand2_1
X_12062_ VGND VPWR u_debug_unit.mon_w5_sync\[5\] _03405_ _03476_ _03385_ sg13g2_a21oi_1
XFILLER_1_154 VPWR VGND sg13g2_decap_4
XFILLER_132_881 VPWR VGND sg13g2_decap_4
XFILLER_104_583 VPWR VGND sg13g2_decap_8
X_16870_ VGND VPWR _07993_ _08003_ _08026_ net122 sg13g2_a21oi_1
Xfanout970 net1043 net970 VPWR VGND sg13g2_buf_1
XFILLER_93_905 VPWR VGND sg13g2_decap_4
Xfanout981 net985 net981 VPWR VGND sg13g2_buf_1
X_15821_ _07070_ u_FIR.sum\[6\]\[11\] net391 VPWR VGND sg13g2_nand2_1
XFILLER_65_607 VPWR VGND sg13g2_decap_4
Xfanout992 net993 net992 VPWR VGND sg13g2_buf_1
XFILLER_64_106 VPWR VGND sg13g2_fill_1
X_18540_ _09650_ _09649_ _09594_ VPWR VGND sg13g2_nand2b_1
XFILLER_92_437 VPWR VGND sg13g2_fill_1
X_15752_ _07003_ _06961_ _07001_ VPWR VGND sg13g2_xnor2_1
X_12964_ _04320_ _04217_ _04322_ VPWR VGND sg13g2_xor2_1
X_23233__1422 VPWR VGND net1421 sg13g2_tiehi
XFILLER_57_191 VPWR VGND sg13g2_decap_8
XFILLER_46_865 VPWR VGND sg13g2_fill_1
X_14703_ _05993_ u_FIR.sum\[4\]\[8\] net398 VPWR VGND sg13g2_xnor2_1
XFILLER_46_876 VPWR VGND sg13g2_decap_8
X_18471_ _09581_ _09572_ _09580_ VPWR VGND sg13g2_xnor2_1
X_11915_ VPWR _03336_ u_LMS.w\[2\]\[10\] VGND sg13g2_inv_1
XFILLER_61_813 VPWR VGND sg13g2_fill_1
X_15683_ VGND VPWR net483 _06934_ _00183_ _06935_ sg13g2_a21oi_1
X_12895_ _04255_ u_FIR.w\[7\]\[4\] net814 VPWR VGND sg13g2_nand2_1
X_17422_ _08439_ _08438_ _08562_ VPWR VGND sg13g2_xor2_1
X_14634_ net1005 VPWR _05926_ VGND net505 u_FIR.sum\[5\]\[6\] sg13g2_o21ai_1
X_11846_ VPWR _03267_ net685 VGND sg13g2_inv_1
XFILLER_61_879 VPWR VGND sg13g2_decap_4
XFILLER_60_356 VPWR VGND sg13g2_fill_1
X_17353_ net46 VPWR _08507_ VGND net44 _08506_ sg13g2_o21ai_1
X_14565_ _05858_ net903 net768 net891 net769 VPWR VGND sg13g2_a22oi_1
XFILLER_60_378 VPWR VGND sg13g2_decap_8
X_16304_ _07532_ _07538_ _07539_ VPWR VGND sg13g2_nor2b_1
X_13516_ _04849_ _04848_ _04844_ VPWR VGND sg13g2_nand2b_1
X_17284_ _08438_ _08439_ _08440_ VPWR VGND sg13g2_nor2_1
X_14496_ VGND VPWR _05788_ _05790_ _05792_ _05780_ sg13g2_a21oi_1
X_19023_ _10110_ net668 net239 VPWR VGND sg13g2_nand2_1
XFILLER_9_265 VPWR VGND sg13g2_fill_2
X_16235_ _07444_ _07471_ _07472_ VPWR VGND sg13g2_nor2b_1
X_13447_ _04691_ u_FIR.sum\[1\]\[15\] _04787_ VPWR VGND sg13g2_nor2b_1
Xclkload13 clknet_4_15_0_clkA clkload13/X VPWR VGND sg13g2_buf_8
XFILLER_127_631 VPWR VGND sg13g2_decap_8
Xclkload24 VPWR clkload24/Y clknet_leaf_44_clkA VGND sg13g2_inv_1
Xclkload35 clknet_leaf_15_clkA clkload35/X VPWR VGND sg13g2_buf_8
Xclkload46 clknet_leaf_33_clkA clkload46/Y VPWR VGND sg13g2_inv_4
X_16166_ _07383_ VPWR _07404_ VGND _07384_ _07392_ sg13g2_o21ai_1
X_13378_ _04721_ _04643_ _04720_ VPWR VGND sg13g2_xnor2_1
Xclkload57 VPWR clkload57/Y clknet_3_6__leaf_spi_sclk VGND sg13g2_inv_1
XFILLER_127_686 VPWR VGND sg13g2_decap_4
X_15117_ _06390_ _06382_ _06388_ VPWR VGND sg13g2_xnor2_1
X_12329_ _03709_ _03673_ _03675_ _03708_ VPWR VGND sg13g2_and3_1
X_16097_ _07337_ net796 net845 VPWR VGND sg13g2_nand2_1
XFILLER_5_482 VPWR VGND sg13g2_decap_8
XFILLER_126_196 VPWR VGND sg13g2_decap_8
X_19925_ net425 _03236_ net134 net103 _10966_ VPWR VGND sg13g2_nor4_1
X_15048_ _06323_ _06321_ _06322_ VPWR VGND sg13g2_nand2_1
XFILLER_114_369 VPWR VGND sg13g2_decap_8
XFILLER_96_710 VPWR VGND sg13g2_fill_1
XFILLER_123_892 VPWR VGND sg13g2_decap_8
X_19856_ VGND VPWR net53 _10906_ _10907_ net24 sg13g2_a21oi_1
X_18807_ _09894_ _09888_ _09893_ VPWR VGND sg13g2_xnor2_1
XFILLER_56_618 VPWR VGND sg13g2_fill_2
X_19787_ net321 net53 _10851_ VPWR VGND sg13g2_and2_2
XFILLER_23_1030 VPWR VGND sg13g2_fill_1
X_16999_ VGND VPWR net95 _08153_ _08155_ _08019_ sg13g2_a21oi_1
XFILLER_110_586 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_50_clkA clknet_4_7_0_clkA clknet_leaf_50_clkA VPWR VGND sg13g2_buf_8
XFILLER_83_426 VPWR VGND sg13g2_fill_2
XFILLER_23_1052 VPWR VGND sg13g2_decap_8
X_18738_ _09825_ _09800_ _09824_ VPWR VGND sg13g2_nand2_1
XFILLER_64_640 VPWR VGND sg13g2_decap_4
XFILLER_37_865 VPWR VGND sg13g2_fill_1
X_18669_ VGND VPWR net56 _09756_ _09757_ net32 sg13g2_a21oi_1
XFILLER_64_673 VPWR VGND sg13g2_fill_1
XFILLER_36_375 VPWR VGND sg13g2_decap_8
X_20700_ _03233_ _03234_ net94 _01340_ VGND VPWR net102 sg13g2_nor4_2
X_21680_ _02288_ u_LMS.w\[7\]\[21\] net62 VPWR VGND sg13g2_xnor2_1
XFILLER_24_548 VPWR VGND sg13g2_fill_1
X_20631_ _01263_ _01257_ _01271_ VPWR VGND sg13g2_xor2_1
X_23350_ net1251 VGND VPWR _00412_ u_LMS.w\[5\]\[6\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
X_20562_ _01181_ VPWR _01202_ VGND _01178_ _01182_ sg13g2_o21ai_1
Xclkload7 clknet_4_9_0_clkA clkload7/X VPWR VGND sg13g2_buf_8
X_22301_ VGND VPWR u_LMS.w\[8\]\[21\] net308 _02886_ _02871_ sg13g2_a21oi_1
XFILLER_20_765 VPWR VGND sg13g2_decap_8
X_23281_ net1331 VGND VPWR _00343_ u_LMS.w\[2\]\[6\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
XFILLER_30_1012 VPWR VGND sg13g2_decap_8
X_20493_ _01136_ _01137_ _00413_ VPWR VGND sg13g2_nor2_1
X_22232_ VGND VPWR _02756_ net2170 _02826_ _02825_ sg13g2_a21oi_1
XFILLER_117_130 VPWR VGND sg13g2_decap_8
XFILLER_106_804 VPWR VGND sg13g2_fill_2
XFILLER_118_686 VPWR VGND sg13g2_fill_2
XFILLER_106_837 VPWR VGND sg13g2_fill_1
X_22163_ _02757_ _02733_ _02734_ VPWR VGND sg13g2_xnor2_1
X_21114_ net362 VPWR _01734_ VGND u_LMS.w\[6\]\[9\] net379 sg13g2_o21ai_1
XFILLER_121_818 VPWR VGND sg13g2_fill_2
X_22094_ _02680_ _02687_ _02688_ VPWR VGND sg13g2_nor2b_1
Xfanout200 net201 net200 VPWR VGND sg13g2_buf_1
Xfanout211 net215 net211 VPWR VGND sg13g2_buf_1
Xfanout222 net224 net222 VPWR VGND sg13g2_buf_1
X_21045_ net18 VPWR _01680_ VGND net16 _01679_ sg13g2_o21ai_1
Xfanout233 net234 net233 VPWR VGND sg13g2_buf_1
XFILLER_132_199 VPWR VGND sg13g2_decap_8
XFILLER_120_339 VPWR VGND sg13g2_decap_8
Xfanout244 net248 net244 VPWR VGND sg13g2_buf_1
Xfanout255 net257 net255 VPWR VGND sg13g2_buf_1
XFILLER_59_445 VPWR VGND sg13g2_fill_1
XFILLER_115_44 VPWR VGND sg13g2_fill_2
XFILLER_101_542 VPWR VGND sg13g2_decap_8
XFILLER_101_553 VPWR VGND sg13g2_fill_1
Xfanout266 _07922_ net266 VPWR VGND sg13g2_buf_1
Xfanout277 net278 net277 VPWR VGND sg13g2_buf_1
Xfanout288 _03437_ net288 VPWR VGND sg13g2_buf_1
Xfanout299 _03141_ net299 VPWR VGND sg13g2_buf_1
XFILLER_28_810 VPWR VGND sg13g2_decap_4
XFILLER_28_843 VPWR VGND sg13g2_decap_4
X_22996_ net1212 VGND VPWR _00058_ u_FIR.sum\[0\]\[8\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
XFILLER_39_191 VPWR VGND sg13g2_fill_2
XFILLER_83_971 VPWR VGND sg13g2_decap_8
XFILLER_131_32 VPWR VGND sg13g2_decap_8
X_21947_ _02541_ net582 net167 VPWR VGND sg13g2_nand2_1
XFILLER_82_481 VPWR VGND sg13g2_fill_1
X_12680_ _04046_ _04018_ _04045_ VPWR VGND sg13g2_xnor2_1
X_21878_ _02472_ _02467_ _02470_ VPWR VGND sg13g2_xnor2_1
X_20829_ _01467_ _01468_ _01469_ VPWR VGND sg13g2_nor2_1
X_23617_ net966 VGND VPWR _00679_ u_debug_unit.force_w7\[7\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
X_14350_ _05649_ _05654_ _05655_ VPWR VGND sg13g2_nor2b_1
XFILLER_129_918 VPWR VGND sg13g2_fill_1
XFILLER_11_743 VPWR VGND sg13g2_decap_4
X_23548_ net1011 VGND VPWR _00610_ sys_enable_bus\[2\] clknet_leaf_37_clkA sg13g2_dfrbpq_1
XFILLER_11_765 VPWR VGND sg13g2_decap_8
X_13301_ _04646_ net741 net829 VPWR VGND sg13g2_nand2_1
XFILLER_7_725 VPWR VGND sg13g2_fill_1
X_14281_ _05588_ _05587_ _05547_ VPWR VGND sg13g2_nand2b_1
XFILLER_6_202 VPWR VGND sg13g2_fill_2
X_23479_ net1486 VGND VPWR _00541_ u_LMS.x_r\[6\]\[6\] clknet_leaf_11_clkA sg13g2_dfrbpq_1
X_16020_ _07259_ _07241_ _07261_ VPWR VGND sg13g2_xor2_1
X_13232_ VPWR _04579_ _04578_ VGND sg13g2_inv_1
XFILLER_6_246 VPWR VGND sg13g2_decap_8
XFILLER_40_40 VPWR VGND sg13g2_fill_1
X_13163_ VGND VPWR _04471_ _04474_ _04512_ _04510_ sg13g2_a21oi_1
XFILLER_108_185 VPWR VGND sg13g2_fill_2
XFILLER_124_645 VPWR VGND sg13g2_fill_1
X_23277__1340 VPWR VGND net1339 sg13g2_tiehi
X_12114_ _03525_ net293 coeff_force_packed\[51\] net296 coeff_force_packed\[9\] VPWR
+ VGND sg13g2_a22oi_1
XFILLER_124_678 VPWR VGND sg13g2_decap_4
X_17971_ _09103_ net307 u_LMS.w\[1\]\[13\] coeff_force_packed\[8\] net557 VPWR VGND
+ sg13g2_a22oi_1
X_13094_ _04414_ _04443_ _04444_ VPWR VGND sg13g2_nor2_1
XFILLER_105_870 VPWR VGND sg13g2_fill_2
XFILLER_97_529 VPWR VGND sg13g2_fill_1
XFILLER_3_986 VPWR VGND sg13g2_decap_8
XFILLER_124_689 VPWR VGND sg13g2_fill_1
X_19710_ _10770_ VPWR _10774_ VGND _10771_ _10772_ sg13g2_o21ai_1
X_16922_ _08078_ net708 net112 VPWR VGND sg13g2_nand2_1
X_12045_ _03460_ net287 coeff_force_packed\[34\] net294 debug_load_bus\[6\] VPWR VGND
+ sg13g2_a22oi_1
XFILLER_77_231 VPWR VGND sg13g2_fill_2
XFILLER_78_765 VPWR VGND sg13g2_decap_4
X_19641_ _10699_ _10695_ _10705_ VPWR VGND sg13g2_xor2_1
XFILLER_93_702 VPWR VGND sg13g2_fill_1
X_16853_ net418 _03276_ net134 net102 _08009_ VPWR VGND sg13g2_nor4_1
XFILLER_120_884 VPWR VGND sg13g2_fill_1
XFILLER_66_949 VPWR VGND sg13g2_decap_4
X_15804_ VGND VPWR _07017_ _07045_ _07053_ _07044_ sg13g2_a21oi_1
X_19572_ _03249_ _03250_ net178 net163 _10636_ VPWR VGND sg13g2_nor4_1
XFILLER_37_139 VPWR VGND sg13g2_decap_8
XFILLER_1_56 VPWR VGND sg13g2_decap_8
X_16784_ _07940_ net2127 _07911_ VPWR VGND sg13g2_xnor2_1
XFILLER_93_768 VPWR VGND sg13g2_fill_2
X_13996_ VPWR _05311_ _05310_ VGND sg13g2_inv_1
XFILLER_92_256 VPWR VGND sg13g2_decap_8
XFILLER_46_651 VPWR VGND sg13g2_fill_1
X_18523_ _09633_ _09632_ _09607_ VPWR VGND sg13g2_nand2b_1
XFILLER_80_407 VPWR VGND sg13g2_fill_1
X_15735_ _06986_ _06985_ _06981_ VPWR VGND sg13g2_nand2b_1
X_12947_ _04306_ _04284_ _04304_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_92 VPWR VGND sg13g2_fill_1
XFILLER_45_161 VPWR VGND sg13g2_fill_1
XFILLER_34_824 VPWR VGND sg13g2_decap_4
X_18454_ _09356_ _09563_ _09564_ VPWR VGND sg13g2_nor2b_1
XFILLER_34_857 VPWR VGND sg13g2_decap_8
X_15666_ _06880_ u_FIR.w\[1\]\[6\] _06878_ _06919_ VPWR VGND sg13g2_a21o_1
X_12878_ _04211_ _04238_ _04239_ VPWR VGND sg13g2_nor2b_1
X_17405_ VPWR VGND _08548_ _08524_ _08547_ u_LMS.w\[0\]\[24\] _08549_ net313 sg13g2_a221oi_1
X_14617_ _05909_ net774 net822 u_FIR.sum\[4\]\[6\] VPWR VGND sg13g2_and3_1
XFILLER_60_153 VPWR VGND sg13g2_fill_2
XFILLER_21_518 VPWR VGND sg13g2_fill_1
X_18385_ _09492_ _09491_ _09495_ VPWR VGND sg13g2_xor2_1
X_11829_ VPWR _03250_ net652 VGND sg13g2_inv_1
X_15597_ _06852_ _06822_ _06851_ VPWR VGND sg13g2_nand2b_1
XFILLER_42_890 VPWR VGND sg13g2_fill_2
X_17336_ _08492_ net440 u_LMS.toggle VPWR VGND sg13g2_nand2_1
X_23195__1490 VPWR VGND net1489 sg13g2_tiehi
X_14548_ _05842_ _05804_ _05840_ VPWR VGND sg13g2_xnor2_1
XFILLER_14_1007 VPWR VGND sg13g2_fill_1
X_17267_ _08423_ _08339_ _08342_ VPWR VGND sg13g2_xnor2_1
X_14479_ net902 net773 u_FIR.sum\[4\]\[0\] _05777_ VPWR VGND sg13g2_a21o_1
X_19006_ net663 net239 net661 _10093_ VPWR VGND net253 sg13g2_nand4_1
X_16218_ _07455_ net818 u_FIR.w\[0\]\[3\] net805 net798 VPWR VGND sg13g2_a22oi_1
X_17198_ VGND VPWR _08252_ _08354_ _08352_ _08353_ sg13g2_a21oi_2
XFILLER_128_984 VPWR VGND sg13g2_decap_8
XFILLER_115_612 VPWR VGND sg13g2_decap_8
X_16149_ _07388_ u_FIR.sum\[7\]\[7\] net386 VPWR VGND sg13g2_nand2_1
XFILLER_46_0 VPWR VGND sg13g2_decap_4
XFILLER_130_604 VPWR VGND sg13g2_decap_4
XFILLER_102_306 VPWR VGND sg13g2_fill_1
XFILLER_69_721 VPWR VGND sg13g2_decap_8
XFILLER_130_637 VPWR VGND sg13g2_fill_1
X_19908_ VPWR _10949_ _10948_ VGND sg13g2_inv_1
XFILLER_114_199 VPWR VGND sg13g2_decap_8
XFILLER_111_851 VPWR VGND sg13g2_fill_2
XFILLER_57_905 VPWR VGND sg13g2_fill_1
XFILLER_111_862 VPWR VGND sg13g2_fill_2
XFILLER_111_873 VPWR VGND sg13g2_fill_1
X_19839_ VGND VPWR u_LMS.w\[4\]\[21\] net310 _10894_ _10879_ sg13g2_a21oi_1
XFILLER_60_1049 VPWR VGND sg13g2_decap_8
XFILLER_110_361 VPWR VGND sg13g2_decap_4
XFILLER_69_798 VPWR VGND sg13g2_decap_4
XFILLER_83_212 VPWR VGND sg13g2_fill_2
X_22850_ net922 _03146_ _00761_ VPWR VGND sg13g2_nor2_1
XFILLER_84_768 VPWR VGND sg13g2_fill_1
XFILLER_56_459 VPWR VGND sg13g2_fill_2
X_21801_ _02395_ _02388_ _02394_ VPWR VGND sg13g2_nand2_1
X_23340__1262 VPWR VGND net1261 sg13g2_tiehi
X_22781_ VGND VPWR _03324_ net344 _00730_ _03108_ sg13g2_a21oi_1
XFILLER_37_695 VPWR VGND sg13g2_decap_8
X_21732_ _02327_ _02328_ _00461_ VPWR VGND sg13g2_nor2_1
XFILLER_64_492 VPWR VGND sg13g2_decap_8
XFILLER_36_183 VPWR VGND sg13g2_decap_8
XFILLER_24_367 VPWR VGND sg13g2_fill_2
X_21663_ _02232_ _02273_ _02274_ VPWR VGND sg13g2_and2_1
XFILLER_80_996 VPWR VGND sg13g2_decap_4
XFILLER_40_827 VPWR VGND sg13g2_decap_8
X_20614_ _01171_ _01162_ _01254_ VPWR VGND sg13g2_xor2_1
X_23402_ net1142 VGND VPWR _00464_ u_LMS.w\[8\]\[12\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
X_21594_ _02211_ _03298_ _02174_ VPWR VGND sg13g2_nand2_1
X_23333_ net1268 VGND VPWR _00395_ u_LMS.w\[5\]\[12\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
X_20545_ _01177_ _01184_ _01185_ VPWR VGND sg13g2_and2_1
XFILLER_124_7 VPWR VGND sg13g2_decap_8
XFILLER_119_940 VPWR VGND sg13g2_decap_8
X_23264_ net1365 VGND VPWR _00326_ u_LMS.w\[2\]\[12\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
X_20476_ net363 VPWR _01125_ VGND u_LMS.w\[5\]\[3\] net381 sg13g2_o21ai_1
X_23388__1185 VPWR VGND net1184 sg13g2_tiehi
X_22215_ u_LMS.w\[8\]\[11\] _02769_ _02809_ VPWR VGND sg13g2_nor2_1
XFILLER_118_483 VPWR VGND sg13g2_fill_2
XFILLER_10_21 VPWR VGND sg13g2_decap_8
XFILLER_106_645 VPWR VGND sg13g2_fill_2
X_23195_ net1489 VGND VPWR _00257_ u_FIR.w\[5\]\[5\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
XFILLER_10_43 VPWR VGND sg13g2_decap_4
XFILLER_106_667 VPWR VGND sg13g2_fill_1
XFILLER_126_21 VPWR VGND sg13g2_decap_8
XFILLER_106_678 VPWR VGND sg13g2_decap_4
X_22146_ _02740_ _02738_ _02739_ VPWR VGND sg13g2_nand2_1
XFILLER_117_1006 VPWR VGND sg13g2_fill_1
Xfanout1006 net1008 net1006 VPWR VGND sg13g2_buf_1
X_22077_ VGND VPWR _02669_ _02670_ _02671_ _02668_ sg13g2_a21oi_1
Xfanout1017 net1018 net1017 VPWR VGND sg13g2_buf_1
XFILLER_86_36 VPWR VGND sg13g2_decap_8
Xfanout1028 net1029 net1028 VPWR VGND sg13g2_buf_1
XFILLER_102_851 VPWR VGND sg13g2_decap_8
Xfanout1039 net1041 net1039 VPWR VGND sg13g2_buf_1
XFILLER_0_978 VPWR VGND sg13g2_decap_8
X_21028_ _01667_ net317 u_LMS.w\[6\]\[13\] coeff_force_packed\[43\] net565 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_87_562 VPWR VGND sg13g2_fill_1
XFILLER_101_372 VPWR VGND sg13g2_fill_1
Xclkbuf_leaf_2_clkA clknet_4_2_0_clkA clknet_leaf_2_clkA VPWR VGND sg13g2_buf_8
X_13850_ _05153_ _05173_ _05174_ VPWR VGND sg13g2_nor2b_1
X_12801_ _04131_ _04163_ _04164_ VPWR VGND sg13g2_nor2b_1
XFILLER_34_109 VPWR VGND sg13g2_fill_1
X_13781_ _05099_ _05106_ _05107_ VPWR VGND sg13g2_nor2b_1
XFILLER_56_993 VPWR VGND sg13g2_fill_1
XFILLER_28_684 VPWR VGND sg13g2_decap_8
X_22979_ net1013 VGND VPWR _00041_ u_spi_slave.tx_shift\[9\] net1629 sg13g2_dfrbpq_1
XFILLER_27_161 VPWR VGND sg13g2_fill_1
X_15520_ _06775_ _06764_ _06777_ VPWR VGND sg13g2_xor2_1
X_12732_ net884 _04095_ net730 _04096_ VPWR VGND sg13g2_nand3_1
XFILLER_15_345 VPWR VGND sg13g2_fill_2
XFILLER_15_356 VPWR VGND sg13g2_fill_1
X_15451_ _06714_ _06693_ _06697_ VPWR VGND sg13g2_nand2_1
XFILLER_71_996 VPWR VGND sg13g2_decap_4
X_12663_ _04029_ _04028_ _04024_ VPWR VGND sg13g2_nand2b_1
X_14402_ _05697_ _05704_ _05705_ VPWR VGND sg13g2_nor2b_1
X_18170_ _09278_ _09279_ _09280_ VPWR VGND sg13g2_nor2_1
X_15382_ _06648_ _06639_ _06647_ VPWR VGND sg13g2_xnor2_1
X_12594_ _03963_ _03956_ _03962_ VPWR VGND sg13g2_nand2_1
XFILLER_11_540 VPWR VGND sg13g2_fill_1
X_17121_ VGND VPWR _08264_ _08269_ _08277_ _08268_ sg13g2_a21oi_1
X_14333_ VGND VPWR _05606_ _05610_ _05638_ _05609_ sg13g2_a21oi_1
XFILLER_7_522 VPWR VGND sg13g2_fill_1
XFILLER_11_573 VPWR VGND sg13g2_decap_4
XFILLER_11_595 VPWR VGND sg13g2_decap_8
XFILLER_128_258 VPWR VGND sg13g2_decap_8
X_17052_ VGND VPWR _08196_ _08207_ _08208_ _08195_ sg13g2_a21oi_1
X_14264_ _05571_ _05531_ _05534_ VPWR VGND sg13g2_nand2_1
XFILLER_100_1021 VPWR VGND sg13g2_decap_4
X_16003_ VGND VPWR _07244_ _07243_ _07242_ sg13g2_or2_1
X_13215_ net868 _04561_ net739 _04562_ VPWR VGND sg13g2_nand3_1
X_14195_ _05504_ _05496_ _05502_ VPWR VGND sg13g2_xnor2_1
XFILLER_83_1005 VPWR VGND sg13g2_decap_8
XFILLER_98_816 VPWR VGND sg13g2_decap_4
XFILLER_83_1016 VPWR VGND sg13g2_fill_2
X_13146_ _04494_ _04455_ _04495_ VPWR VGND sg13g2_xor2_1
XFILLER_124_464 VPWR VGND sg13g2_fill_1
XFILLER_98_838 VPWR VGND sg13g2_fill_2
XFILLER_111_103 VPWR VGND sg13g2_decap_4
X_17954_ _09078_ _09080_ _09086_ _09087_ VPWR VGND sg13g2_or3_1
X_13077_ _04427_ _04424_ _04428_ VPWR VGND sg13g2_xor2_1
XFILLER_2_282 VPWR VGND sg13g2_decap_8
X_16905_ _08060_ _08029_ _08061_ VPWR VGND sg13g2_xor2_1
X_12028_ _03442_ _03443_ net328 _03445_ VPWR VGND _03444_ sg13g2_nand4_1
X_17885_ _09004_ _09017_ _09018_ VPWR VGND sg13g2_nor2_1
X_19624_ _10686_ _10672_ _10688_ VPWR VGND sg13g2_xor2_1
X_16836_ VGND VPWR _07992_ _07990_ net124 sg13g2_or2_1
XFILLER_19_651 VPWR VGND sg13g2_fill_1
XFILLER_19_662 VPWR VGND sg13g2_fill_2
X_19555_ _10619_ _10581_ _10592_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_278 VPWR VGND sg13g2_fill_1
X_16767_ _07923_ net914 _07897_ VPWR VGND sg13g2_nand2_1
X_13979_ net997 VPWR _05296_ VGND net492 u_FIR.sum\[4\]\[0\] sg13g2_o21ai_1
XFILLER_65_289 VPWR VGND sg13g2_fill_1
XFILLER_47_993 VPWR VGND sg13g2_decap_8
XFILLER_19_684 VPWR VGND sg13g2_decap_8
X_18506_ u_LMS.w\[2\]\[2\] net253 net683 _09616_ VPWR VGND sg13g2_nand3_1
X_15718_ _06970_ _06969_ _06936_ VPWR VGND sg13g2_nand2b_1
XFILLER_80_248 VPWR VGND sg13g2_decap_8
X_19486_ _10540_ VPWR _10550_ VGND _10509_ _10538_ sg13g2_o21ai_1
X_16698_ VGND VPWR net520 _07862_ _00270_ _07863_ sg13g2_a21oi_1
XFILLER_62_985 VPWR VGND sg13g2_decap_8
X_18437_ _09547_ _09476_ _09477_ VPWR VGND sg13g2_xnor2_1
X_15649_ _06902_ net786 net860 VPWR VGND sg13g2_nand2_1
XFILLER_21_304 VPWR VGND sg13g2_fill_1
XFILLER_33_197 VPWR VGND sg13g2_fill_1
XFILLER_21_348 VPWR VGND sg13g2_fill_1
X_18368_ _09476_ _09477_ _09478_ VPWR VGND sg13g2_nor2b_1
X_17319_ _08474_ VPWR _08475_ VGND _08396_ net2194 sg13g2_o21ai_1
X_18299_ _09409_ net79 net682 net107 net680 VPWR VGND sg13g2_a22oi_1
XFILLER_119_247 VPWR VGND sg13g2_decap_4
X_20330_ _00993_ _00929_ net2132 VPWR VGND sg13g2_xnor2_1
XFILLER_116_910 VPWR VGND sg13g2_fill_2
XFILLER_128_792 VPWR VGND sg13g2_fill_2
X_20261_ _00924_ _00923_ _00890_ VPWR VGND sg13g2_nand2b_1
XFILLER_115_420 VPWR VGND sg13g2_decap_4
X_22000_ _02594_ _02503_ _02504_ VPWR VGND sg13g2_xnor2_1
X_23358__1244 VPWR VGND net1243 sg13g2_tiehi
X_20192_ net636 net192 net172 _00855_ VPWR VGND net633 sg13g2_nand4_1
XFILLER_0_219 VPWR VGND sg13g2_decap_4
XFILLER_88_326 VPWR VGND sg13g2_fill_2
XFILLER_131_946 VPWR VGND sg13g2_decap_8
XFILLER_5_1016 VPWR VGND sg13g2_decap_8
XFILLER_111_681 VPWR VGND sg13g2_decap_4
XFILLER_29_437 VPWR VGND sg13g2_fill_1
X_22902_ VPWR _00780_ _03179_ VGND sg13g2_inv_1
XFILLER_29_448 VPWR VGND sg13g2_fill_1
X_23261__1372 VPWR VGND net1371 sg13g2_tiehi
X_22833_ VGND VPWR _07882_ net341 _00756_ _03134_ sg13g2_a21oi_1
XFILLER_71_215 VPWR VGND sg13g2_decap_8
XFILLER_71_226 VPWR VGND sg13g2_fill_1
XFILLER_53_930 VPWR VGND sg13g2_fill_2
XFILLER_65_790 VPWR VGND sg13g2_decap_8
X_22764_ u_debug_unit.mon_w3_sync\[5\] net337 _03100_ VPWR VGND sg13g2_nor2_1
XFILLER_13_805 VPWR VGND sg13g2_fill_1
XFILLER_80_771 VPWR VGND sg13g2_decap_4
X_21715_ net366 VPWR _02316_ VGND u_LMS.w\[7\]\[5\] net377 sg13g2_o21ai_1
X_22695_ coeff_force_packed\[59\] net466 _03069_ _00683_ VPWR VGND sg13g2_mux2_1
XFILLER_12_315 VPWR VGND sg13g2_decap_4
XFILLER_12_337 VPWR VGND sg13g2_decap_8
X_21646_ VGND VPWR _02259_ _02260_ _00443_ net935 sg13g2_a21oi_1
XFILLER_40_668 VPWR VGND sg13g2_decap_4
XFILLER_40_679 VPWR VGND sg13g2_fill_2
XFILLER_21_860 VPWR VGND sg13g2_decap_8
XFILLER_21_871 VPWR VGND sg13g2_decap_8
X_21577_ _02193_ _02192_ _02194_ VPWR VGND sg13g2_nor2b_1
X_20528_ _01168_ net88 net612 net151 net614 VPWR VGND sg13g2_a22oi_1
X_23316_ net1285 VGND VPWR _00378_ u_LMS.w\[4\]\[18\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
XFILLER_107_910 VPWR VGND sg13g2_decap_4
XFILLER_107_932 VPWR VGND sg13g2_decap_4
XFILLER_119_792 VPWR VGND sg13g2_decap_4
X_20459_ VGND VPWR _01110_ _01111_ _00405_ net937 sg13g2_a21oi_1
X_23247_ net1397 VGND VPWR _00309_ u_LMS.w\[1\]\[18\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
XFILLER_21_86 VPWR VGND sg13g2_decap_4
X_13000_ _04353_ VPWR _04356_ VGND _04339_ _04350_ sg13g2_o21ai_1
X_23178_ net1519 VGND VPWR _00240_ u_FIR.w\[3\]\[2\] clknet_leaf_51_clkA sg13g2_dfrbpq_1
XFILLER_121_401 VPWR VGND sg13g2_fill_2
X_22129_ _02717_ _02722_ _02707_ _02723_ VPWR VGND sg13g2_nand3_1
XFILLER_82_1060 VPWR VGND sg13g2_fill_1
XFILLER_0_775 VPWR VGND sg13g2_fill_1
X_14951_ _06233_ _06218_ _06232_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_489 VPWR VGND sg13g2_fill_1
XFILLER_0_797 VPWR VGND sg13g2_decap_4
XFILLER_130_990 VPWR VGND sg13g2_decap_8
X_13902_ _05211_ _05223_ _05224_ VPWR VGND sg13g2_nor2_1
XFILLER_130_1025 VPWR VGND sg13g2_decap_8
X_17670_ _08803_ net223 net691 net186 net694 VPWR VGND sg13g2_a22oi_1
X_14882_ _06167_ _06166_ _06135_ VPWR VGND sg13g2_nand2b_1
X_16621_ VGND VPWR net517 _07805_ _00250_ _07806_ sg13g2_a21oi_1
XFILLER_75_576 VPWR VGND sg13g2_decap_4
X_13833_ _05157_ u_FIR.w\[5\]\[6\] net409 VPWR VGND sg13g2_nand2_1
XFILLER_62_215 VPWR VGND sg13g2_fill_2
XFILLER_29_993 VPWR VGND sg13g2_decap_8
X_19340_ _10400_ VPWR _10404_ VGND _10401_ _10402_ sg13g2_o21ai_1
X_16552_ VGND VPWR net488 _07755_ _00231_ _07756_ sg13g2_a21oi_1
X_13764_ _03363_ net852 _05090_ VPWR VGND sg13g2_nor2_1
XFILLER_44_974 VPWR VGND sg13g2_fill_1
X_15503_ VGND VPWR _06757_ _06759_ _06761_ _06749_ sg13g2_a21oi_1
X_19271_ _10338_ _10220_ _10222_ VPWR VGND sg13g2_xnor2_1
X_12715_ _04080_ _04070_ _04078_ VPWR VGND sg13g2_xnor2_1
X_16483_ _07704_ u_FIR.x\[6\] net524 VPWR VGND sg13g2_nand2_1
X_13695_ _05023_ _05004_ _05021_ VPWR VGND sg13g2_xnor2_1
XFILLER_71_793 VPWR VGND sg13g2_decap_8
XFILLER_15_175 VPWR VGND sg13g2_fill_2
X_18222_ _09297_ _09295_ _09332_ VPWR VGND sg13g2_xor2_1
X_15434_ _06696_ _06695_ _06698_ VPWR VGND sg13g2_xor2_1
XFILLER_62_60 VPWR VGND sg13g2_fill_2
X_12646_ VGND VPWR _03966_ _03986_ _04013_ _03985_ sg13g2_a21oi_1
XFILLER_30_145 VPWR VGND sg13g2_decap_4
XFILLER_30_167 VPWR VGND sg13g2_fill_2
X_18153_ net421 net420 net176 net217 _09263_ VPWR VGND sg13g2_nor4_1
X_15365_ _06603_ _06631_ _06632_ VPWR VGND sg13g2_nor2b_1
X_12577_ _03945_ _03946_ _03947_ VPWR VGND sg13g2_nor2_1
X_17104_ _08260_ _08254_ _08258_ VPWR VGND sg13g2_xnor2_1
X_14316_ _05622_ _05585_ _05620_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_578 VPWR VGND sg13g2_decap_8
X_18084_ _09194_ _09193_ _09188_ VPWR VGND sg13g2_nand2b_1
XFILLER_8_875 VPWR VGND sg13g2_decap_8
X_15296_ _06563_ _06532_ _06565_ VPWR VGND sg13g2_xor2_1
XFILLER_7_77 VPWR VGND sg13g2_decap_8
XFILLER_116_228 VPWR VGND sg13g2_decap_8
X_17035_ _08191_ _08190_ _08187_ VPWR VGND sg13g2_nand2b_1
X_14247_ _05555_ _05526_ _05553_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_762 VPWR VGND sg13g2_decap_4
X_14178_ VGND VPWR _05449_ _05456_ _05487_ _05463_ sg13g2_a21oi_1
XFILLER_125_795 VPWR VGND sg13g2_decap_4
XFILLER_124_272 VPWR VGND sg13g2_decap_4
XFILLER_112_423 VPWR VGND sg13g2_decap_8
XFILLER_98_646 VPWR VGND sg13g2_fill_2
X_13129_ _04464_ VPWR _04478_ VGND _04459_ _04462_ sg13g2_o21ai_1
XFILLER_97_145 VPWR VGND sg13g2_decap_4
X_18986_ _10050_ VPWR _10073_ VGND _03258_ net159 sg13g2_o21ai_1
XFILLER_100_618 VPWR VGND sg13g2_fill_2
X_17937_ net77 u_LMS.w\[1\]\[19\] _09070_ VPWR VGND sg13g2_xor2_1
XFILLER_78_381 VPWR VGND sg13g2_decap_8
XFILLER_39_746 VPWR VGND sg13g2_fill_1
X_17868_ _09001_ _08924_ _08946_ VPWR VGND sg13g2_xnor2_1
XFILLER_38_245 VPWR VGND sg13g2_fill_2
XFILLER_26_407 VPWR VGND sg13g2_fill_2
X_19607_ _10671_ _10670_ _10669_ VPWR VGND sg13g2_nand2b_1
XFILLER_66_587 VPWR VGND sg13g2_decap_8
XFILLER_4_1060 VPWR VGND sg13g2_fill_1
X_16819_ net126 net2199 net123 _07975_ VPWR VGND sg13g2_or3_1
X_17799_ _03273_ net223 net196 _08928_ _08932_ VPWR VGND sg13g2_nor4_1
X_19538_ _10602_ u_LMS.x_r\[4\]\[4\] net204 VPWR VGND sg13g2_nand2_1
XFILLER_81_579 VPWR VGND sg13g2_decap_4
XFILLER_50_900 VPWR VGND sg13g2_fill_1
XFILLER_35_996 VPWR VGND sg13g2_decap_8
X_19469_ _10533_ net643 net208 VPWR VGND sg13g2_nand2_1
XFILLER_62_793 VPWR VGND sg13g2_decap_8
XFILLER_22_635 VPWR VGND sg13g2_decap_8
X_21500_ _02117_ _02112_ _02116_ VPWR VGND sg13g2_xnor2_1
X_22480_ VGND VPWR net446 _03229_ _00548_ _02989_ sg13g2_a21oi_1
XFILLER_50_977 VPWR VGND sg13g2_decap_4
X_21431_ _02040_ _02047_ _02048_ VPWR VGND sg13g2_nor2b_1
XFILLER_21_178 VPWR VGND sg13g2_decap_4
X_21362_ _01979_ _01974_ _01977_ VPWR VGND sg13g2_xnor2_1
XFILLER_107_239 VPWR VGND sg13g2_decap_8
X_20313_ _00976_ _11058_ _00955_ VPWR VGND sg13g2_xnor2_1
X_23101_ net1054 VGND VPWR _00163_ u_FIR.sum\[6\]\[6\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
X_21293_ _01902_ VPWR _01910_ VGND net2211 _01909_ sg13g2_o21ai_1
XFILLER_116_751 VPWR VGND sg13g2_decap_8
XFILLER_104_902 VPWR VGND sg13g2_fill_2
X_23032_ net1158 VGND VPWR _00094_ u_FIR.sum\[2\]\[13\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
X_20244_ _00907_ _00901_ _00903_ VPWR VGND sg13g2_xnor2_1
XFILLER_131_710 VPWR VGND sg13g2_decap_4
XFILLER_130_220 VPWR VGND sg13g2_decap_8
X_20175_ VGND VPWR _00838_ _00837_ _00836_ sg13g2_or2_1
XFILLER_89_668 VPWR VGND sg13g2_fill_1
XFILLER_88_145 VPWR VGND sg13g2_fill_2
XFILLER_85_830 VPWR VGND sg13g2_fill_1
XFILLER_57_554 VPWR VGND sg13g2_decap_8
XFILLER_123_55 VPWR VGND sg13g2_fill_2
XFILLER_57_587 VPWR VGND sg13g2_decap_8
XFILLER_72_524 VPWR VGND sg13g2_decap_4
XFILLER_57_598 VPWR VGND sg13g2_fill_1
XFILLER_44_215 VPWR VGND sg13g2_decap_8
XFILLER_44_226 VPWR VGND sg13g2_fill_1
XFILLER_16_20 VPWR VGND sg13g2_decap_8
X_22816_ u_debug_unit.mon_w7_sync\[3\] net346 _03126_ VPWR VGND sg13g2_nor2_1
XFILLER_41_922 VPWR VGND sg13g2_decap_8
X_22747_ VGND VPWR _07761_ net334 _00713_ _03091_ sg13g2_a21oi_1
XFILLER_73_1026 VPWR VGND sg13g2_decap_4
X_12500_ VPWR _03875_ _03874_ VGND sg13g2_inv_1
XFILLER_41_955 VPWR VGND sg13g2_fill_2
XFILLER_9_606 VPWR VGND sg13g2_decap_8
X_13480_ _04815_ net755 net893 u_FIR.sum\[2\]\[1\] VPWR VGND sg13g2_and3_1
X_22678_ coeff_force_packed\[46\] net465 _03067_ _00668_ VPWR VGND sg13g2_mux2_1
XFILLER_9_639 VPWR VGND sg13g2_decap_8
X_12431_ _03802_ _03807_ _03808_ VPWR VGND sg13g2_nor2b_1
XFILLER_12_178 VPWR VGND sg13g2_fill_1
X_21629_ net63 VPWR _02246_ VGND u_LMS.w\[7\]\[23\] u_LMS.w\[7\]\[22\] sg13g2_o21ai_1
X_23501__1409 VPWR VGND net1408 sg13g2_tiehi
XFILLER_12_189 VPWR VGND sg13g2_fill_2
X_15150_ _06422_ _06421_ _06417_ VPWR VGND sg13g2_nand2b_1
XFILLER_5_801 VPWR VGND sg13g2_fill_1
X_12362_ _03741_ _03720_ _03740_ VPWR VGND sg13g2_xnor2_1
X_14101_ _05412_ _05372_ _05410_ VPWR VGND sg13g2_xnor2_1
XFILLER_113_0 VPWR VGND sg13g2_decap_4
XFILLER_10_1021 VPWR VGND sg13g2_decap_8
X_15081_ _06314_ _06316_ _06355_ VPWR VGND sg13g2_and2_1
X_12293_ _03674_ _03646_ _03672_ VPWR VGND sg13g2_xnor2_1
XFILLER_4_333 VPWR VGND sg13g2_decap_8
X_14032_ _05345_ net761 net878 VPWR VGND sg13g2_nand2_1
XFILLER_79_112 VPWR VGND sg13g2_fill_2
X_18840_ _09919_ VPWR _09927_ VGND _09925_ _09926_ sg13g2_o21ai_1
XFILLER_121_220 VPWR VGND sg13g2_fill_2
XFILLER_122_754 VPWR VGND sg13g2_decap_8
XFILLER_121_253 VPWR VGND sg13g2_fill_2
X_18771_ _09858_ _09855_ _09856_ VPWR VGND sg13g2_xnor2_1
X_15983_ _07225_ _07220_ _07224_ VPWR VGND sg13g2_xnor2_1
X_17722_ _08851_ _08854_ _08855_ VPWR VGND sg13g2_nor2_1
X_14934_ net1007 VPWR _06217_ VGND net509 u_FIR.sum\[5\]\[15\] sg13g2_o21ai_1
XFILLER_94_159 VPWR VGND sg13g2_fill_2
X_17653_ _08784_ _08785_ _08786_ VPWR VGND sg13g2_nor2_1
X_14865_ _06145_ _06147_ _06150_ VPWR VGND sg13g2_nor2_1
XFILLER_75_395 VPWR VGND sg13g2_decap_4
XFILLER_17_930 VPWR VGND sg13g2_fill_1
X_16604_ VGND VPWR u_LMS.w\[4\]\[12\] _07793_ _07795_ _07794_ sg13g2_a21oi_1
X_13816_ _05141_ _05133_ _05139_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_866 VPWR VGND sg13g2_fill_1
X_17584_ VPWR _08717_ _08716_ VGND sg13g2_inv_1
XFILLER_17_963 VPWR VGND sg13g2_decap_4
X_14796_ net1005 VPWR _06084_ VGND net505 u_FIR.sum\[5\]\[10\] sg13g2_o21ai_1
X_19323_ net153 VPWR _10387_ VGND net650 net652 sg13g2_o21ai_1
XFILLER_91_899 VPWR VGND sg13g2_fill_1
X_16535_ VGND VPWR u_LMS.w\[1\]\[16\] _07733_ _07743_ _07734_ sg13g2_a21oi_1
X_13747_ _05073_ _05041_ _05074_ VPWR VGND sg13g2_nor2b_1
X_19254_ _10326_ _10206_ _10207_ VPWR VGND sg13g2_xnor2_1
X_16466_ _07693_ net413 net908 VPWR VGND sg13g2_nand2_1
X_13678_ _05006_ net750 net852 VPWR VGND sg13g2_nand2_1
XFILLER_31_465 VPWR VGND sg13g2_decap_4
X_18205_ net120 _09314_ _09315_ VPWR VGND sg13g2_nor2b_1
X_15417_ net1002 VPWR _06682_ VGND net500 u_FIR.sum\[6\]\[14\] sg13g2_o21ai_1
X_19185_ _10233_ _10232_ _10271_ VPWR VGND sg13g2_xor2_1
X_12629_ _03994_ _03976_ _03996_ VPWR VGND sg13g2_xor2_1
X_23418__1095 VPWR VGND net1094 sg13g2_tiehi
X_16397_ VGND VPWR _07610_ _07620_ _07628_ _07619_ sg13g2_a21oi_1
XFILLER_106_1060 VPWR VGND sg13g2_fill_1
X_18136_ _09244_ VPWR _09246_ VGND net421 net79 sg13g2_o21ai_1
X_15348_ _06615_ _06614_ _06608_ VPWR VGND sg13g2_nand2b_1
XFILLER_7_160 VPWR VGND sg13g2_fill_1
XFILLER_117_548 VPWR VGND sg13g2_decap_8
X_18067_ _09174_ _09176_ _09177_ VPWR VGND sg13g2_nor2_1
X_15279_ _06548_ _06540_ _06547_ VPWR VGND sg13g2_nand2_1
X_23070__1102 VPWR VGND net1101 sg13g2_tiehi
X_23457__1561 VPWR VGND net1560 sg13g2_tiehi
X_17018_ _08174_ net704 net246 VPWR VGND sg13g2_nand2_1
XFILLER_132_529 VPWR VGND sg13g2_decap_8
XFILLER_125_581 VPWR VGND sg13g2_fill_1
XFILLER_98_432 VPWR VGND sg13g2_decap_8
Xfanout607 u_LMS.x_r\[6\]\[7\] net607 VPWR VGND sg13g2_buf_1
Xfanout618 u_LMS.x_r\[6\]\[1\] net618 VPWR VGND sg13g2_buf_1
XFILLER_59_808 VPWR VGND sg13g2_fill_1
Xfanout629 u_LMS.x_r\[5\]\[3\] net629 VPWR VGND sg13g2_buf_1
X_18969_ _10056_ _10052_ _10054_ VPWR VGND sg13g2_xnor2_1
XFILLER_100_437 VPWR VGND sg13g2_fill_1
XFILLER_39_521 VPWR VGND sg13g2_fill_1
XFILLER_85_137 VPWR VGND sg13g2_decap_8
XFILLER_39_532 VPWR VGND sg13g2_fill_1
X_21980_ _02574_ _02564_ _02573_ VPWR VGND sg13g2_nand2b_1
XFILLER_66_351 VPWR VGND sg13g2_decap_8
XFILLER_27_705 VPWR VGND sg13g2_fill_1
XFILLER_96_1004 VPWR VGND sg13g2_decap_4
XFILLER_67_896 VPWR VGND sg13g2_fill_2
XFILLER_54_513 VPWR VGND sg13g2_fill_1
X_20931_ _01571_ _01537_ _01538_ VPWR VGND sg13g2_xnor2_1
XFILLER_81_332 VPWR VGND sg13g2_fill_2
XFILLER_26_237 VPWR VGND sg13g2_fill_1
XFILLER_54_557 VPWR VGND sg13g2_fill_1
X_20862_ _01502_ net619 net245 VPWR VGND sg13g2_nand2_1
X_23650_ net982 VGND VPWR _00712_ u_debug_unit.mon_w2_sync\[2\] clknet_leaf_52_clkA
+ sg13g2_dfrbpq_1
XFILLER_26_259 VPWR VGND sg13g2_fill_2
X_22601_ _03059_ net429 _03428_ VPWR VGND sg13g2_nand2_1
X_20793_ _01433_ net613 net245 VPWR VGND sg13g2_nand2_1
X_23581_ net954 VGND VPWR _00643_ coeff_force_packed\[24\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
X_22532_ net916 _03020_ _00569_ VPWR VGND sg13g2_nor2_1
XFILLER_22_454 VPWR VGND sg13g2_decap_8
X_22463_ net961 VPWR _02981_ VGND net449 net611 sg13g2_o21ai_1
X_21414_ VGND VPWR _02012_ _02020_ _02031_ _02030_ sg13g2_a21oi_1
XFILLER_120_1013 VPWR VGND sg13g2_fill_1
X_22394_ VGND VPWR net435 _03272_ _00505_ _02946_ sg13g2_a21oi_1
XFILLER_108_526 VPWR VGND sg13g2_fill_2
XFILLER_5_119 VPWR VGND sg13g2_decap_4
X_21345_ _01962_ _03218_ _01960_ VPWR VGND sg13g2_xnor2_1
XFILLER_118_55 VPWR VGND sg13g2_fill_2
X_21276_ _01862_ VPWR _01893_ VGND _01889_ _01891_ sg13g2_o21ai_1
XFILLER_2_837 VPWR VGND sg13g2_fill_1
X_20227_ _00890_ net632 net264 VPWR VGND sg13g2_nand2_1
X_23015_ net1183 VGND VPWR _00077_ u_FIR.sum\[1\]\[12\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
XFILLER_89_443 VPWR VGND sg13g2_fill_1
XFILLER_131_540 VPWR VGND sg13g2_decap_8
XFILLER_103_253 VPWR VGND sg13g2_fill_1
XFILLER_89_476 VPWR VGND sg13g2_fill_2
Xrebuffer1660 net2061 net1659 VPWR VGND sg13g2_buf_1
X_20158_ _00819_ _00820_ _00821_ VPWR VGND sg13g2_nor2_1
XFILLER_103_297 VPWR VGND sg13g2_fill_1
XFILLER_76_137 VPWR VGND sg13g2_fill_2
X_20089_ _11128_ _11127_ _11130_ VPWR VGND sg13g2_xor2_1
X_12980_ net1040 VPWR _04338_ VGND net546 u_FIR.sum\[1\]\[13\] sg13g2_o21ai_1
XFILLER_100_960 VPWR VGND sg13g2_decap_8
XFILLER_100_971 VPWR VGND sg13g2_fill_2
XFILLER_100_993 VPWR VGND sg13g2_decap_8
X_11931_ VPWR _03352_ u_LMS.w\[0\]\[5\] VGND sg13g2_inv_1
X_14650_ _05941_ net771 net836 VPWR VGND sg13g2_nand2_1
X_11862_ VPWR _03283_ u_LMS.x\[7\] VGND sg13g2_inv_1
XFILLER_33_719 VPWR VGND sg13g2_decap_8
XFILLER_26_760 VPWR VGND sg13g2_decap_8
X_13601_ _04929_ _04926_ _04931_ VPWR VGND sg13g2_xor2_1
XFILLER_14_922 VPWR VGND sg13g2_fill_2
X_14581_ _05874_ _05872_ _05873_ VPWR VGND sg13g2_nand2_1
X_23779_ net991 VGND VPWR _00037_ _00021_ clknet_leaf_51_clkA sg13g2_dfrbpq_1
X_11793_ VPWR _03214_ u_LMS.count\[27\] VGND sg13g2_inv_1
XFILLER_41_730 VPWR VGND sg13g2_decap_4
XFILLER_25_281 VPWR VGND sg13g2_decap_8
XFILLER_129_1060 VPWR VGND sg13g2_fill_1
X_16320_ _07554_ net794 net803 VPWR VGND sg13g2_nand2_1
X_13532_ VGND VPWR _04864_ _04862_ _04822_ sg13g2_or2_1
XFILLER_14_977 VPWR VGND sg13g2_decap_8
XFILLER_40_240 VPWR VGND sg13g2_decap_8
XFILLER_9_425 VPWR VGND sg13g2_fill_1
XFILLER_13_476 VPWR VGND sg13g2_decap_8
X_16251_ _07487_ _07449_ _07452_ VPWR VGND sg13g2_nand2_1
X_13463_ _04801_ _04802_ _00096_ VPWR VGND sg13g2_nor2_1
XFILLER_9_447 VPWR VGND sg13g2_decap_4
X_15202_ _06473_ _06454_ _06471_ VPWR VGND sg13g2_xnor2_1
X_12414_ _03791_ _03717_ _03789_ VPWR VGND sg13g2_xnor2_1
X_16182_ _07418_ _07419_ _07420_ VPWR VGND sg13g2_nor2b_1
X_13394_ net1039 VPWR _04737_ VGND net544 u_FIR.sum\[2\]\[12\] sg13g2_o21ai_1
X_15133_ _06406_ _06373_ _06404_ VPWR VGND sg13g2_xnor2_1
X_12345_ _03724_ net721 net866 VPWR VGND sg13g2_nand2_1
XFILLER_127_868 VPWR VGND sg13g2_decap_8
XFILLER_127_879 VPWR VGND sg13g2_fill_2
X_23706__1475 VPWR VGND net1474 sg13g2_tiehi
X_19941_ VGND VPWR _10980_ _10981_ _10982_ _10974_ sg13g2_a21oi_1
X_15064_ _06325_ VPWR _06338_ VGND _06320_ _06323_ sg13g2_o21ai_1
X_12276_ _03657_ net725 net854 VPWR VGND sg13g2_nand2_1
XFILLER_107_592 VPWR VGND sg13g2_fill_1
X_14015_ _05329_ net761 net904 VPWR VGND sg13g2_nand2_1
XFILLER_4_56 VPWR VGND sg13g2_decap_8
X_19872_ VGND VPWR net53 _10918_ _10919_ net24 sg13g2_a21oi_1
XFILLER_110_702 VPWR VGND sg13g2_fill_2
X_18823_ _09878_ VPWR _09910_ VGND _09906_ _09908_ sg13g2_o21ai_1
XFILLER_110_735 VPWR VGND sg13g2_fill_2
XFILLER_67_137 VPWR VGND sg13g2_fill_1
X_18754_ _09827_ _09839_ _09841_ VPWR VGND sg13g2_nor2_1
X_15966_ _07209_ _07186_ _07208_ VPWR VGND sg13g2_xnor2_1
X_17705_ _08838_ _08835_ _08837_ VPWR VGND sg13g2_nand2_1
X_14917_ _06200_ u_FIR.sum\[4\]\[15\] net396 VPWR VGND sg13g2_nand2_1
XFILLER_82_118 VPWR VGND sg13g2_decap_4
X_18685_ VPWR _09772_ _09771_ VGND sg13g2_inv_1
X_15897_ _07142_ _07117_ _07144_ VPWR VGND sg13g2_xor2_1
XFILLER_75_170 VPWR VGND sg13g2_decap_4
XFILLER_36_535 VPWR VGND sg13g2_decap_4
XFILLER_91_630 VPWR VGND sg13g2_decap_8
XFILLER_63_321 VPWR VGND sg13g2_decap_8
X_17636_ _03273_ _03274_ net105 _08769_ VGND VPWR net92 sg13g2_nor4_2
X_14848_ _06134_ _06122_ _06133_ VPWR VGND sg13g2_xnor2_1
XFILLER_1_1052 VPWR VGND sg13g2_decap_8
XFILLER_51_516 VPWR VGND sg13g2_decap_4
X_17567_ _08700_ _08690_ _08696_ VPWR VGND sg13g2_xnor2_1
X_14779_ _06067_ _06051_ _06066_ VPWR VGND sg13g2_xnor2_1
XFILLER_51_549 VPWR VGND sg13g2_fill_2
XFILLER_32_730 VPWR VGND sg13g2_decap_8
X_19306_ _03248_ _10362_ _10369_ _10370_ VPWR VGND sg13g2_nor3_1
X_16518_ u_LMS.w\[1\]\[20\] u_LMS.w\[1\]\[19\] u_LMS.w\[1\]\[18\] _07730_ VPWR VGND
+ sg13g2_nor3_1
X_17498_ net121 _08630_ _08631_ VPWR VGND sg13g2_nor2b_1
X_19237_ VGND VPWR u_LMS.w\[3\]\[23\] net305 _10313_ _10292_ sg13g2_a21oi_1
X_16449_ _07675_ _07666_ _07678_ VPWR VGND sg13g2_xor2_1
XFILLER_31_284 VPWR VGND sg13g2_fill_2
XFILLER_76_0 VPWR VGND sg13g2_decap_8
X_19168_ _10255_ u_LMS.w\[3\]\[23\] net67 VPWR VGND sg13g2_xnor2_1
XFILLER_9_981 VPWR VGND sg13g2_decap_8
X_18119_ _09226_ _09227_ _09228_ _09229_ VPWR VGND sg13g2_nor3_1
X_19099_ _10186_ u_LMS.w\[3\]\[11\] _10185_ VPWR VGND sg13g2_nand2_1
XFILLER_105_507 VPWR VGND sg13g2_fill_1
XFILLER_105_518 VPWR VGND sg13g2_decap_4
X_21130_ _01747_ net589 net162 VPWR VGND sg13g2_nand2_1
XFILLER_132_304 VPWR VGND sg13g2_decap_8
XFILLER_105_529 VPWR VGND sg13g2_decap_8
X_21061_ net17 VPWR _01693_ VGND net15 _01692_ sg13g2_o21ai_1
Xfanout404 _04986_ net404 VPWR VGND sg13g2_buf_1
Xfanout415 net416 net415 VPWR VGND sg13g2_buf_1
XFILLER_99_774 VPWR VGND sg13g2_decap_8
X_20012_ _11051_ _11052_ _11053_ VPWR VGND sg13g2_nor2_1
Xfanout426 _03227_ net426 VPWR VGND sg13g2_buf_1
Xfanout437 net438 net437 VPWR VGND sg13g2_buf_1
XFILLER_98_273 VPWR VGND sg13g2_fill_2
Xfanout448 net451 net448 VPWR VGND sg13g2_buf_1
Xfanout459 spi_wdata\[7\] net459 VPWR VGND sg13g2_buf_1
XFILLER_86_435 VPWR VGND sg13g2_fill_1
XFILLER_67_660 VPWR VGND sg13g2_fill_1
XFILLER_73_107 VPWR VGND sg13g2_decap_8
X_21963_ _03217_ _02556_ _02557_ VPWR VGND sg13g2_nor2_1
XFILLER_104_79 VPWR VGND sg13g2_fill_2
XFILLER_94_490 VPWR VGND sg13g2_fill_2
XFILLER_54_332 VPWR VGND sg13g2_decap_4
X_23702_ net1502 VGND VPWR _00764_ u_p2s_output.reg_sh\[3\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
XFILLER_66_192 VPWR VGND sg13g2_decap_8
X_20914_ _01553_ VPWR _01554_ VGND _03228_ _01203_ sg13g2_o21ai_1
XFILLER_81_140 VPWR VGND sg13g2_decap_8
X_21894_ _02458_ VPWR _02488_ VGND _02484_ _02486_ sg13g2_o21ai_1
XFILLER_81_151 VPWR VGND sg13g2_fill_1
XFILLER_42_505 VPWR VGND sg13g2_fill_2
XFILLER_70_825 VPWR VGND sg13g2_decap_4
X_23633_ net956 VGND VPWR _00695_ u_debug_unit.error_signal_sync\[7\] clknet_leaf_53_clkA
+ sg13g2_dfrbpq_1
XFILLER_81_173 VPWR VGND sg13g2_fill_1
X_20845_ net620 net228 net618 _01485_ VPWR VGND net210 sg13g2_nand4_1
Xfanout11 net11 _02252_ VPWR VGND sg13g2_buf_4
XFILLER_120_45 VPWR VGND sg13g2_fill_2
Xfanout22 _01071_ net22 VPWR VGND sg13g2_buf_2
Xfanout33 net34 net33 VPWR VGND sg13g2_buf_2
X_23564_ net956 VGND VPWR _00626_ coeff_force_packed\[9\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
Xfanout44 _08498_ net44 VPWR VGND sg13g2_buf_1
XFILLER_80_27 VPWR VGND sg13g2_fill_2
XFILLER_23_763 VPWR VGND sg13g2_decap_4
X_20776_ net620 net171 net136 _01416_ VPWR VGND net618 sg13g2_nand4_1
XFILLER_50_560 VPWR VGND sg13g2_fill_2
XFILLER_11_914 VPWR VGND sg13g2_decap_8
XFILLER_10_402 VPWR VGND sg13g2_decap_8
Xfanout55 net55 _10263_ VPWR VGND sg13g2_buf_4
XFILLER_23_785 VPWR VGND sg13g2_fill_2
Xfanout66 _10829_ net66 VPWR VGND sg13g2_buf_2
XFILLER_11_936 VPWR VGND sg13g2_fill_2
X_22515_ u_LMS.count\[4\] _03007_ _03010_ VPWR VGND sg13g2_nor2_1
Xfanout77 net78 net77 VPWR VGND sg13g2_buf_2
Xfanout88 net88 net89 VPWR VGND sg13g2_buf_4
X_23495_ net1429 VGND VPWR _00557_ u_LMS.x_r\[8\]\[6\] clknet_leaf_7_clkA sg13g2_dfrbpq_1
Xfanout99 net105 net99 VPWR VGND sg13g2_buf_2
XFILLER_7_918 VPWR VGND sg13g2_decap_8
XFILLER_129_21 VPWR VGND sg13g2_decap_8
XFILLER_108_301 VPWR VGND sg13g2_fill_1
X_22446_ VGND VPWR net443 _03246_ _00531_ _02972_ sg13g2_a21oi_1
XFILLER_13_98 VPWR VGND sg13g2_decap_4
X_22377_ net962 VPWR _02938_ VGND net452 u_LMS.x_r\[1\]\[2\] sg13g2_o21ai_1
XFILLER_124_805 VPWR VGND sg13g2_decap_8
XFILLER_108_367 VPWR VGND sg13g2_fill_1
XFILLER_129_98 VPWR VGND sg13g2_decap_8
X_12130_ sys_enable_bus\[1\] net285 _03540_ VPWR VGND sg13g2_and2_1
X_21328_ _01945_ net600 net170 VPWR VGND sg13g2_nand2_1
XFILLER_124_849 VPWR VGND sg13g2_decap_8
XFILLER_123_337 VPWR VGND sg13g2_fill_2
XFILLER_2_634 VPWR VGND sg13g2_fill_1
XFILLER_2_645 VPWR VGND sg13g2_fill_1
X_21259_ VGND VPWR _01841_ _01872_ _01876_ _01875_ sg13g2_a21oi_1
X_12061_ _03470_ _03473_ _03469_ _03475_ VPWR VGND _03474_ sg13g2_nand4_1
XFILLER_2_656 VPWR VGND sg13g2_fill_1
XFILLER_1_133 VPWR VGND sg13g2_decap_8
XFILLER_104_562 VPWR VGND sg13g2_decap_8
XFILLER_78_925 VPWR VGND sg13g2_decap_4
XFILLER_2_678 VPWR VGND sg13g2_fill_2
Xrebuffer2180 _02752_ net2179 VPWR VGND sg13g2_buf_2
XFILLER_49_115 VPWR VGND sg13g2_fill_2
XFILLER_131_381 VPWR VGND sg13g2_decap_8
Xfanout960 net970 net960 VPWR VGND sg13g2_buf_1
X_15820_ VGND VPWR net790 _07021_ _07069_ _06990_ sg13g2_a21oi_1
Xfanout971 net973 net971 VPWR VGND sg13g2_buf_1
XFILLER_93_917 VPWR VGND sg13g2_fill_2
Xfanout982 net984 net982 VPWR VGND sg13g2_buf_1
Xfanout993 net999 net993 VPWR VGND sg13g2_buf_1
XFILLER_92_405 VPWR VGND sg13g2_fill_1
XFILLER_93_939 VPWR VGND sg13g2_decap_8
XFILLER_92_416 VPWR VGND sg13g2_decap_4
X_15751_ _07002_ _07001_ _06961_ VPWR VGND sg13g2_nand2b_1
X_12963_ _04217_ _04320_ _04321_ VPWR VGND sg13g2_and2_1
XFILLER_85_490 VPWR VGND sg13g2_fill_2
X_14702_ _05992_ u_FIR.sum\[4\]\[8\] net398 VPWR VGND sg13g2_nand2_1
X_18470_ _09580_ _09576_ _09579_ VPWR VGND sg13g2_xnor2_1
X_11914_ VPWR _03335_ u_LMS.w\[3\]\[12\] VGND sg13g2_inv_1
X_15682_ net979 VPWR _06935_ VGND net483 u_FIR.sum\[7\]\[7\] sg13g2_o21ai_1
X_12894_ u_FIR.w\[7\]\[4\] net814 _04254_ VPWR VGND sg13g2_and2_1
XFILLER_72_151 VPWR VGND sg13g2_decap_8
X_17421_ _08560_ _08561_ _00295_ VPWR VGND sg13g2_nor2_1
X_14633_ net505 VPWR _05925_ VGND _05923_ _05924_ sg13g2_o21ai_1
X_11845_ VPWR _03266_ net682 VGND sg13g2_inv_1
XFILLER_54_61 VPWR VGND sg13g2_fill_2
X_17352_ _08506_ _08464_ _08466_ VPWR VGND sg13g2_xnor2_1
X_14564_ VGND VPWR _05857_ _05855_ _05826_ sg13g2_or2_1
X_16303_ _07538_ _07501_ _07536_ VPWR VGND sg13g2_xnor2_1
X_13515_ _04846_ _04822_ _04848_ VPWR VGND sg13g2_xor2_1
X_17283_ _08439_ _03352_ _08426_ VPWR VGND sg13g2_xnor2_1
Xclkbuf_4_4_0_clkA clknet_0_clkA clknet_4_4_0_clkA VPWR VGND sg13g2_buf_8
X_14495_ _05791_ _05780_ _05788_ _05790_ VPWR VGND sg13g2_and3_1
X_19022_ _10094_ _10108_ _10109_ VPWR VGND sg13g2_nor2_1
X_16234_ _07471_ _07462_ _07469_ VPWR VGND sg13g2_xnor2_1
XFILLER_16_1060 VPWR VGND sg13g2_fill_1
X_13446_ u_FIR.sum\[1\]\[14\] _04540_ _04786_ VPWR VGND sg13g2_nor2b_1
XFILLER_70_71 VPWR VGND sg13g2_fill_2
Xclkload14 clkload14/Y clknet_leaf_64_clkA VPWR VGND sg13g2_inv_8
Xclkload25 clknet_leaf_51_clkA clkload25/X VPWR VGND sg13g2_buf_8
Xclkload36 VPWR clkload36/Y clknet_leaf_19_clkA VGND sg13g2_inv_1
X_16165_ VGND VPWR _07385_ _07391_ _07403_ _07390_ sg13g2_a21oi_1
Xclkload47 clkload47/Y clknet_leaf_34_clkA VPWR VGND sg13g2_inv_2
X_13377_ _04720_ _04712_ _04718_ VPWR VGND sg13g2_xnor2_1
Xclkload58 clkload58/X clknet_3_7__leaf_spi_sclk VPWR VGND sg13g2_buf_4
X_15116_ _06389_ _06382_ _06388_ VPWR VGND sg13g2_nand2_1
X_12328_ _03706_ _03678_ _03708_ VPWR VGND sg13g2_xor2_1
X_16096_ _07336_ net799 net832 VPWR VGND sg13g2_nand2_1
XFILLER_114_348 VPWR VGND sg13g2_fill_2
X_19924_ net425 net134 _10965_ VPWR VGND sg13g2_nor2_1
X_15047_ net846 net783 u_FIR.sum\[5\]\[4\] _06322_ VPWR VGND sg13g2_a21o_1
X_12259_ _03641_ _03609_ _03640_ VPWR VGND sg13g2_xnor2_1
XFILLER_69_903 VPWR VGND sg13g2_decap_4
XFILLER_123_860 VPWR VGND sg13g2_fill_1
XFILLER_69_936 VPWR VGND sg13g2_decap_4
X_19855_ _10906_ u_LMS.w\[4\]\[2\] _10706_ VPWR VGND sg13g2_xnor2_1
XFILLER_96_744 VPWR VGND sg13g2_fill_2
XFILLER_110_532 VPWR VGND sg13g2_fill_2
X_18806_ VGND VPWR _09855_ _09889_ _09893_ _09892_ sg13g2_a21oi_1
XFILLER_110_565 VPWR VGND sg13g2_decap_8
X_19786_ _10847_ _10848_ _10849_ _10850_ VPWR VGND sg13g2_or3_1
XFILLER_23_1020 VPWR VGND sg13g2_fill_1
X_16998_ _03281_ net95 _08154_ VPWR VGND sg13g2_nor2_1
X_18737_ _09824_ _09805_ _09822_ VPWR VGND sg13g2_xnor2_1
X_15949_ _07193_ _07185_ _07192_ VPWR VGND sg13g2_nand2_1
XFILLER_48_170 VPWR VGND sg13g2_fill_2
XFILLER_110_1034 VPWR VGND sg13g2_decap_4
XFILLER_92_950 VPWR VGND sg13g2_decap_8
X_18668_ _09756_ _09640_ _09642_ VPWR VGND sg13g2_xnor2_1
XFILLER_37_888 VPWR VGND sg13g2_fill_1
XFILLER_91_460 VPWR VGND sg13g2_fill_1
XFILLER_52_825 VPWR VGND sg13g2_decap_8
XFILLER_91_482 VPWR VGND sg13g2_fill_2
X_17619_ _08745_ VPWR _08752_ VGND _08712_ _08743_ sg13g2_o21ai_1
X_18599_ VGND VPWR u_LMS.w\[2\]\[18\] net302 _09703_ _09702_ sg13g2_a21oi_1
X_20630_ VGND VPWR _01270_ _01269_ _01237_ sg13g2_or2_1
XFILLER_20_700 VPWR VGND sg13g2_decap_4
XFILLER_20_722 VPWR VGND sg13g2_decap_4
X_20561_ VGND VPWR _01175_ _01186_ _01201_ _01185_ sg13g2_a21oi_1
Xclkload8 clknet_4_10_0_clkA clkload8/X VPWR VGND sg13g2_buf_8
X_22300_ net8 VPWR _02885_ VGND net7 _02884_ sg13g2_o21ai_1
X_20492_ net363 VPWR _01137_ VGND u_LMS.w\[5\]\[7\] net381 sg13g2_o21ai_1
X_23280_ net1333 VGND VPWR _00342_ u_LMS.w\[2\]\[5\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
XFILLER_30_1002 VPWR VGND sg13g2_decap_4
XFILLER_118_621 VPWR VGND sg13g2_fill_1
XFILLER_20_799 VPWR VGND sg13g2_decap_8
X_22231_ _02825_ u_LMS.w\[8\]\[18\] net61 VPWR VGND sg13g2_xnor2_1
X_22162_ _02756_ u_LMS.w\[8\]\[17\] _02755_ VPWR VGND sg13g2_nand2b_1
XFILLER_132_112 VPWR VGND sg13g2_decap_8
X_21113_ VGND VPWR _01657_ _01732_ _01733_ _01710_ sg13g2_a21oi_1
X_22093_ _02687_ net586 net255 VPWR VGND sg13g2_nand2_1
Xfanout201 net202 net201 VPWR VGND sg13g2_buf_1
XFILLER_8_1003 VPWR VGND sg13g2_fill_2
Xfanout212 net213 net212 VPWR VGND sg13g2_buf_2
XFILLER_132_178 VPWR VGND sg13g2_decap_8
X_21044_ _01637_ _01678_ _01679_ VPWR VGND sg13g2_and2_1
Xfanout223 net224 net223 VPWR VGND sg13g2_buf_1
XFILLER_87_733 VPWR VGND sg13g2_fill_2
XFILLER_59_424 VPWR VGND sg13g2_decap_8
Xfanout234 _08067_ net234 VPWR VGND sg13g2_buf_8
Xfanout245 net248 net245 VPWR VGND sg13g2_buf_1
XFILLER_8_1047 VPWR VGND sg13g2_decap_8
XFILLER_59_435 VPWR VGND sg13g2_fill_1
Xfanout256 net257 net256 VPWR VGND sg13g2_buf_1
XFILLER_86_232 VPWR VGND sg13g2_fill_1
Xfanout267 _06102_ net267 VPWR VGND sg13g2_buf_1
XFILLER_59_457 VPWR VGND sg13g2_decap_8
Xfanout278 _05617_ net278 VPWR VGND sg13g2_buf_1
Xfanout289 _03436_ net289 VPWR VGND sg13g2_buf_1
XFILLER_74_416 VPWR VGND sg13g2_fill_1
XFILLER_101_587 VPWR VGND sg13g2_decap_8
XFILLER_74_427 VPWR VGND sg13g2_fill_2
XFILLER_28_822 VPWR VGND sg13g2_decap_4
XFILLER_39_170 VPWR VGND sg13g2_fill_1
X_22995_ net1213 VGND VPWR _00057_ u_FIR.sum\[0\]\[7\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
XFILLER_27_332 VPWR VGND sg13g2_decap_8
XFILLER_131_11 VPWR VGND sg13g2_decap_8
X_21946_ _02540_ _02532_ _02539_ VPWR VGND sg13g2_xnor2_1
XFILLER_83_994 VPWR VGND sg13g2_fill_2
XFILLER_70_611 VPWR VGND sg13g2_fill_2
XFILLER_15_527 VPWR VGND sg13g2_fill_1
XFILLER_15_538 VPWR VGND sg13g2_fill_2
XFILLER_131_88 VPWR VGND sg13g2_decap_8
X_21877_ _02471_ _02470_ _02467_ VPWR VGND sg13g2_nand2b_1
X_23616_ net967 VGND VPWR _00678_ coeff_force_packed\[55\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
XFILLER_39_1060 VPWR VGND sg13g2_fill_1
X_20828_ _01468_ _01438_ _01444_ VPWR VGND sg13g2_xnor2_1
XFILLER_24_31 VPWR VGND sg13g2_fill_2
X_23547_ net1010 VGND VPWR _00609_ sys_enable_bus\[1\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
X_20759_ VGND VPWR _01397_ _01398_ _01399_ _01396_ sg13g2_a21oi_1
XFILLER_7_704 VPWR VGND sg13g2_fill_1
XFILLER_10_232 VPWR VGND sg13g2_decap_8
X_13300_ _04645_ _04602_ _04605_ VPWR VGND sg13g2_nand2_1
X_14280_ _05587_ _05583_ _05586_ VPWR VGND sg13g2_xnor2_1
X_23478_ net1490 VGND VPWR _00540_ u_LMS.x_r\[6\]\[5\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
X_13231_ _04531_ VPWR _04578_ VGND _04488_ _04529_ sg13g2_o21ai_1
X_22429_ net949 VPWR _02964_ VGND net437 net645 sg13g2_o21ai_1
XFILLER_40_52 VPWR VGND sg13g2_decap_8
XFILLER_109_687 VPWR VGND sg13g2_decap_4
XFILLER_108_175 VPWR VGND sg13g2_fill_1
X_13162_ _04511_ _04471_ _04474_ _04510_ VPWR VGND sg13g2_and3_1
XFILLER_108_197 VPWR VGND sg13g2_decap_8
X_12113_ _03524_ _03418_ u_debug_unit.mon_w2_sync\[2\] _03400_ u_debug_unit.mon_w3_sync\[2\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_6_0 VPWR VGND sg13g2_decap_8
XFILLER_3_965 VPWR VGND sg13g2_decap_8
Xclkbuf_4_12_0_clkA clknet_0_clkA clknet_4_12_0_clkA VPWR VGND sg13g2_buf_8
X_17970_ net41 VPWR _09102_ VGND net39 _09101_ sg13g2_o21ai_1
X_13093_ _04443_ net740 net896 VPWR VGND sg13g2_nand2_1
XFILLER_111_329 VPWR VGND sg13g2_decap_8
X_16921_ _08077_ _08075_ _08076_ VPWR VGND sg13g2_xnor2_1
X_12044_ _03459_ net286 u_debug_unit.sw_reset\[6\] net295 coeff_force_packed\[41\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_104_370 VPWR VGND sg13g2_fill_1
XFILLER_78_744 VPWR VGND sg13g2_fill_1
XFILLER_2_497 VPWR VGND sg13g2_fill_1
X_19640_ _10704_ _10693_ _10702_ VPWR VGND sg13g2_xnor2_1
XFILLER_66_917 VPWR VGND sg13g2_fill_1
XFILLER_38_608 VPWR VGND sg13g2_decap_8
X_16852_ net418 net134 _08008_ VPWR VGND sg13g2_nor2_1
Xfanout790 u_FIR.w\[1\]\[1\] net790 VPWR VGND sg13g2_buf_1
XFILLER_1_35 VPWR VGND sg13g2_decap_8
X_15803_ _07047_ _07049_ _07052_ VPWR VGND sg13g2_nor2_1
X_19571_ _10635_ _10627_ _10634_ VPWR VGND sg13g2_xnor2_1
X_16783_ _07911_ VPWR _07939_ VGND _07909_ _07926_ sg13g2_o21ai_1
X_13995_ net880 u_FIR.sum\[3\]\[2\] net765 _05310_ VPWR VGND sg13g2_nand3_1
XFILLER_92_246 VPWR VGND sg13g2_decap_4
X_18522_ _09632_ _03337_ _09606_ VPWR VGND sg13g2_nand2_1
X_15734_ _06983_ _06984_ _06985_ VPWR VGND sg13g2_and2_1
XFILLER_18_343 VPWR VGND sg13g2_fill_1
X_12946_ _04284_ _04304_ _04305_ VPWR VGND sg13g2_nor2b_1
XFILLER_46_685 VPWR VGND sg13g2_fill_1
X_18453_ _09562_ VPWR _09563_ VGND _09557_ _09559_ sg13g2_o21ai_1
X_15665_ _06918_ _06900_ _06916_ VPWR VGND sg13g2_xnor2_1
XFILLER_60_110 VPWR VGND sg13g2_decap_8
X_12877_ _04238_ _04229_ _04236_ VPWR VGND sg13g2_xnor2_1
XFILLER_60_121 VPWR VGND sg13g2_fill_1
XFILLER_34_869 VPWR VGND sg13g2_decap_8
X_17404_ VGND VPWR _03353_ _08395_ _08548_ _08494_ sg13g2_a21oi_1
X_14616_ _05863_ _05865_ _05908_ VPWR VGND sg13g2_and2_1
X_18384_ _09486_ _09484_ _09488_ _09494_ VPWR VGND sg13g2_a21o_1
X_11828_ VPWR _03249_ net649 VGND sg13g2_inv_1
X_15596_ _06851_ _06823_ _06850_ VPWR VGND sg13g2_xnor2_1
X_17335_ net440 u_LMS.toggle _08491_ VPWR VGND sg13g2_and2_1
X_14547_ _05841_ _05840_ _05804_ VPWR VGND sg13g2_nand2b_1
X_17266_ _03351_ _08421_ _08422_ VPWR VGND sg13g2_nor2_1
X_14478_ net902 u_FIR.sum\[4\]\[0\] net773 _05776_ VPWR VGND sg13g2_nand3_1
X_19005_ _10092_ net663 net253 VPWR VGND sg13g2_nand2_1
X_16217_ _07454_ _07446_ _07453_ VPWR VGND sg13g2_xnor2_1
X_13429_ _04770_ _04769_ _04749_ VPWR VGND sg13g2_nand2b_1
XFILLER_128_963 VPWR VGND sg13g2_decap_8
X_17197_ _08251_ _08234_ _08353_ VPWR VGND sg13g2_xor2_1
X_16148_ u_FIR.w\[0\]\[0\] net805 _07387_ VPWR VGND sg13g2_and2_1
XFILLER_114_134 VPWR VGND sg13g2_fill_1
X_16079_ _07320_ _07292_ _07319_ VPWR VGND sg13g2_xnor2_1
XFILLER_114_156 VPWR VGND sg13g2_fill_1
X_19907_ _10946_ _10940_ _10948_ VPWR VGND sg13g2_xor2_1
XFILLER_39_0 VPWR VGND sg13g2_decap_8
XFILLER_114_189 VPWR VGND sg13g2_fill_1
XFILLER_123_690 VPWR VGND sg13g2_fill_1
XFILLER_96_541 VPWR VGND sg13g2_decap_4
X_19838_ net26 VPWR _10893_ VGND net25 _10892_ sg13g2_o21ai_1
XFILLER_96_574 VPWR VGND sg13g2_decap_8
XFILLER_84_725 VPWR VGND sg13g2_fill_2
XFILLER_56_416 VPWR VGND sg13g2_fill_2
XFILLER_96_596 VPWR VGND sg13g2_fill_1
XFILLER_84_736 VPWR VGND sg13g2_fill_1
XFILLER_110_384 VPWR VGND sg13g2_decap_8
Xinput1 reset net1 VPWR VGND sg13g2_buf_1
X_19769_ _10833_ u_LMS.w\[4\]\[19\] net65 VPWR VGND sg13g2_xnor2_1
X_21800_ _02392_ _02393_ _02394_ VPWR VGND sg13g2_nor2b_1
X_22780_ u_debug_unit.mon_w4_sync\[6\] net344 _03108_ VPWR VGND sg13g2_nor2_1
XFILLER_52_600 VPWR VGND sg13g2_fill_1
XFILLER_64_471 VPWR VGND sg13g2_decap_8
X_21731_ net366 VPWR _02328_ VGND u_LMS.w\[7\]\[9\] net377 sg13g2_o21ai_1
XFILLER_51_110 VPWR VGND sg13g2_fill_2
XFILLER_51_121 VPWR VGND sg13g2_fill_1
XFILLER_80_975 VPWR VGND sg13g2_fill_2
X_21662_ net2164 _02231_ _02159_ _02273_ VPWR VGND sg13g2_nand3_1
X_23401_ net1145 VGND VPWR _00463_ u_LMS.w\[7\]\[11\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
X_20613_ VGND VPWR _01244_ _01245_ _01253_ _01252_ sg13g2_a21oi_1
X_21593_ _02177_ VPWR _02210_ VGND _02207_ _02208_ sg13g2_o21ai_1
X_23332_ net1269 VGND VPWR _00394_ u_LMS.w\[4\]\[11\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
X_23726__1335 VPWR VGND net1334 sg13g2_tiehi
XFILLER_20_552 VPWR VGND sg13g2_fill_1
X_20544_ _01184_ _01178_ _01183_ VPWR VGND sg13g2_xnor2_1
X_23263_ net1367 VGND VPWR _00325_ u_LMS.w\[1\]\[11\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
X_20475_ VGND VPWR net51 _01123_ _01124_ net19 sg13g2_a21oi_1
XFILLER_117_7 VPWR VGND sg13g2_decap_8
X_22214_ VGND VPWR _02805_ _02806_ _02808_ _02772_ sg13g2_a21oi_1
X_23194_ net1491 VGND VPWR _00256_ u_FIR.w\[5\]\[4\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
XFILLER_105_123 VPWR VGND sg13g2_decap_8
X_22145_ _02386_ _02405_ _02415_ _02739_ VPWR VGND sg13g2_or3_1
XFILLER_105_156 VPWR VGND sg13g2_decap_8
XFILLER_121_605 VPWR VGND sg13g2_fill_1
XFILLER_105_167 VPWR VGND sg13g2_fill_1
XFILLER_10_99 VPWR VGND sg13g2_decap_8
Xfanout1007 net1008 net1007 VPWR VGND sg13g2_buf_1
XFILLER_126_77 VPWR VGND sg13g2_decap_8
X_22076_ _02667_ _02654_ _02670_ VPWR VGND sg13g2_xor2_1
Xfanout1018 net1032 net1018 VPWR VGND sg13g2_buf_1
XFILLER_0_957 VPWR VGND sg13g2_decap_8
Xfanout1029 net1032 net1029 VPWR VGND sg13g2_buf_1
XFILLER_101_340 VPWR VGND sg13g2_fill_1
X_21027_ net17 VPWR _01666_ VGND net15 _01665_ sg13g2_o21ai_1
XFILLER_19_31 VPWR VGND sg13g2_decap_4
XFILLER_19_107 VPWR VGND sg13g2_fill_1
XFILLER_47_427 VPWR VGND sg13g2_decap_8
XFILLER_19_129 VPWR VGND sg13g2_decap_8
X_12800_ _04162_ _04132_ _04163_ VPWR VGND sg13g2_xor2_1
XFILLER_74_257 VPWR VGND sg13g2_fill_1
X_13780_ _05106_ _05064_ _05104_ VPWR VGND sg13g2_xnor2_1
XFILLER_28_663 VPWR VGND sg13g2_fill_1
X_22978_ net996 VGND VPWR _00040_ u_spi_slave.tx_shift\[8\] net1628 sg13g2_dfrbpq_1
XFILLER_43_600 VPWR VGND sg13g2_fill_1
XFILLER_16_814 VPWR VGND sg13g2_decap_8
XFILLER_76_1013 VPWR VGND sg13g2_decap_8
X_12731_ _03360_ net897 _04095_ VPWR VGND sg13g2_nor2_1
X_21929_ _02523_ net580 net203 VPWR VGND sg13g2_nand2_1
XFILLER_71_953 VPWR VGND sg13g2_fill_2
X_15450_ _06713_ _06705_ _06711_ VPWR VGND sg13g2_xnor2_1
X_12662_ _04026_ _03993_ _04028_ VPWR VGND sg13g2_xor2_1
XFILLER_42_165 VPWR VGND sg13g2_fill_1
XFILLER_15_379 VPWR VGND sg13g2_fill_2
X_14401_ _05704_ _05676_ _05702_ VPWR VGND sg13g2_xnor2_1
XFILLER_42_187 VPWR VGND sg13g2_decap_8
X_15381_ _06647_ _06539_ _06645_ VPWR VGND sg13g2_xnor2_1
X_12593_ _03960_ _03961_ _03962_ VPWR VGND sg13g2_and2_1
X_17120_ _08274_ _08273_ _08276_ VPWR VGND sg13g2_xor2_1
X_14332_ _05613_ VPWR _05637_ VGND net279 _05614_ sg13g2_o21ai_1
XFILLER_51_40 VPWR VGND sg13g2_decap_4
XFILLER_128_237 VPWR VGND sg13g2_decap_8
X_17051_ _08207_ _08197_ _08206_ VPWR VGND sg13g2_xnor2_1
Xclkbuf_leaf_40_clkA clknet_4_7_0_clkA clknet_leaf_40_clkA VPWR VGND sg13g2_buf_8
X_14263_ _05497_ net764 _05569_ _05570_ VPWR VGND sg13g2_mux2_1
XFILLER_100_1000 VPWR VGND sg13g2_decap_8
X_16002_ _07243_ net796 net899 VPWR VGND sg13g2_nand2_1
X_13214_ _03361_ net884 _04561_ VPWR VGND sg13g2_nor2_1
XFILLER_109_495 VPWR VGND sg13g2_fill_1
X_14194_ _05496_ _05502_ _05503_ VPWR VGND sg13g2_nor2b_1
XFILLER_124_421 VPWR VGND sg13g2_decap_8
XFILLER_124_432 VPWR VGND sg13g2_fill_2
XFILLER_98_806 VPWR VGND sg13g2_fill_2
XFILLER_3_740 VPWR VGND sg13g2_fill_1
X_13145_ _04494_ _04486_ _04492_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_988 VPWR VGND sg13g2_fill_1
XFILLER_97_327 VPWR VGND sg13g2_fill_1
X_17953_ _09086_ _09083_ _09085_ VPWR VGND sg13g2_nand2_1
X_13076_ _04427_ _04425_ _04426_ VPWR VGND sg13g2_nand2_1
XFILLER_32_7 VPWR VGND sg13g2_decap_8
XFILLER_39_906 VPWR VGND sg13g2_fill_2
XFILLER_111_159 VPWR VGND sg13g2_decap_8
X_16904_ _08060_ _08048_ _08058_ VPWR VGND sg13g2_xnor2_1
X_12027_ _03444_ net294 debug_load_bus\[7\] net296 u_debug_unit.force_w1\[7\] VPWR
+ VGND sg13g2_a22oi_1
XFILLER_39_928 VPWR VGND sg13g2_fill_2
X_17884_ _09015_ _09016_ _09017_ VPWR VGND sg13g2_nor2_1
XFILLER_38_427 VPWR VGND sg13g2_decap_8
X_19623_ _10672_ _10686_ _10687_ VPWR VGND sg13g2_nor2_1
X_16835_ net124 _07990_ _07991_ VPWR VGND sg13g2_nor2_2
XFILLER_20_1001 VPWR VGND sg13g2_decap_8
XFILLER_19_641 VPWR VGND sg13g2_fill_2
X_23077__1091 VPWR VGND net1090 sg13g2_tiehi
X_19554_ VGND VPWR _10611_ _10617_ _10618_ _10610_ sg13g2_a21oi_1
XFILLER_81_717 VPWR VGND sg13g2_fill_1
X_16766_ net914 _07897_ _07922_ VPWR VGND sg13g2_and2_2
X_13978_ VGND VPWR _05293_ _05294_ _05295_ net416 sg13g2_a21oi_1
XFILLER_20_1045 VPWR VGND sg13g2_decap_8
X_18505_ _09615_ u_LMS.w\[2\]\[3\] _09614_ VPWR VGND sg13g2_nand2_1
X_15717_ _06968_ _06937_ _06969_ VPWR VGND sg13g2_xor2_1
X_12929_ _04288_ net729 net815 VPWR VGND sg13g2_nand2_1
X_19485_ _03249_ _03250_ net101 _10549_ VGND VPWR net96 sg13g2_nor4_2
X_16697_ net1024 VPWR _07863_ VGND net520 net731 sg13g2_o21ai_1
XFILLER_33_132 VPWR VGND sg13g2_decap_8
XFILLER_61_452 VPWR VGND sg13g2_fill_2
X_18436_ _09498_ VPWR _09546_ VGND _09543_ _09544_ sg13g2_o21ai_1
X_15648_ _06901_ _06863_ _06865_ VPWR VGND sg13g2_nand2_1
XFILLER_62_997 VPWR VGND sg13g2_fill_1
XFILLER_34_688 VPWR VGND sg13g2_fill_2
XFILLER_33_165 VPWR VGND sg13g2_fill_1
X_18367_ _09477_ _09448_ _09449_ VPWR VGND sg13g2_xnor2_1
X_15579_ _06834_ _06833_ _06829_ VPWR VGND sg13g2_nand2b_1
X_17318_ net71 VPWR _08474_ VGND u_LMS.w\[0\]\[19\] u_LMS.w\[0\]\[18\] sg13g2_o21ai_1
X_18298_ _09397_ VPWR _09408_ VGND _09358_ _09394_ sg13g2_o21ai_1
X_17249_ _08405_ _08375_ _08163_ VPWR VGND sg13g2_nand2b_1
X_20260_ _00923_ _00894_ _00922_ VPWR VGND sg13g2_xnor2_1
XFILLER_115_454 VPWR VGND sg13g2_fill_1
X_20191_ _00854_ net633 net192 VPWR VGND sg13g2_nand2_1
XFILLER_116_999 VPWR VGND sg13g2_fill_1
XFILLER_88_338 VPWR VGND sg13g2_decap_8
X_22901_ _03179_ net297 u_FIR.x\[7\] net298 u_s2p_input.reg_sh\[6\] VPWR VGND sg13g2_a22oi_1
XFILLER_69_596 VPWR VGND sg13g2_decap_4
XFILLER_56_29 VPWR VGND sg13g2_fill_2
XFILLER_110_170 VPWR VGND sg13g2_fill_2
XFILLER_45_909 VPWR VGND sg13g2_fill_1
X_22832_ u_debug_unit.mon_w8_sync\[4\] net341 _03134_ VPWR VGND sg13g2_nor2_1
XFILLER_44_419 VPWR VGND sg13g2_fill_2
XFILLER_72_739 VPWR VGND sg13g2_decap_8
XFILLER_37_493 VPWR VGND sg13g2_decap_8
XFILLER_25_633 VPWR VGND sg13g2_fill_2
X_22763_ VGND VPWR _07783_ net336 _00721_ _03099_ sg13g2_a21oi_1
XFILLER_71_249 VPWR VGND sg13g2_decap_8
XFILLER_24_110 VPWR VGND sg13g2_fill_1
XFILLER_80_750 VPWR VGND sg13g2_decap_8
XFILLER_72_39 VPWR VGND sg13g2_decap_4
XFILLER_52_452 VPWR VGND sg13g2_fill_1
X_21714_ VGND VPWR net50 _02314_ _02315_ _02304_ sg13g2_a21oi_1
X_22694_ coeff_force_packed\[58\] net468 _03069_ _00682_ VPWR VGND sg13g2_mux2_1
XFILLER_52_496 VPWR VGND sg13g2_fill_2
XFILLER_36_1030 VPWR VGND sg13g2_decap_4
X_21645_ _02260_ net312 u_LMS.w\[7\]\[14\] coeff_force_packed\[51\] net562 VPWR VGND
+ sg13g2_a22oi_1
Xclkbuf_leaf_63_clkA clknet_4_0_0_clkA clknet_leaf_63_clkA VPWR VGND sg13g2_buf_8
X_21576_ _02193_ u_LMS.w\[7\]\[4\] _02185_ VPWR VGND sg13g2_xnor2_1
X_23315_ net1286 VGND VPWR _00377_ u_LMS.w\[4\]\[17\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
X_20527_ _01167_ net88 _01165_ VPWR VGND sg13g2_nand2b_1
XFILLER_21_54 VPWR VGND sg13g2_fill_2
X_23246_ net1399 VGND VPWR _00308_ u_LMS.w\[1\]\[17\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
XFILLER_4_526 VPWR VGND sg13g2_fill_1
XFILLER_106_421 VPWR VGND sg13g2_decap_8
X_20458_ VGND VPWR u_LMS.w\[5\]\[22\] net318 _01111_ _01094_ sg13g2_a21oi_1
XFILLER_122_903 VPWR VGND sg13g2_fill_1
X_23177_ net1520 VGND VPWR _00239_ u_FIR.w\[3\]\[1\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
X_20389_ _03320_ _03319_ net75 _01052_ VPWR VGND sg13g2_a21o_1
XFILLER_0_710 VPWR VGND sg13g2_decap_8
XFILLER_0_721 VPWR VGND sg13g2_fill_1
X_22128_ _02722_ _02718_ _02719_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_765 VPWR VGND sg13g2_decap_4
X_14950_ _06230_ _06219_ _06232_ VPWR VGND sg13g2_xor2_1
X_22059_ VGND VPWR _02653_ _02652_ _02651_ sg13g2_or2_1
XFILLER_88_883 VPWR VGND sg13g2_decap_8
XFILLER_88_894 VPWR VGND sg13g2_fill_2
XFILLER_130_1004 VPWR VGND sg13g2_decap_8
XFILLER_102_682 VPWR VGND sg13g2_decap_4
XFILLER_87_382 VPWR VGND sg13g2_fill_1
X_13901_ _05223_ _05212_ _05222_ VPWR VGND sg13g2_xnor2_1
X_14881_ _06165_ net267 _06166_ VPWR VGND sg13g2_xor2_1
XFILLER_48_758 VPWR VGND sg13g2_fill_2
XFILLER_75_544 VPWR VGND sg13g2_fill_2
XFILLER_75_566 VPWR VGND sg13g2_decap_4
X_16620_ net1020 VPWR _07806_ VGND net517 net759 sg13g2_o21ai_1
X_13832_ net748 net810 _05156_ VPWR VGND sg13g2_and2_1
XFILLER_44_931 VPWR VGND sg13g2_decap_4
X_16551_ net982 VPWR _07756_ VGND net488 net782 sg13g2_o21ai_1
X_23039__1148 VPWR VGND net1147 sg13g2_tiehi
X_13763_ _05089_ net750 net826 VPWR VGND sg13g2_nand2_1
XFILLER_28_493 VPWR VGND sg13g2_decap_8
XFILLER_16_633 VPWR VGND sg13g2_fill_2
X_15502_ _06760_ _06749_ _06757_ _06759_ VPWR VGND sg13g2_and3_1
X_12714_ _04079_ _04070_ _04078_ VPWR VGND sg13g2_nand2_1
XFILLER_16_677 VPWR VGND sg13g2_fill_2
X_19270_ VPWR VGND _10337_ _08554_ net27 _03330_ _00368_ net368 sg13g2_a221oi_1
X_16482_ VGND VPWR _07702_ _07703_ _00214_ net941 sg13g2_a21oi_1
XFILLER_31_603 VPWR VGND sg13g2_decap_4
X_13694_ _05004_ _05021_ _05022_ VPWR VGND sg13g2_nor2b_1
XFILLER_31_625 VPWR VGND sg13g2_fill_1
XFILLER_30_102 VPWR VGND sg13g2_fill_1
XFILLER_102_90 VPWR VGND sg13g2_fill_1
X_18221_ _09327_ VPWR _09331_ VGND _09328_ _09330_ sg13g2_o21ai_1
X_15433_ _06697_ _06695_ _06696_ VPWR VGND sg13g2_nand2_1
XFILLER_30_113 VPWR VGND sg13g2_decap_4
X_12645_ _04012_ _03990_ _04010_ VPWR VGND sg13g2_xnor2_1
X_18152_ net421 net217 _09262_ VPWR VGND sg13g2_nor2_1
X_15364_ _06629_ _06604_ _06631_ VPWR VGND sg13g2_xor2_1
X_12576_ VGND VPWR net737 net895 _03946_ u_FIR.sum\[0\]\[1\] sg13g2_a21oi_1
XFILLER_50_1038 VPWR VGND sg13g2_fill_2
XFILLER_129_557 VPWR VGND sg13g2_decap_8
X_17103_ _08259_ _08258_ _08254_ VPWR VGND sg13g2_nand2b_1
X_14315_ _05621_ _05620_ _05585_ VPWR VGND sg13g2_nand2b_1
X_18083_ _09191_ _09189_ _09193_ VPWR VGND sg13g2_xor2_1
X_15295_ _06532_ _06563_ _06564_ VPWR VGND sg13g2_nor2_1
XFILLER_7_56 VPWR VGND sg13g2_decap_8
X_17034_ _08189_ _08167_ _08190_ VPWR VGND sg13g2_xor2_1
X_14246_ _05526_ _05553_ _05554_ VPWR VGND sg13g2_nor2b_1
X_14177_ _05465_ VPWR _05486_ VGND _05466_ _05474_ sg13g2_o21ai_1
XFILLER_124_251 VPWR VGND sg13g2_decap_8
XFILLER_98_625 VPWR VGND sg13g2_decap_8
XFILLER_113_936 VPWR VGND sg13g2_decap_8
XFILLER_3_570 VPWR VGND sg13g2_decap_8
X_13128_ VGND VPWR _04442_ _04469_ _04477_ _04468_ sg13g2_a21oi_1
X_18985_ _10071_ VPWR _10072_ VGND _10042_ _10069_ sg13g2_o21ai_1
X_17936_ VGND VPWR _08980_ _09048_ _09069_ _09068_ sg13g2_a21oi_1
X_13059_ _04411_ _04389_ _04409_ VPWR VGND sg13g2_xnor2_1
XFILLER_38_224 VPWR VGND sg13g2_decap_4
X_17867_ _03344_ _08999_ _09000_ VPWR VGND sg13g2_nor2_1
X_19606_ _10648_ _10646_ _10670_ VPWR VGND sg13g2_xor2_1
X_16818_ net2200 net126 net123 _07974_ VPWR VGND sg13g2_nor3_2
XFILLER_38_268 VPWR VGND sg13g2_fill_2
X_17798_ _08929_ _08885_ _08931_ VPWR VGND sg13g2_xor2_1
XFILLER_66_599 VPWR VGND sg13g2_decap_4
XFILLER_35_920 VPWR VGND sg13g2_decap_4
X_19537_ _10601_ u_LMS.x_r\[4\]\[3\] net204 VPWR VGND sg13g2_nand2_1
X_16749_ VGND VPWR u_FIR.sum\[8\]\[9\] _07893_ _07905_ _07894_ sg13g2_a21oi_1
X_19468_ _10532_ net642 net249 VPWR VGND sg13g2_nand2_1
XFILLER_34_485 VPWR VGND sg13g2_fill_2
X_18419_ _09527_ _09523_ _09528_ _09529_ VPWR VGND sg13g2_a21o_1
XFILLER_50_956 VPWR VGND sg13g2_decap_8
XFILLER_22_658 VPWR VGND sg13g2_decap_8
X_19399_ _10463_ _10462_ _10455_ VPWR VGND sg13g2_nand2b_1
X_21430_ _02046_ _02044_ _02047_ VPWR VGND sg13g2_xor2_1
X_23264__1366 VPWR VGND net1365 sg13g2_tiehi
X_21361_ _01974_ _01977_ _01978_ VPWR VGND sg13g2_nor2_1
X_23100_ net1056 VGND VPWR _00162_ u_FIR.sum\[6\]\[5\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
X_20312_ _00975_ u_LMS.w\[5\]\[17\] _00974_ VPWR VGND sg13g2_nand2_1
X_21292_ _01901_ _01900_ _01909_ VPWR VGND sg13g2_xor2_1
X_23307__1295 VPWR VGND net1294 sg13g2_tiehi
X_23031_ net1159 VGND VPWR _00093_ u_FIR.sum\[2\]\[12\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
X_20243_ _00904_ _00905_ _00906_ VPWR VGND sg13g2_nor2_1
X_20174_ _00837_ _11184_ _11185_ VPWR VGND sg13g2_xnor2_1
XFILLER_130_210 VPWR VGND sg13g2_decap_4
XFILLER_107_68 VPWR VGND sg13g2_fill_2
XFILLER_77_809 VPWR VGND sg13g2_decap_4
XFILLER_88_157 VPWR VGND sg13g2_decap_8
XFILLER_131_788 VPWR VGND sg13g2_decap_4
XFILLER_85_820 VPWR VGND sg13g2_fill_2
XFILLER_96_190 VPWR VGND sg13g2_fill_1
X_22815_ VGND VPWR _07858_ net348 _00747_ _03125_ sg13g2_a21oi_1
XFILLER_72_569 VPWR VGND sg13g2_decap_8
XFILLER_37_290 VPWR VGND sg13g2_decap_8
XFILLER_13_603 VPWR VGND sg13g2_fill_1
X_22746_ u_debug_unit.mon_w2_sync\[3\] net335 _03091_ VPWR VGND sg13g2_nor2_1
XFILLER_26_997 VPWR VGND sg13g2_decap_4
XFILLER_13_636 VPWR VGND sg13g2_decap_4
X_23035__1154 VPWR VGND net1153 sg13g2_tiehi
X_22677_ coeff_force_packed\[45\] net467 _03067_ _00667_ VPWR VGND sg13g2_mux2_1
XFILLER_41_978 VPWR VGND sg13g2_fill_2
X_12430_ _03807_ _03767_ _03806_ VPWR VGND sg13g2_xnor2_1
X_21628_ _02238_ _02242_ _02239_ _02245_ VPWR VGND _02244_ sg13g2_nand4_1
XFILLER_32_53 VPWR VGND sg13g2_decap_4
X_12361_ _03740_ _03722_ _03738_ VPWR VGND sg13g2_xnor2_1
X_21559_ _02176_ _02103_ _02105_ VPWR VGND sg13g2_xnor2_1
X_14100_ _05411_ _05410_ _05372_ VPWR VGND sg13g2_nand2b_1
XFILLER_5_824 VPWR VGND sg13g2_decap_4
XFILLER_126_538 VPWR VGND sg13g2_decap_8
X_15080_ _06354_ _06318_ _06352_ VPWR VGND sg13g2_xnor2_1
X_12292_ _03673_ _03672_ _03646_ VPWR VGND sg13g2_nand2b_1
XFILLER_5_846 VPWR VGND sg13g2_decap_4
XFILLER_106_0 VPWR VGND sg13g2_decap_4
X_14031_ _05344_ net763 net863 VPWR VGND sg13g2_nand2_1
XFILLER_5_879 VPWR VGND sg13g2_fill_1
XFILLER_107_763 VPWR VGND sg13g2_fill_2
X_23229_ net1428 VGND VPWR _00291_ u_LMS.w\[0\]\[23\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
XFILLER_79_102 VPWR VGND sg13g2_fill_1
XFILLER_95_617 VPWR VGND sg13g2_decap_8
XFILLER_79_168 VPWR VGND sg13g2_fill_1
X_18770_ _09857_ _09855_ _09856_ VPWR VGND sg13g2_nand2_1
X_15982_ _07224_ _07222_ _07223_ VPWR VGND sg13g2_xnor2_1
XFILLER_48_522 VPWR VGND sg13g2_fill_1
X_17721_ _08852_ _08853_ _08854_ VPWR VGND sg13g2_nor2b_1
XFILLER_76_842 VPWR VGND sg13g2_decap_8
X_14933_ _06214_ _06198_ _06216_ VPWR VGND sg13g2_xor2_1
XFILLER_36_706 VPWR VGND sg13g2_fill_2
X_17652_ _08785_ _08746_ _08747_ VPWR VGND sg13g2_xnor2_1
X_14864_ VGND VPWR net511 _06148_ _00150_ _06149_ sg13g2_a21oi_1
X_16603_ u_LMS.w\[4\]\[24\] _07793_ _07794_ VPWR VGND sg13g2_nor2_1
X_13815_ _05133_ _05139_ _05140_ VPWR VGND sg13g2_nor2b_1
X_17583_ _08716_ _08710_ _08715_ VPWR VGND sg13g2_xnor2_1
X_14795_ _06081_ _06047_ _06083_ VPWR VGND sg13g2_xor2_1
XFILLER_44_750 VPWR VGND sg13g2_fill_2
X_19322_ _10386_ net652 net153 VPWR VGND sg13g2_nand2_1
X_16534_ VGND VPWR net482 _07741_ _00227_ _07742_ sg13g2_a21oi_1
X_13746_ _05073_ _05042_ _05072_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_934 VPWR VGND sg13g2_decap_4
XFILLER_32_945 VPWR VGND sg13g2_fill_1
XFILLER_71_591 VPWR VGND sg13g2_decap_8
XFILLER_31_422 VPWR VGND sg13g2_decap_8
X_19253_ VGND VPWR net27 _10324_ _00363_ _10325_ sg13g2_a21oi_1
X_16465_ _07692_ u_FIR.x\[0\] net524 VPWR VGND sg13g2_nand2_1
X_13677_ _05005_ _04969_ _04972_ VPWR VGND sg13g2_nand2_1
X_18204_ _09307_ VPWR _09314_ VGND _09271_ _09305_ sg13g2_o21ai_1
X_15416_ _06679_ _06664_ _06681_ VPWR VGND sg13g2_xor2_1
X_12628_ VGND VPWR _03995_ _03993_ _03952_ sg13g2_or2_1
X_19184_ VGND VPWR _10269_ _10270_ _00349_ net926 sg13g2_a21oi_1
X_16396_ _07624_ VPWR _07627_ VGND _07609_ _07621_ sg13g2_o21ai_1
X_18135_ net671 net144 u_LMS.x_r\[2\]\[7\] _09245_ VPWR VGND net90 sg13g2_nand4_1
X_15347_ _06612_ _06575_ _06614_ VPWR VGND sg13g2_xor2_1
X_12559_ VGND VPWR net542 _03930_ _00063_ _03931_ sg13g2_a21oi_1
XFILLER_129_365 VPWR VGND sg13g2_decap_8
X_18066_ _09176_ net164 net670 net176 net669 VPWR VGND sg13g2_a22oi_1
X_15278_ _06547_ _06541_ _06545_ VPWR VGND sg13g2_xnor2_1
X_17017_ _08173_ _08166_ _08171_ VPWR VGND sg13g2_xnor2_1
X_14229_ _05537_ net822 u_FIR.w\[4\]\[3\] net807 u_FIR.w\[4\]\[2\] VPWR VGND sg13g2_a22oi_1
XFILLER_132_508 VPWR VGND sg13g2_decap_8
XFILLER_99_945 VPWR VGND sg13g2_fill_1
Xfanout608 u_LMS.x_r\[6\]\[6\] net608 VPWR VGND sg13g2_buf_1
XFILLER_101_906 VPWR VGND sg13g2_decap_4
Xfanout619 u_LMS.x_r\[6\]\[1\] net619 VPWR VGND sg13g2_buf_1
XFILLER_101_917 VPWR VGND sg13g2_decap_8
XFILLER_100_405 VPWR VGND sg13g2_fill_1
XFILLER_101_928 VPWR VGND sg13g2_fill_1
XFILLER_100_416 VPWR VGND sg13g2_fill_1
XFILLER_101_939 VPWR VGND sg13g2_fill_1
X_18968_ _10055_ _10052_ _10054_ VPWR VGND sg13g2_nand2_1
XFILLER_21_0 VPWR VGND sg13g2_decap_4
X_17919_ _08665_ VPWR _09052_ VGND _08632_ _08666_ sg13g2_o21ai_1
XFILLER_113_1021 VPWR VGND sg13g2_fill_2
XFILLER_39_544 VPWR VGND sg13g2_decap_8
X_18899_ VGND VPWR _09986_ _09984_ _09951_ sg13g2_or2_1
XFILLER_67_864 VPWR VGND sg13g2_fill_1
XFILLER_39_555 VPWR VGND sg13g2_fill_2
XFILLER_27_717 VPWR VGND sg13g2_decap_8
X_20930_ net2064 u_LMS.w\[6\]\[16\] _01570_ VPWR VGND sg13g2_xor2_1
XFILLER_93_160 VPWR VGND sg13g2_decap_4
XFILLER_66_385 VPWR VGND sg13g2_decap_8
XFILLER_27_739 VPWR VGND sg13g2_decap_8
XFILLER_81_322 VPWR VGND sg13g2_fill_2
X_20861_ net210 _01500_ net619 _01501_ VPWR VGND sg13g2_nand3_1
XFILLER_82_889 VPWR VGND sg13g2_decap_8
X_22600_ net458 u_debug_unit.sw_reset\[7\] _03058_ _00599_ VPWR VGND sg13g2_mux2_1
X_23580_ net981 VGND VPWR _00642_ coeff_force_packed\[23\] clknet_leaf_53_clkA sg13g2_dfrbpq_1
X_20792_ _01432_ net615 net245 VPWR VGND sg13g2_nand2_1
XFILLER_22_422 VPWR VGND sg13g2_decap_8
X_22531_ _03020_ u_LMS.count\[10\] _03019_ VPWR VGND sg13g2_xnor2_1
XFILLER_50_742 VPWR VGND sg13g2_decap_4
XFILLER_50_753 VPWR VGND sg13g2_fill_1
XFILLER_72_1060 VPWR VGND sg13g2_fill_1
XFILLER_22_477 VPWR VGND sg13g2_fill_1
XFILLER_10_628 VPWR VGND sg13g2_decap_8
X_22462_ VGND VPWR net449 _03238_ _00539_ _02980_ sg13g2_a21oi_1
X_21413_ _02021_ _02029_ _02030_ VPWR VGND sg13g2_nor2_1
X_23031__1160 VPWR VGND net1159 sg13g2_tiehi
X_22393_ net947 VPWR _02946_ VGND net433 net679 sg13g2_o21ai_1
XFILLER_108_538 VPWR VGND sg13g2_decap_8
XFILLER_120_1047 VPWR VGND sg13g2_decap_8
X_21344_ _03218_ _01960_ _01961_ VPWR VGND sg13g2_nor2_1
X_21275_ _01862_ _01889_ _01891_ _01892_ VPWR VGND sg13g2_nor3_1
XFILLER_78_38 VPWR VGND sg13g2_decap_8
X_23014_ net1185 VGND VPWR _00076_ u_FIR.sum\[1\]\[11\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
X_20226_ _00889_ _00875_ _00888_ VPWR VGND sg13g2_nand2_1
Xrebuffer1650 net2078 net1649 VPWR VGND sg13g2_buf_1
X_20157_ _11164_ _11157_ _00820_ VPWR VGND sg13g2_xor2_1
Xrebuffer1661 _02163_ net1660 VPWR VGND sg13g2_buf_1
XFILLER_131_596 VPWR VGND sg13g2_decap_8
XFILLER_76_127 VPWR VGND sg13g2_fill_2
X_20088_ _03241_ _03242_ net95 _11129_ VGND VPWR net103 sg13g2_nor4_2
X_11930_ VPWR _03351_ u_LMS.w\[0\]\[8\] VGND sg13g2_inv_1
XFILLER_85_672 VPWR VGND sg13g2_fill_1
XFILLER_73_812 VPWR VGND sg13g2_decap_8
XFILLER_45_525 VPWR VGND sg13g2_fill_2
XFILLER_27_42 VPWR VGND sg13g2_fill_2
X_11861_ VPWR _03282_ net714 VGND sg13g2_inv_1
X_13600_ _04930_ _04929_ _04926_ VPWR VGND sg13g2_nand2b_1
XFILLER_72_366 VPWR VGND sg13g2_decap_8
X_14580_ net836 net774 u_FIR.sum\[4\]\[5\] _05873_ VPWR VGND sg13g2_a21o_1
XFILLER_32_219 VPWR VGND sg13g2_fill_1
X_23778_ net995 VGND VPWR _00018_ u_spi_slave.bit_cnt\[3\] clknet_3_3__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_11792_ VPWR _03213_ u_LMS.count\[30\] VGND sg13g2_inv_1
XFILLER_60_539 VPWR VGND sg13g2_decap_4
X_13531_ _04863_ net752 net879 VPWR VGND sg13g2_nand2_1
X_22729_ VGND VPWR _07737_ net329 _00704_ _03082_ sg13g2_a21oi_1
XFILLER_40_230 VPWR VGND sg13g2_fill_2
X_16250_ _07415_ net800 _07485_ _07486_ VPWR VGND sg13g2_mux2_1
XFILLER_43_74 VPWR VGND sg13g2_decap_4
X_13462_ net1039 VPWR _04802_ VGND net547 u_FIR.sum\[2\]\[15\] sg13g2_o21ai_1
X_15201_ _06454_ _06471_ _06472_ VPWR VGND sg13g2_nor2b_1
X_12413_ _03790_ _03716_ _03789_ VPWR VGND sg13g2_nand2_1
X_16181_ _07415_ VPWR _07419_ VGND _07416_ _07417_ sg13g2_o21ai_1
X_13393_ _04734_ _04707_ _04736_ VPWR VGND sg13g2_xor2_1
X_15132_ _06373_ _06404_ _06405_ VPWR VGND sg13g2_nor2_1
X_12344_ _03723_ _03682_ _03684_ VPWR VGND sg13g2_nand2_1
XFILLER_127_858 VPWR VGND sg13g2_fill_1
X_19940_ _10981_ _10958_ _10973_ VPWR VGND sg13g2_xnor2_1
X_15063_ _06330_ VPWR _06337_ VGND _06301_ _06328_ sg13g2_o21ai_1
X_12275_ _03653_ _03655_ _03656_ VPWR VGND sg13g2_nor2_1
X_14014_ _05328_ net761 net892 VPWR VGND sg13g2_nand2_1
XFILLER_4_35 VPWR VGND sg13g2_decap_8
X_19871_ _10918_ _10780_ _10782_ VPWR VGND sg13g2_xnor2_1
X_18822_ _09878_ _09906_ _09908_ _09909_ VPWR VGND sg13g2_nor3_1
XFILLER_1_860 VPWR VGND sg13g2_fill_1
XFILLER_95_414 VPWR VGND sg13g2_decap_4
X_18753_ _09827_ _09839_ _09840_ VPWR VGND sg13g2_and2_1
XFILLER_110_769 VPWR VGND sg13g2_fill_1
X_15965_ _07207_ net273 _07208_ VPWR VGND sg13g2_xor2_1
X_17704_ _08797_ _08836_ _08837_ VPWR VGND sg13g2_nor2_1
X_14916_ VGND VPWR _06181_ _06191_ _06199_ _06190_ sg13g2_a21oi_1
XFILLER_48_363 VPWR VGND sg13g2_decap_8
X_18684_ _09769_ _09763_ _09771_ VPWR VGND sg13g2_xor2_1
X_15896_ _07117_ _07142_ _07143_ VPWR VGND sg13g2_nor2b_1
X_17635_ _08768_ _08622_ _08754_ VPWR VGND sg13g2_xnor2_1
XFILLER_36_558 VPWR VGND sg13g2_decap_4
X_14847_ _06133_ net269 _06131_ VPWR VGND sg13g2_xnor2_1
XFILLER_1_1031 VPWR VGND sg13g2_decap_8
X_17566_ _08698_ VPWR _08699_ VGND _08695_ _08697_ sg13g2_o21ai_1
X_14778_ _06065_ net269 _06066_ VPWR VGND sg13g2_xor2_1
XFILLER_56_1033 VPWR VGND sg13g2_decap_8
X_19305_ net153 VPWR _10369_ VGND net645 net646 sg13g2_o21ai_1
XFILLER_56_1044 VPWR VGND sg13g2_fill_1
X_16517_ u_LMS.w\[1\]\[23\] u_LMS.w\[1\]\[22\] u_LMS.w\[1\]\[24\] _07729_ VPWR VGND
+ u_LMS.w\[1\]\[21\] sg13g2_nand4_1
X_13729_ _05056_ net825 _05055_ VPWR VGND sg13g2_nand2_1
X_17497_ _08598_ VPWR _08630_ VGND _03272_ _08606_ sg13g2_o21ai_1
X_19236_ net30 VPWR _10312_ VGND net28 _10311_ sg13g2_o21ai_1
X_16448_ _07675_ _07666_ _07677_ VPWR VGND sg13g2_nor2b_1
XFILLER_32_797 VPWR VGND sg13g2_fill_2
XFILLER_31_296 VPWR VGND sg13g2_fill_2
X_19167_ _10254_ u_LMS.w\[3\]\[22\] net67 VPWR VGND sg13g2_xnor2_1
X_16379_ VGND VPWR _07584_ _07592_ _07611_ _07599_ sg13g2_a21oi_1
X_18118_ _09228_ net79 net671 net98 net669 VPWR VGND sg13g2_a22oi_1
XFILLER_69_0 VPWR VGND sg13g2_decap_8
X_23155__1557 VPWR VGND net1556 sg13g2_tiehi
X_19098_ _10185_ _10137_ _10139_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_492 VPWR VGND sg13g2_decap_8
XFILLER_117_368 VPWR VGND sg13g2_decap_8
X_18049_ VGND VPWR net37 _09162_ _00321_ _09163_ sg13g2_a21oi_1
X_21060_ _01692_ _01642_ _01691_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_349 VPWR VGND sg13g2_decap_8
Xfanout405 net406 net405 VPWR VGND sg13g2_buf_1
Xfanout416 _03357_ net416 VPWR VGND sg13g2_buf_1
X_20011_ _11052_ _10980_ _10981_ VPWR VGND sg13g2_xnor2_1
Xfanout427 _03218_ net427 VPWR VGND sg13g2_buf_1
Xfanout438 net439 net438 VPWR VGND sg13g2_buf_1
Xfanout449 net451 net449 VPWR VGND sg13g2_buf_1
XFILLER_86_458 VPWR VGND sg13g2_decap_8
XFILLER_58_149 VPWR VGND sg13g2_decap_8
XFILLER_39_352 VPWR VGND sg13g2_decap_8
X_21962_ _02556_ _02554_ _02555_ VPWR VGND sg13g2_xnor2_1
XFILLER_55_823 VPWR VGND sg13g2_decap_8
XFILLER_39_374 VPWR VGND sg13g2_decap_4
X_23701_ net1509 VGND VPWR _00763_ u_p2s_output.reg_sh\[2\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
X_20913_ _01224_ _01552_ _01221_ _01553_ VPWR VGND sg13g2_nand3_1
X_21893_ _02458_ _02484_ _02486_ _02487_ VPWR VGND sg13g2_nor3_1
X_23632_ net956 VGND VPWR _00694_ u_debug_unit.error_signal_sync\[6\] clknet_leaf_53_clkA
+ sg13g2_dfrbpq_1
XFILLER_14_208 VPWR VGND sg13g2_fill_1
X_20844_ _01484_ net621 net210 VPWR VGND sg13g2_nand2_1
XFILLER_70_848 VPWR VGND sg13g2_decap_8
XFILLER_23_720 VPWR VGND sg13g2_decap_8
Xfanout12 net12 _02249_ VPWR VGND sg13g2_buf_4
X_23563_ net956 VGND VPWR _00625_ coeff_force_packed\[8\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
Xfanout23 _01071_ net23 VPWR VGND sg13g2_buf_1
X_20775_ _01415_ net618 net171 VPWR VGND sg13g2_nand2_1
Xfanout34 _09681_ net34 VPWR VGND sg13g2_buf_2
Xfanout45 _08495_ net45 VPWR VGND sg13g2_buf_2
Xfanout56 _09678_ net56 VPWR VGND sg13g2_buf_1
X_22514_ u_LMS.count\[4\] _03007_ _03009_ VPWR VGND sg13g2_and2_1
Xfanout67 net68 net67 VPWR VGND sg13g2_buf_2
XFILLER_22_263 VPWR VGND sg13g2_fill_1
X_23494_ net1433 VGND VPWR _00556_ u_LMS.x_r\[8\]\[5\] clknet_leaf_7_clkA sg13g2_dfrbpq_1
Xfanout78 _09067_ net78 VPWR VGND sg13g2_buf_2
Xfanout89 net89 _07992_ VPWR VGND sg13g2_buf_4
XFILLER_10_447 VPWR VGND sg13g2_fill_1
X_22445_ net959 VPWR _02972_ VGND net443 net627 sg13g2_o21ai_1
XFILLER_13_77 VPWR VGND sg13g2_decap_8
XFILLER_109_836 VPWR VGND sg13g2_fill_2
XFILLER_108_335 VPWR VGND sg13g2_fill_2
XFILLER_109_858 VPWR VGND sg13g2_fill_1
X_22376_ VGND VPWR net456 _03281_ _00496_ _02937_ sg13g2_a21oi_1
XFILLER_129_77 VPWR VGND sg13g2_decap_8
X_21327_ _01944_ _01936_ _01943_ VPWR VGND sg13g2_xnor2_1
XFILLER_89_59 VPWR VGND sg13g2_fill_2
XFILLER_124_828 VPWR VGND sg13g2_decap_8
X_12060_ _03474_ net285 sys_enable_bus\[5\] net295 coeff_force_packed\[40\] VPWR VGND
+ sg13g2_a22oi_1
XFILLER_1_112 VPWR VGND sg13g2_decap_8
X_21258_ _01875_ net111 net598 net132 net596 VPWR VGND sg13g2_a22oi_1
X_23720__1383 VPWR VGND net1382 sg13g2_tiehi
Xrebuffer2170 _02635_ net2169 VPWR VGND sg13g2_buf_1
X_20209_ _00872_ _00869_ _00871_ VPWR VGND sg13g2_nand2_1
XFILLER_77_403 VPWR VGND sg13g2_decap_8
XFILLER_77_414 VPWR VGND sg13g2_fill_1
XFILLER_131_360 VPWR VGND sg13g2_decap_8
X_21189_ _01806_ _01805_ _01787_ VPWR VGND sg13g2_nand2b_1
Xfanout950 net951 net950 VPWR VGND sg13g2_buf_1
Xfanout961 net970 net961 VPWR VGND sg13g2_buf_1
Xfanout972 net973 net972 VPWR VGND sg13g2_buf_1
Xfanout983 net984 net983 VPWR VGND sg13g2_buf_1
Xfanout994 net996 net994 VPWR VGND sg13g2_buf_1
XFILLER_46_801 VPWR VGND sg13g2_fill_2
X_15750_ _07001_ _06997_ _07000_ VPWR VGND sg13g2_xnor2_1
X_12962_ _04320_ _04318_ _04319_ _04254_ net730 VPWR VGND sg13g2_a22oi_1
X_14701_ VPWR _05991_ _05990_ VGND sg13g2_inv_1
X_11913_ VPWR _03334_ u_LMS.w\[3\]\[14\] VGND sg13g2_inv_1
X_15681_ _06932_ _06896_ _06934_ VPWR VGND sg13g2_xor2_1
X_12893_ _04253_ _04221_ _04224_ VPWR VGND sg13g2_nand2_1
X_17420_ net364 VPWR _08561_ VGND u_LMS.w\[0\]\[4\] net382 sg13g2_o21ai_1
X_14632_ VGND VPWR _05883_ _05886_ _05924_ _05922_ sg13g2_a21oi_1
X_11844_ VPWR _03265_ net680 VGND sg13g2_inv_1
XFILLER_61_837 VPWR VGND sg13g2_decap_4
XFILLER_45_388 VPWR VGND sg13g2_decap_4
XFILLER_60_314 VPWR VGND sg13g2_decap_8
XFILLER_127_1009 VPWR VGND sg13g2_decap_8
XFILLER_61_859 VPWR VGND sg13g2_decap_8
X_17351_ VGND VPWR _08504_ _08505_ _00281_ net936 sg13g2_a21oi_1
X_14563_ _05826_ _05855_ _05856_ VPWR VGND sg13g2_nor2_1
X_16302_ _07537_ _07536_ _07501_ VPWR VGND sg13g2_nand2b_1
X_13514_ VGND VPWR _04847_ _04846_ _04822_ sg13g2_or2_1
XFILLER_9_212 VPWR VGND sg13g2_fill_2
XFILLER_41_572 VPWR VGND sg13g2_decap_8
X_17282_ VGND VPWR u_LMS.w\[0\]\[4\] _08428_ _08438_ _08437_ sg13g2_a21oi_1
X_14494_ net876 net773 u_FIR.sum\[4\]\[2\] _05790_ VPWR VGND sg13g2_a21o_1
XFILLER_41_594 VPWR VGND sg13g2_decap_8
XFILLER_9_245 VPWR VGND sg13g2_fill_1
X_19021_ _10108_ net260 net661 net239 net663 VPWR VGND sg13g2_a22oi_1
X_23110__1627 VPWR VGND net1626 sg13g2_tiehi
X_16233_ _07462_ _07469_ _07470_ VPWR VGND sg13g2_nor2b_1
X_13445_ _04742_ _04643_ _04772_ _04785_ VPWR VGND sg13g2_a21o_1
Xclkload15 clkload15/Y clknet_leaf_65_clkA VPWR VGND sg13g2_inv_8
Xclkload26 clkload26/Y clknet_leaf_52_clkA VPWR VGND sg13g2_inv_2
XFILLER_10_992 VPWR VGND sg13g2_fill_1
Xclkload37 VPWR clkload37/Y clknet_leaf_9_clkA VGND sg13g2_inv_1
X_16164_ VGND VPWR _07365_ _07393_ _07402_ _07395_ sg13g2_a21oi_1
X_13376_ _04712_ _04718_ _04719_ VPWR VGND sg13g2_nor2b_1
XFILLER_62_7 VPWR VGND sg13g2_decap_4
XFILLER_127_655 VPWR VGND sg13g2_fill_1
Xclkload48 VPWR clkload48/Y clknet_leaf_21_clkA VGND sg13g2_inv_1
XFILLER_5_440 VPWR VGND sg13g2_decap_8
X_15115_ _06387_ _06383_ _06388_ VPWR VGND sg13g2_xor2_1
X_12327_ _03678_ _03706_ _03707_ VPWR VGND sg13g2_nor2b_1
X_16095_ _07335_ _07294_ _07334_ VPWR VGND sg13g2_xnor2_1
XFILLER_86_1048 VPWR VGND sg13g2_decap_8
XFILLER_126_176 VPWR VGND sg13g2_fill_1
XFILLER_86_1059 VPWR VGND sg13g2_fill_2
X_19923_ _10964_ net626 net86 VPWR VGND sg13g2_nand2_1
X_15046_ net846 u_FIR.sum\[5\]\[4\] net783 _06321_ VPWR VGND sg13g2_nand3_1
X_23151__1563 VPWR VGND net1562 sg13g2_tiehi
X_12258_ _03638_ _03616_ _03640_ VPWR VGND sg13g2_xor2_1
XFILLER_79_81 VPWR VGND sg13g2_fill_2
X_19854_ _10905_ net385 _10854_ VPWR VGND sg13g2_nand2_1
X_12189_ _00037_ VPWR _03578_ VGND net428 _03572_ sg13g2_o21ai_1
XFILLER_69_959 VPWR VGND sg13g2_decap_4
XFILLER_68_425 VPWR VGND sg13g2_fill_2
X_18805_ _09892_ net107 net661 net129 net659 VPWR VGND sg13g2_a22oi_1
X_19785_ _10849_ u_LMS.w\[4\]\[24\] net66 VPWR VGND sg13g2_nand2_1
X_23004__1201 VPWR VGND net1200 sg13g2_tiehi
X_23166__1541 VPWR VGND net1540 sg13g2_tiehi
X_16997_ _03281_ net417 _08153_ VPWR VGND sg13g2_nor2_1
X_18736_ _09823_ _09822_ _09805_ VPWR VGND sg13g2_nand2b_1
XFILLER_83_428 VPWR VGND sg13g2_fill_1
X_15948_ _07191_ _07171_ _07192_ VPWR VGND sg13g2_xor2_1
XFILLER_77_992 VPWR VGND sg13g2_fill_2
XFILLER_36_300 VPWR VGND sg13g2_decap_8
XFILLER_110_1013 VPWR VGND sg13g2_decap_8
XFILLER_95_299 VPWR VGND sg13g2_decap_8
XFILLER_76_491 VPWR VGND sg13g2_fill_2
X_18667_ _09754_ _09755_ _00347_ VPWR VGND sg13g2_nor2_1
X_15879_ net275 _07124_ _07126_ VPWR VGND sg13g2_and2_1
XFILLER_52_804 VPWR VGND sg13g2_decap_8
XFILLER_93_1019 VPWR VGND sg13g2_fill_1
X_17618_ _08751_ _08748_ _08749_ VPWR VGND sg13g2_xnor2_1
X_18598_ net558 coeff_force_packed\[20\] _09702_ VPWR VGND sg13g2_and2_1
XFILLER_36_399 VPWR VGND sg13g2_decap_4
XFILLER_24_539 VPWR VGND sg13g2_decap_8
X_17549_ _08682_ _08680_ _08681_ VPWR VGND sg13g2_nand2_1
X_20560_ _01197_ net117 _01200_ VPWR VGND sg13g2_xor2_1
XFILLER_20_745 VPWR VGND sg13g2_fill_2
Xclkload9 clknet_4_11_0_clkA clkload9/X VPWR VGND sg13g2_buf_8
Xclkbuf_3_7__f_spi_sclk clknet_3_7__leaf_spi_sclk clknet_0_spi_sclk VPWR VGND sg13g2_buf_16
X_19219_ _10298_ u_LMS.w\[3\]\[20\] net1649 VPWR VGND sg13g2_xnor2_1
X_20491_ VGND VPWR net51 _01135_ _01136_ _01119_ sg13g2_a21oi_1
X_22230_ VPWR _02824_ net2170 VGND sg13g2_inv_1
XFILLER_118_655 VPWR VGND sg13g2_fill_2
XFILLER_106_806 VPWR VGND sg13g2_fill_1
XFILLER_118_677 VPWR VGND sg13g2_fill_1
X_22161_ _02755_ _02735_ _02754_ VPWR VGND sg13g2_xnor2_1
XFILLER_117_165 VPWR VGND sg13g2_fill_1
X_21112_ _01732_ _01615_ _01617_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_124 VPWR VGND sg13g2_decap_8
XFILLER_105_349 VPWR VGND sg13g2_decap_4
X_22092_ _02686_ _02677_ _02681_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_157 VPWR VGND sg13g2_decap_8
Xfanout202 net207 net202 VPWR VGND sg13g2_buf_2
X_21043_ _01635_ _01636_ _01569_ _01678_ VPWR VGND sg13g2_nand3_1
Xfanout213 net214 net213 VPWR VGND sg13g2_buf_2
Xfanout224 net234 net224 VPWR VGND sg13g2_buf_1
Xfanout235 _07917_ net235 VPWR VGND sg13g2_buf_1
XFILLER_113_371 VPWR VGND sg13g2_fill_2
Xfanout246 net247 net246 VPWR VGND sg13g2_buf_1
XFILLER_115_46 VPWR VGND sg13g2_fill_1
Xfanout257 net259 net257 VPWR VGND sg13g2_buf_1
Xfanout268 _06102_ net268 VPWR VGND sg13g2_buf_1
X_23344__1258 VPWR VGND net1257 sg13g2_tiehi
Xfanout279 _05570_ net279 VPWR VGND sg13g2_buf_1
XFILLER_28_801 VPWR VGND sg13g2_fill_1
XFILLER_68_992 VPWR VGND sg13g2_fill_1
X_22994_ net1215 VGND VPWR _00056_ u_FIR.sum\[0\]\[6\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
XFILLER_86_299 VPWR VGND sg13g2_decap_4
XFILLER_39_182 VPWR VGND sg13g2_fill_1
XFILLER_28_856 VPWR VGND sg13g2_fill_2
XFILLER_27_322 VPWR VGND sg13g2_decap_4
X_21945_ _02539_ _02535_ _02537_ VPWR VGND sg13g2_xnor2_1
XFILLER_83_962 VPWR VGND sg13g2_fill_1
XFILLER_55_664 VPWR VGND sg13g2_fill_2
XFILLER_43_804 VPWR VGND sg13g2_decap_8
XFILLER_54_141 VPWR VGND sg13g2_decap_8
XFILLER_54_152 VPWR VGND sg13g2_fill_2
XFILLER_131_67 VPWR VGND sg13g2_decap_8
X_21876_ _02469_ _02436_ _02470_ VPWR VGND sg13g2_xor2_1
XFILLER_27_399 VPWR VGND sg13g2_fill_2
X_23385__1194 VPWR VGND net1193 sg13g2_tiehi
X_23615_ net965 VGND VPWR _00677_ coeff_force_packed\[54\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
X_20827_ _01467_ _01465_ _01466_ VPWR VGND sg13g2_nand2_1
XFILLER_51_870 VPWR VGND sg13g2_fill_2
XFILLER_126_1042 VPWR VGND sg13g2_decap_8
X_23546_ net1010 VGND VPWR _00608_ sys_enable clknet_leaf_17_clkA sg13g2_dfrbpq_1
XFILLER_24_65 VPWR VGND sg13g2_fill_1
X_20758_ _01395_ _01394_ _01398_ VPWR VGND sg13g2_xor2_1
XFILLER_129_909 VPWR VGND sg13g2_fill_1
XFILLER_50_380 VPWR VGND sg13g2_fill_1
XFILLER_24_98 VPWR VGND sg13g2_fill_2
X_23236__1417 VPWR VGND net1416 sg13g2_tiehi
X_23477_ net1493 VGND VPWR _00539_ u_LMS.x_r\[6\]\[4\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
XFILLER_109_611 VPWR VGND sg13g2_fill_2
XFILLER_10_255 VPWR VGND sg13g2_decap_8
X_20689_ _01321_ VPWR _01329_ VGND _01322_ _01328_ sg13g2_o21ai_1
X_23505__1395 VPWR VGND net1394 sg13g2_tiehi
X_13230_ _04577_ _04558_ _04575_ VPWR VGND sg13g2_xnor2_1
X_22428_ VGND VPWR net437 _03255_ _00522_ _02963_ sg13g2_a21oi_1
X_23100__1057 VPWR VGND net1056 sg13g2_tiehi
XFILLER_109_677 VPWR VGND sg13g2_decap_4
X_13161_ _04510_ _04477_ _04508_ VPWR VGND sg13g2_xnor2_1
X_22359_ net1027 VPWR _02929_ VGND net454 u_LMS.x_r\[0\]\[1\] sg13g2_o21ai_1
XFILLER_40_86 VPWR VGND sg13g2_decap_8
XFILLER_3_911 VPWR VGND sg13g2_decap_8
XFILLER_40_97 VPWR VGND sg13g2_fill_2
XFILLER_108_187 VPWR VGND sg13g2_fill_1
X_12112_ _03523_ net294 debug_load_bus\[2\] net295 coeff_force_packed\[37\] VPWR VGND
+ sg13g2_a22oi_1
XFILLER_3_944 VPWR VGND sg13g2_fill_2
XFILLER_123_124 VPWR VGND sg13g2_fill_2
X_13092_ _04429_ VPWR _04442_ VGND _04424_ _04427_ sg13g2_o21ai_1
XFILLER_112_809 VPWR VGND sg13g2_fill_2
XFILLER_105_872 VPWR VGND sg13g2_fill_1
X_16920_ _07963_ _07961_ _08076_ VPWR VGND sg13g2_xor2_1
X_12043_ _03455_ _03456_ net328 _03458_ VPWR VGND _03457_ sg13g2_nand4_1
XFILLER_77_200 VPWR VGND sg13g2_fill_2
XFILLER_49_51 VPWR VGND sg13g2_decap_4
XFILLER_77_211 VPWR VGND sg13g2_decap_4
XFILLER_132_691 VPWR VGND sg13g2_fill_1
X_16851_ _08007_ net705 net86 VPWR VGND sg13g2_nand2_1
XFILLER_49_95 VPWR VGND sg13g2_decap_4
XFILLER_120_864 VPWR VGND sg13g2_fill_2
XFILLER_1_14 VPWR VGND sg13g2_decap_8
Xfanout780 u_FIR.w\[2\]\[2\] net780 VPWR VGND sg13g2_buf_1
XFILLER_93_715 VPWR VGND sg13g2_decap_4
Xfanout791 u_FIR.w\[1\]\[0\] net791 VPWR VGND sg13g2_buf_1
X_15802_ VGND VPWR net495 _07050_ _00186_ _07051_ sg13g2_a21oi_1
XFILLER_37_108 VPWR VGND sg13g2_decap_4
X_19570_ _10567_ _10633_ _10634_ VPWR VGND sg13g2_nor2b_1
XFILLER_92_214 VPWR VGND sg13g2_decap_8
XFILLER_59_992 VPWR VGND sg13g2_fill_2
X_16782_ _07914_ _07934_ _07938_ VPWR VGND sg13g2_xor2_1
X_13994_ _05307_ _05308_ _05309_ VPWR VGND sg13g2_nor2_1
XFILLER_105_90 VPWR VGND sg13g2_fill_2
X_18521_ _09630_ VPWR _09631_ VGND _03338_ _09608_ sg13g2_o21ai_1
X_15733_ net847 net784 _06982_ _06984_ VPWR VGND sg13g2_a21o_1
XFILLER_19_867 VPWR VGND sg13g2_decap_8
X_12945_ _04304_ _04297_ _04302_ VPWR VGND sg13g2_xnor2_1
X_18452_ _09356_ _09561_ _09562_ VPWR VGND sg13g2_nor2b_1
X_15664_ _06917_ _06900_ _06916_ VPWR VGND sg13g2_nand2_1
XFILLER_45_174 VPWR VGND sg13g2_decap_4
X_12876_ _04229_ _04236_ _04237_ VPWR VGND sg13g2_nor2b_1
X_17403_ _08489_ VPWR _08547_ VGND _08487_ _08488_ sg13g2_o21ai_1
X_14615_ _05906_ _05867_ _05907_ VPWR VGND sg13g2_xor2_1
XFILLER_61_667 VPWR VGND sg13g2_fill_1
X_18383_ _09491_ _09492_ _09493_ VPWR VGND sg13g2_nor2_1
X_11827_ VPWR _03248_ net647 VGND sg13g2_inv_1
XFILLER_21_509 VPWR VGND sg13g2_decap_8
X_15595_ _06848_ _06812_ _06850_ VPWR VGND sg13g2_xor2_1
XFILLER_60_155 VPWR VGND sg13g2_fill_1
XFILLER_33_369 VPWR VGND sg13g2_decap_4
XFILLER_60_166 VPWR VGND sg13g2_fill_1
XFILLER_14_561 VPWR VGND sg13g2_fill_2
XFILLER_60_177 VPWR VGND sg13g2_fill_1
X_17334_ _08487_ _08488_ _08489_ _08490_ VPWR VGND sg13g2_or3_1
X_14546_ _05839_ _05836_ _05840_ VPWR VGND sg13g2_xor2_1
XFILLER_81_71 VPWR VGND sg13g2_fill_1
XFILLER_60_199 VPWR VGND sg13g2_decap_4
XFILLER_53_1058 VPWR VGND sg13g2_fill_2
X_17265_ _08421_ _08344_ _08346_ VPWR VGND sg13g2_xnor2_1
X_14477_ VGND VPWR net513 _05774_ _00137_ _05775_ sg13g2_a21oi_1
XFILLER_128_931 VPWR VGND sg13g2_decap_4
X_19004_ _10091_ _10068_ _10090_ VPWR VGND sg13g2_nand2_1
XFILLER_128_942 VPWR VGND sg13g2_fill_1
X_16216_ _07453_ _07447_ _07451_ VPWR VGND sg13g2_xnor2_1
X_13428_ _04768_ net283 _04769_ VPWR VGND sg13g2_xor2_1
XFILLER_127_430 VPWR VGND sg13g2_fill_1
X_17196_ _08281_ VPWR _08352_ VGND _08351_ _08350_ sg13g2_o21ai_1
X_16147_ _07339_ VPWR _07386_ VGND _07336_ _07340_ sg13g2_o21ai_1
X_13359_ _04701_ _04675_ _04703_ VPWR VGND sg13g2_xor2_1
XFILLER_127_474 VPWR VGND sg13g2_decap_8
X_16078_ _07317_ _07266_ _07319_ VPWR VGND sg13g2_xor2_1
X_19906_ _10946_ _10940_ _10947_ VPWR VGND sg13g2_nor2b_1
X_15029_ _06305_ _06302_ _06303_ VPWR VGND sg13g2_xnor2_1
XFILLER_111_831 VPWR VGND sg13g2_decap_8
XFILLER_68_222 VPWR VGND sg13g2_fill_2
XFILLER_111_853 VPWR VGND sg13g2_fill_1
X_19837_ _10892_ _10890_ _10891_ VPWR VGND sg13g2_xnor2_1
XFILLER_111_864 VPWR VGND sg13g2_fill_1
XFILLER_60_1029 VPWR VGND sg13g2_fill_1
X_19768_ _10831_ VPWR _10832_ VGND _10810_ _10741_ sg13g2_o21ai_1
Xinput2 spi_mosi net2 VPWR VGND sg13g2_buf_1
X_18719_ _09774_ VPWR _09806_ VGND _03256_ _09782_ sg13g2_o21ai_1
XFILLER_83_258 VPWR VGND sg13g2_decap_4
XFILLER_71_409 VPWR VGND sg13g2_fill_2
X_19699_ _10763_ _10713_ _10714_ VPWR VGND sg13g2_xnor2_1
XFILLER_36_141 VPWR VGND sg13g2_fill_2
XFILLER_37_675 VPWR VGND sg13g2_fill_1
X_21730_ VGND VPWR net49 _02326_ _02327_ net10 sg13g2_a21oi_1
X_21661_ VGND VPWR _02271_ _02272_ _00446_ net931 sg13g2_a21oi_1
XFILLER_51_166 VPWR VGND sg13g2_fill_2
X_23400_ net1148 VGND VPWR _00462_ u_LMS.w\[7\]\[10\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
X_20612_ _01246_ _01251_ _01252_ VPWR VGND sg13g2_nor2b_1
X_21592_ _02176_ u_LMS.w\[7\]\[9\] _02209_ VPWR VGND sg13g2_xor2_1
X_23331_ net1270 VGND VPWR _00393_ u_LMS.w\[4\]\[10\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
X_20543_ _01180_ _01182_ _01183_ VPWR VGND sg13g2_nor2_1
XFILLER_20_564 VPWR VGND sg13g2_decap_4
X_23262_ net1369 VGND VPWR _00324_ u_LMS.w\[1\]\[10\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
XFILLER_118_430 VPWR VGND sg13g2_decap_4
X_20474_ _01123_ _01004_ _01006_ VPWR VGND sg13g2_xnor2_1
XFILLER_106_603 VPWR VGND sg13g2_decap_8
X_22213_ _02807_ _02806_ _02772_ VPWR VGND sg13g2_nand2b_1
XFILLER_119_986 VPWR VGND sg13g2_fill_1
XFILLER_106_614 VPWR VGND sg13g2_fill_2
X_23193_ net1492 VGND VPWR _00255_ u_FIR.w\[5\]\[3\] clknet_leaf_35_clkA sg13g2_dfrbpq_1
XFILLER_3_218 VPWR VGND sg13g2_fill_2
XFILLER_3_229 VPWR VGND sg13g2_fill_2
XFILLER_106_647 VPWR VGND sg13g2_fill_1
X_22144_ _02405_ _02415_ _02386_ _02738_ VPWR VGND sg13g2_nand3_1
XFILLER_0_903 VPWR VGND sg13g2_fill_2
XFILLER_0_914 VPWR VGND sg13g2_fill_2
XFILLER_105_179 VPWR VGND sg13g2_fill_2
XFILLER_126_56 VPWR VGND sg13g2_decap_8
XFILLER_120_105 VPWR VGND sg13g2_fill_1
X_22075_ _02662_ VPWR _02669_ VGND _02657_ _02663_ sg13g2_o21ai_1
XFILLER_121_639 VPWR VGND sg13g2_fill_2
Xfanout1008 net1009 net1008 VPWR VGND sg13g2_buf_1
Xfanout1019 net1021 net1019 VPWR VGND sg13g2_buf_1
X_21026_ _01628_ _01627_ _01665_ VPWR VGND sg13g2_xor2_1
XFILLER_102_886 VPWR VGND sg13g2_decap_4
XFILLER_75_748 VPWR VGND sg13g2_fill_2
XFILLER_101_396 VPWR VGND sg13g2_decap_8
XFILLER_19_87 VPWR VGND sg13g2_decap_4
XFILLER_55_450 VPWR VGND sg13g2_decap_8
XFILLER_55_461 VPWR VGND sg13g2_decap_8
XFILLER_71_921 VPWR VGND sg13g2_fill_1
XFILLER_35_20 VPWR VGND sg13g2_decap_8
X_12730_ _04094_ net731 net869 VPWR VGND sg13g2_nand2_1
X_21928_ _02522_ net578 net222 VPWR VGND sg13g2_nand2_1
X_23124__1604 VPWR VGND net1603 sg13g2_tiehi
XFILLER_70_420 VPWR VGND sg13g2_fill_2
XFILLER_82_291 VPWR VGND sg13g2_decap_8
XFILLER_15_347 VPWR VGND sg13g2_fill_1
X_12661_ VGND VPWR _04027_ _04025_ _03994_ sg13g2_or2_1
X_21859_ _02453_ _02450_ _02451_ VPWR VGND sg13g2_xnor2_1
XFILLER_43_678 VPWR VGND sg13g2_fill_2
XFILLER_35_86 VPWR VGND sg13g2_decap_8
XFILLER_24_870 VPWR VGND sg13g2_fill_1
X_14400_ _05676_ _05702_ _05703_ VPWR VGND sg13g2_nor2b_1
X_15380_ VGND VPWR _06646_ _06644_ _06643_ sg13g2_or2_1
X_12592_ _03959_ _03957_ _03945_ _03961_ VPWR VGND sg13g2_a21o_1
X_14331_ VGND VPWR _05604_ _05615_ _05636_ _05623_ sg13g2_a21oi_1
X_23529_ net1305 VGND VPWR _00591_ u_LMS.toggle clknet_leaf_58_clkA sg13g2_dfrbpq_1
XFILLER_7_502 VPWR VGND sg13g2_decap_8
X_17050_ _08203_ _08198_ _08206_ VPWR VGND sg13g2_xor2_1
X_14262_ _05538_ _05568_ _05569_ VPWR VGND sg13g2_nor2_1
XFILLER_13_1042 VPWR VGND sg13g2_decap_8
X_16001_ _07242_ net797 net886 VPWR VGND sg13g2_nand2_1
X_13213_ _04560_ net741 net855 VPWR VGND sg13g2_nand2_1
XFILLER_7_579 VPWR VGND sg13g2_decap_8
XFILLER_125_923 VPWR VGND sg13g2_decap_4
X_14193_ _05500_ _05501_ _05502_ VPWR VGND sg13g2_nor2b_1
XFILLER_124_400 VPWR VGND sg13g2_decap_8
XFILLER_124_411 VPWR VGND sg13g2_fill_1
X_13144_ _04493_ _04486_ _04492_ VPWR VGND sg13g2_nand2_1
XFILLER_124_444 VPWR VGND sg13g2_fill_2
X_23198__1485 VPWR VGND net1484 sg13g2_tiehi
X_17952_ net78 u_LMS.w\[1\]\[23\] _09085_ VPWR VGND sg13g2_xor2_1
X_13075_ net855 net747 u_FIR.sum\[1\]\[4\] _04426_ VPWR VGND sg13g2_a21o_1
XFILLER_105_680 VPWR VGND sg13g2_decap_8
XFILLER_78_531 VPWR VGND sg13g2_decap_8
X_16903_ _08048_ _08058_ _08059_ VPWR VGND sg13g2_and2_1
X_12026_ _03443_ net286 u_debug_unit.sw_reset\[7\] net288 u_debug_unit.force_w8\[7\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_104_190 VPWR VGND sg13g2_decap_4
X_17883_ _09016_ _03346_ _09003_ VPWR VGND sg13g2_xnor2_1
XFILLER_25_7 VPWR VGND sg13g2_decap_4
XFILLER_93_501 VPWR VGND sg13g2_decap_8
X_19622_ _10686_ _10683_ _10685_ VPWR VGND sg13g2_nand2_1
XFILLER_93_512 VPWR VGND sg13g2_fill_1
X_16834_ _07952_ _07989_ _07968_ _07990_ VPWR VGND sg13g2_mux2_1
X_19553_ _10616_ _10613_ _10617_ VPWR VGND sg13g2_xor2_1
XFILLER_47_962 VPWR VGND sg13g2_fill_2
X_16765_ _07921_ _07920_ _07918_ VPWR VGND sg13g2_xnor2_1
X_13977_ net905 net765 u_FIR.sum\[3\]\[0\] _05294_ VPWR VGND sg13g2_a21o_1
XFILLER_47_973 VPWR VGND sg13g2_fill_1
X_18504_ VGND VPWR _09524_ _09613_ _09614_ _09535_ sg13g2_a21oi_1
X_15716_ _06966_ _06938_ _06968_ VPWR VGND sg13g2_xor2_1
XFILLER_19_697 VPWR VGND sg13g2_decap_8
X_19484_ _10548_ _10545_ _10546_ VPWR VGND sg13g2_xnor2_1
X_12928_ _04287_ u_FIR.w\[7\]\[6\] net409 VPWR VGND sg13g2_nand2_1
X_16696_ VGND VPWR u_LMS.w\[7\]\[16\] _07852_ _07862_ _07853_ sg13g2_a21oi_1
X_18435_ _09545_ _09496_ _09497_ VPWR VGND sg13g2_xnor2_1
X_15647_ _06874_ VPWR _06900_ VGND _06826_ _06866_ sg13g2_o21ai_1
X_12859_ _03360_ net857 _04220_ VPWR VGND sg13g2_nor2_1
X_18366_ VGND VPWR _09473_ _09475_ _09476_ _09472_ sg13g2_a21oi_1
XFILLER_15_892 VPWR VGND sg13g2_decap_8
X_15578_ _06831_ _06797_ _06833_ VPWR VGND sg13g2_xor2_1
X_17317_ _08472_ VPWR _08473_ VGND _08401_ _08471_ sg13g2_o21ai_1
X_14529_ net992 VPWR _05824_ VGND net490 u_FIR.sum\[5\]\[3\] sg13g2_o21ai_1
X_18297_ VGND VPWR _09403_ _09404_ _09407_ _09406_ sg13g2_a21oi_1
XFILLER_119_216 VPWR VGND sg13g2_fill_2
X_17248_ _08404_ u_LMS.w\[0\]\[16\] _08402_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_750 VPWR VGND sg13g2_decap_4
XFILLER_128_761 VPWR VGND sg13g2_decap_8
XFILLER_116_901 VPWR VGND sg13g2_decap_4
XFILLER_116_912 VPWR VGND sg13g2_fill_1
X_17179_ _08325_ _08332_ _08335_ VPWR VGND sg13g2_nor2_1
XFILLER_115_411 VPWR VGND sg13g2_fill_1
XFILLER_51_0 VPWR VGND sg13g2_decap_8
XFILLER_127_293 VPWR VGND sg13g2_decap_8
X_20190_ _00853_ _00849_ _00851_ VPWR VGND sg13g2_xnor2_1
XFILLER_131_926 VPWR VGND sg13g2_fill_1
XFILLER_88_328 VPWR VGND sg13g2_fill_1
XFILLER_97_840 VPWR VGND sg13g2_decap_4
XFILLER_130_447 VPWR VGND sg13g2_fill_2
XFILLER_116_1052 VPWR VGND sg13g2_decap_8
XFILLER_69_575 VPWR VGND sg13g2_decap_4
X_22900_ VPWR _00779_ _03178_ VGND sg13g2_inv_1
XFILLER_38_951 VPWR VGND sg13g2_fill_2
X_22831_ VGND VPWR _07880_ net338 _00755_ _03133_ sg13g2_a21oi_1
XFILLER_56_269 VPWR VGND sg13g2_decap_8
X_23476__1498 VPWR VGND net1497 sg13g2_tiehi
X_22762_ u_debug_unit.mon_w3_sync\[4\] net336 _03099_ VPWR VGND sg13g2_nor2_1
XFILLER_53_932 VPWR VGND sg13g2_fill_1
XFILLER_37_483 VPWR VGND sg13g2_decap_4
X_21713_ _02314_ _02195_ _02197_ VPWR VGND sg13g2_xnor2_1
XFILLER_25_667 VPWR VGND sg13g2_decap_8
X_22693_ coeff_force_packed\[57\] net470 _03069_ _00681_ VPWR VGND sg13g2_mux2_1
XFILLER_24_155 VPWR VGND sg13g2_decap_4
XFILLER_80_795 VPWR VGND sg13g2_decap_8
XFILLER_24_177 VPWR VGND sg13g2_decap_8
X_21644_ net12 VPWR _02259_ VGND net11 _02258_ sg13g2_o21ai_1
XFILLER_40_637 VPWR VGND sg13g2_decap_8
X_23120__1610 VPWR VGND net1609 sg13g2_tiehi
X_21575_ _02188_ VPWR _02192_ VGND _02189_ _02190_ sg13g2_o21ai_1
XFILLER_123_1045 VPWR VGND sg13g2_decap_8
X_23314_ net1287 VGND VPWR _00376_ u_LMS.w\[4\]\[16\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
X_20526_ net94 _01165_ _01166_ VPWR VGND sg13g2_nor2_1
X_23245_ net1400 VGND VPWR _00307_ u_LMS.w\[1\]\[16\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
XFILLER_4_516 VPWR VGND sg13g2_fill_2
X_20457_ net23 VPWR _01110_ VGND net21 _01109_ sg13g2_o21ai_1
XFILLER_106_455 VPWR VGND sg13g2_fill_2
X_23176_ net1522 VGND VPWR _00238_ u_FIR.w\[3\]\[0\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
X_20388_ _01051_ net2126 _01050_ VPWR VGND sg13g2_nand2_1
XFILLER_121_403 VPWR VGND sg13g2_fill_1
X_22127_ _02718_ _02719_ _02721_ VPWR VGND sg13g2_nor2b_1
XFILLER_97_59 VPWR VGND sg13g2_fill_2
XFILLER_0_733 VPWR VGND sg13g2_decap_4
XFILLER_82_1040 VPWR VGND sg13g2_fill_2
XFILLER_0_744 VPWR VGND sg13g2_decap_8
XFILLER_82_1051 VPWR VGND sg13g2_decap_8
XFILLER_121_447 VPWR VGND sg13g2_fill_2
X_22058_ _02652_ _02629_ _02630_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_788 VPWR VGND sg13g2_decap_4
X_21009_ VGND VPWR _01649_ _01648_ _01646_ sg13g2_or2_1
X_13900_ _05222_ _05213_ _05220_ VPWR VGND sg13g2_xnor2_1
XFILLER_43_1057 VPWR VGND sg13g2_decap_4
X_14880_ _06165_ u_FIR.sum\[4\]\[13\] net397 VPWR VGND sg13g2_xnor2_1
X_13831_ VGND VPWR _05123_ _05127_ _05155_ _05126_ sg13g2_a21oi_1
XFILLER_47_258 VPWR VGND sg13g2_decap_8
XFILLER_90_504 VPWR VGND sg13g2_decap_8
XFILLER_90_515 VPWR VGND sg13g2_fill_2
XFILLER_62_206 VPWR VGND sg13g2_fill_1
XFILLER_62_217 VPWR VGND sg13g2_fill_1
XFILLER_28_472 VPWR VGND sg13g2_fill_1
X_16550_ VGND VPWR u_LMS.w\[2\]\[12\] _07753_ _07755_ _07754_ sg13g2_a21oi_1
X_13762_ _05088_ _05048_ _05051_ VPWR VGND sg13g2_nand2_1
XFILLER_55_280 VPWR VGND sg13g2_decap_8
XFILLER_15_111 VPWR VGND sg13g2_decap_4
X_15501_ net874 net791 u_FIR.sum\[6\]\[2\] _06759_ VPWR VGND sg13g2_a21o_1
X_12713_ _04078_ _04036_ _04076_ VPWR VGND sg13g2_xnor2_1
XFILLER_16_667 VPWR VGND sg13g2_fill_2
X_16481_ _07703_ net415 net841 VPWR VGND sg13g2_nand2_1
X_13693_ _05021_ _05013_ _05019_ VPWR VGND sg13g2_xnor2_1
X_18220_ _09330_ _09327_ _09329_ VPWR VGND sg13g2_nand2_1
XFILLER_15_177 VPWR VGND sg13g2_fill_1
X_15432_ _06671_ VPWR _06696_ VGND _06586_ _06669_ sg13g2_o21ai_1
XFILLER_70_283 VPWR VGND sg13g2_decap_8
X_12644_ _04011_ _04010_ _03990_ VPWR VGND sg13g2_nand2b_1
XFILLER_62_62 VPWR VGND sg13g2_fill_1
X_18151_ _09261_ _09216_ _09239_ VPWR VGND sg13g2_xnor2_1
X_15363_ _06604_ _06629_ _06630_ VPWR VGND sg13g2_nor2_1
X_12575_ _03945_ net737 net895 u_FIR.sum\[0\]\[1\] VPWR VGND sg13g2_and3_1
XFILLER_30_169 VPWR VGND sg13g2_fill_1
XFILLER_129_536 VPWR VGND sg13g2_decap_8
X_17102_ _08257_ _08168_ _08258_ VPWR VGND sg13g2_xor2_1
X_14314_ _05619_ net278 _05620_ VPWR VGND sg13g2_xor2_1
XFILLER_7_35 VPWR VGND sg13g2_decap_8
X_18082_ _09192_ net79 _09190_ VPWR VGND sg13g2_nand2b_1
X_15294_ _06563_ _06533_ _06562_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_343 VPWR VGND sg13g2_decap_8
X_17033_ _08189_ net709 net192 VPWR VGND sg13g2_nand2_1
XFILLER_8_899 VPWR VGND sg13g2_decap_8
X_14245_ _05553_ _05544_ _05551_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_753 VPWR VGND sg13g2_decap_4
X_14176_ VGND VPWR _05467_ _05473_ _05485_ _05472_ sg13g2_a21oi_1
X_13127_ _04475_ _04476_ _00086_ VPWR VGND sg13g2_nor2_1
X_18984_ net202 _10070_ net663 _10071_ VPWR VGND sg13g2_nand3_1
XFILLER_98_648 VPWR VGND sg13g2_fill_1
X_17935_ _09068_ u_LMS.w\[1\]\[18\] net77 VPWR VGND sg13g2_xnor2_1
X_13058_ _04410_ _04389_ _04409_ VPWR VGND sg13g2_nand2_1
X_12009_ spi_addr\[5\] spi_addr\[6\] _03426_ VPWR VGND sg13g2_nor2_1
XFILLER_121_981 VPWR VGND sg13g2_decap_8
X_17866_ _08999_ _08947_ _08949_ VPWR VGND sg13g2_xnor2_1
XFILLER_93_320 VPWR VGND sg13g2_decap_8
X_19605_ VGND VPWR _10667_ _10668_ _10669_ _10666_ sg13g2_a21oi_1
X_16817_ _07969_ _07954_ _07973_ VPWR VGND sg13g2_nor2_2
XFILLER_94_876 VPWR VGND sg13g2_fill_1
XFILLER_93_353 VPWR VGND sg13g2_decap_8
X_17797_ _08930_ net699 net243 VPWR VGND sg13g2_nand2_1
XFILLER_93_364 VPWR VGND sg13g2_fill_2
X_19536_ _03248_ net181 _10600_ VPWR VGND sg13g2_nor2_1
XFILLER_53_228 VPWR VGND sg13g2_fill_2
X_16748_ _07895_ _07897_ _07902_ _07904_ VGND VPWR _07899_ sg13g2_nor4_2
XFILLER_81_559 VPWR VGND sg13g2_decap_4
X_19467_ _10531_ net639 net251 VPWR VGND sg13g2_nand2_1
XFILLER_34_453 VPWR VGND sg13g2_fill_1
X_16679_ u_LMS.w\[7\]\[20\] u_LMS.w\[7\]\[19\] u_LMS.w\[7\]\[18\] _07849_ VPWR VGND
+ sg13g2_nor3_1
XFILLER_62_773 VPWR VGND sg13g2_decap_8
XFILLER_62_784 VPWR VGND sg13g2_fill_1
X_23454__1570 VPWR VGND net1569 sg13g2_tiehi
X_18418_ _03265_ net219 net195 _09524_ _09528_ VPWR VGND sg13g2_nor4_1
XFILLER_99_0 VPWR VGND sg13g2_decap_8
XFILLER_61_283 VPWR VGND sg13g2_decap_4
X_19398_ _10462_ _10459_ _10460_ VPWR VGND sg13g2_xnor2_1
X_23246__1400 VPWR VGND net1399 sg13g2_tiehi
X_18349_ _09459_ _09458_ _09455_ VPWR VGND sg13g2_nand2b_1
X_21360_ _01977_ _01975_ _01976_ VPWR VGND sg13g2_xnor2_1
X_20311_ _00973_ _11025_ _00974_ VPWR VGND sg13g2_xor2_1
X_21291_ _01908_ _01906_ _01903_ VPWR VGND sg13g2_xnor2_1
X_23030_ net1161 VGND VPWR _00092_ u_FIR.sum\[2\]\[11\] clknet_leaf_32_clkA sg13g2_dfrbpq_1
X_20242_ _00905_ _00880_ _00881_ VPWR VGND sg13g2_xnor2_1
XFILLER_104_904 VPWR VGND sg13g2_fill_1
XFILLER_103_425 VPWR VGND sg13g2_fill_1
X_20173_ _00832_ _00835_ _00836_ VPWR VGND sg13g2_nor2_1
XFILLER_104_959 VPWR VGND sg13g2_decap_8
XFILLER_107_58 VPWR VGND sg13g2_decap_4
XFILLER_88_125 VPWR VGND sg13g2_decap_8
XFILLER_115_296 VPWR VGND sg13g2_fill_2
XFILLER_88_136 VPWR VGND sg13g2_fill_1
XFILLER_130_255 VPWR VGND sg13g2_decap_8
XFILLER_57_501 VPWR VGND sg13g2_fill_1
XFILLER_97_681 VPWR VGND sg13g2_fill_1
XFILLER_123_35 VPWR VGND sg13g2_decap_8
XFILLER_123_57 VPWR VGND sg13g2_fill_1
Xclkbuf_leaf_30_clkA clknet_4_15_0_clkA clknet_leaf_30_clkA VPWR VGND sg13g2_buf_8
XFILLER_45_729 VPWR VGND sg13g2_fill_1
XFILLER_84_386 VPWR VGND sg13g2_decap_4
X_22814_ u_debug_unit.mon_w7_sync\[2\] net348 _03125_ VPWR VGND sg13g2_nor2_1
X_23020__1177 VPWR VGND net1176 sg13g2_tiehi
XFILLER_72_548 VPWR VGND sg13g2_fill_2
XFILLER_53_740 VPWR VGND sg13g2_fill_2
X_22745_ VGND VPWR _07759_ net334 _00712_ _03090_ sg13g2_a21oi_1
XFILLER_25_464 VPWR VGND sg13g2_fill_2
XFILLER_16_66 VPWR VGND sg13g2_fill_2
XFILLER_73_1039 VPWR VGND sg13g2_fill_1
X_22676_ coeff_force_packed\[44\] net469 _03067_ _00666_ VPWR VGND sg13g2_mux2_1
X_21627_ net62 u_LMS.w\[7\]\[23\] _02244_ VPWR VGND sg13g2_xor2_1
XFILLER_8_129 VPWR VGND sg13g2_fill_2
XFILLER_32_32 VPWR VGND sg13g2_fill_2
X_12360_ _03739_ _03722_ _03738_ VPWR VGND sg13g2_nand2_1
X_21558_ _03298_ _02174_ _02175_ VPWR VGND sg13g2_nor2_1
XFILLER_126_517 VPWR VGND sg13g2_decap_8
XFILLER_32_98 VPWR VGND sg13g2_decap_4
XFILLER_10_1001 VPWR VGND sg13g2_decap_4
X_20509_ _01148_ _01149_ _00417_ VPWR VGND sg13g2_nor2_1
X_12291_ _03670_ _03635_ _03672_ VPWR VGND sg13g2_xor2_1
X_21489_ _02058_ VPWR _02106_ VGND _02104_ _02103_ sg13g2_o21ai_1
XFILLER_119_580 VPWR VGND sg13g2_fill_1
X_14030_ _05343_ net760 net904 VPWR VGND sg13g2_nand2_1
X_23228_ net1430 VGND VPWR _00290_ u_LMS.w\[0\]\[22\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
XFILLER_10_1056 VPWR VGND sg13g2_decap_4
X_23159_ net1550 VGND VPWR _00221_ u_FIR.w\[0\]\[4\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
XFILLER_79_114 VPWR VGND sg13g2_fill_1
XFILLER_110_918 VPWR VGND sg13g2_decap_8
X_15981_ _07223_ u_FIR.sum\[6\]\[18\] _07206_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_255 VPWR VGND sg13g2_fill_1
XFILLER_0_563 VPWR VGND sg13g2_fill_2
XFILLER_95_629 VPWR VGND sg13g2_decap_4
X_17720_ _08850_ _08849_ _08853_ VPWR VGND sg13g2_xor2_1
X_14932_ _06198_ _06214_ _06215_ VPWR VGND sg13g2_nor2b_1
XFILLER_88_692 VPWR VGND sg13g2_decap_8
XFILLER_0_596 VPWR VGND sg13g2_fill_1
XFILLER_102_480 VPWR VGND sg13g2_fill_2
XFILLER_57_62 VPWR VGND sg13g2_fill_1
XFILLER_76_865 VPWR VGND sg13g2_fill_2
X_17651_ VGND VPWR _08778_ _08779_ _08784_ _08783_ sg13g2_a21oi_1
X_14863_ net1007 VPWR _06149_ VGND net511 u_FIR.sum\[5\]\[12\] sg13g2_o21ai_1
XFILLER_48_578 VPWR VGND sg13g2_fill_2
XFILLER_29_770 VPWR VGND sg13g2_decap_8
X_16602_ _07792_ VPWR _07793_ VGND _07788_ _07789_ sg13g2_o21ai_1
X_13814_ _05139_ _05102_ _05137_ VPWR VGND sg13g2_xnor2_1
X_17582_ VGND VPWR _08680_ _08711_ _08715_ _08714_ sg13g2_a21oi_1
X_14794_ _06047_ _06081_ _06082_ VPWR VGND sg13g2_nor2b_1
X_19321_ _10368_ _10384_ _10385_ VPWR VGND sg13g2_nor2_1
X_16533_ net974 VPWR _07742_ VGND net482 net787 sg13g2_o21ai_1
XFILLER_16_453 VPWR VGND sg13g2_decap_8
X_13745_ _05072_ _05043_ _05070_ VPWR VGND sg13g2_xnor2_1
XFILLER_90_378 VPWR VGND sg13g2_decap_8
X_23357__1245 VPWR VGND net1244 sg13g2_tiehi
XFILLER_73_72 VPWR VGND sg13g2_fill_2
XFILLER_31_401 VPWR VGND sg13g2_decap_8
X_19252_ net354 VPWR _10325_ VGND u_LMS.w\[3\]\[3\] net371 sg13g2_o21ai_1
X_16464_ _07690_ _07691_ _00208_ VPWR VGND sg13g2_nor2_1
XFILLER_92_7 VPWR VGND sg13g2_decap_4
X_13676_ VGND VPWR _04966_ _04973_ _05004_ _04980_ sg13g2_a21oi_1
X_18203_ _09313_ _09311_ _09310_ VPWR VGND sg13g2_xnor2_1
X_15415_ _06664_ _06679_ _06680_ VPWR VGND sg13g2_nor2b_1
X_19183_ _10270_ net307 u_LMS.w\[3\]\[12\] coeff_force_packed\[21\] net558 VPWR VGND
+ sg13g2_a22oi_1
X_12627_ _03994_ net733 net884 VPWR VGND sg13g2_nand2_1
X_16395_ VGND VPWR net497 _07625_ _00204_ _07626_ sg13g2_a21oi_1
X_18134_ _09244_ net671 net144 VPWR VGND sg13g2_nand2_1
X_15346_ _06613_ _06575_ _06612_ VPWR VGND sg13g2_nand2_1
X_12558_ net1038 VPWR _03931_ VGND net543 u_FIR.sum\[0\]\[13\] sg13g2_o21ai_1
XFILLER_7_140 VPWR VGND sg13g2_fill_2
XFILLER_8_674 VPWR VGND sg13g2_fill_1
X_18065_ _03261_ net139 _09175_ VPWR VGND sg13g2_nor2_1
X_15277_ _06546_ _06545_ _06541_ VPWR VGND sg13g2_nand2b_1
X_12489_ _03864_ _03836_ _03839_ VPWR VGND sg13g2_nand2_1
X_17016_ _08172_ _08171_ _08166_ VPWR VGND sg13g2_nand2b_1
X_14228_ _05536_ _05528_ _05535_ VPWR VGND sg13g2_xnor2_1
X_14159_ net766 net809 _05469_ VPWR VGND sg13g2_and2_1
Xfanout609 u_LMS.x_r\[6\]\[6\] net609 VPWR VGND sg13g2_buf_1
XFILLER_98_467 VPWR VGND sg13g2_fill_1
X_18967_ _10026_ _10053_ _10054_ VPWR VGND sg13g2_and2_1
Xclkbuf_leaf_53_clkA clknet_4_6_0_clkA clknet_leaf_53_clkA VPWR VGND sg13g2_buf_8
XFILLER_67_821 VPWR VGND sg13g2_fill_2
X_17918_ _09051_ _09050_ _08974_ _09049_ _08668_ VPWR VGND sg13g2_a22oi_1
X_18898_ _09985_ net659 net220 VPWR VGND sg13g2_nand2_1
XFILLER_14_0 VPWR VGND sg13g2_decap_8
X_17849_ _08982_ u_LMS.w\[1\]\[16\] _08981_ VPWR VGND sg13g2_nand2_1
XFILLER_93_172 VPWR VGND sg13g2_decap_4
X_20860_ _01500_ net621 net245 VPWR VGND sg13g2_nand2_1
XFILLER_81_356 VPWR VGND sg13g2_decap_8
X_19519_ _03249_ net143 _10583_ VPWR VGND sg13g2_nor2_1
X_20791_ _01431_ net616 net227 VPWR VGND sg13g2_nand2_1
XFILLER_35_784 VPWR VGND sg13g2_fill_1
XFILLER_50_721 VPWR VGND sg13g2_decap_8
X_22530_ _03000_ _03018_ _03019_ _00568_ VPWR VGND sg13g2_nor3_1
XFILLER_34_272 VPWR VGND sg13g2_decap_8
XFILLER_50_776 VPWR VGND sg13g2_decap_4
X_22461_ net961 VPWR _02980_ VGND net449 net613 sg13g2_o21ai_1
X_21412_ _02029_ net2156 _02028_ VPWR VGND sg13g2_xnor2_1
X_22392_ VGND VPWR net435 _03273_ _00504_ _02945_ sg13g2_a21oi_1
XFILLER_120_1026 VPWR VGND sg13g2_decap_8
XFILLER_108_528 VPWR VGND sg13g2_fill_1
X_21343_ _01960_ _01958_ _01959_ VPWR VGND sg13g2_xnor2_1
XFILLER_118_35 VPWR VGND sg13g2_decap_8
XFILLER_123_509 VPWR VGND sg13g2_decap_8
X_21274_ _01885_ _01890_ _01891_ VPWR VGND sg13g2_nor2_1
XFILLER_2_817 VPWR VGND sg13g2_fill_2
XFILLER_116_561 VPWR VGND sg13g2_fill_2
X_23013_ net1186 VGND VPWR _00075_ u_FIR.sum\[1\]\[10\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
X_20225_ _00887_ VPWR _00888_ VGND _03242_ net180 sg13g2_o21ai_1
XFILLER_89_467 VPWR VGND sg13g2_decap_4
X_20156_ _00819_ _11196_ _11194_ VPWR VGND sg13g2_nand2b_1
Xrebuffer1651 _09584_ net1650 VPWR VGND sg13g2_buf_8
XFILLER_89_478 VPWR VGND sg13g2_fill_1
XFILLER_49_309 VPWR VGND sg13g2_decap_4
XFILLER_131_575 VPWR VGND sg13g2_decap_8
Xrebuffer1662 _07929_ net1661 VPWR VGND sg13g2_buf_1
XFILLER_103_288 VPWR VGND sg13g2_decap_8
X_20087_ _11128_ _10975_ _11113_ VPWR VGND sg13g2_xnor2_1
XFILLER_58_854 VPWR VGND sg13g2_decap_4
XFILLER_100_951 VPWR VGND sg13g2_fill_1
XFILLER_58_865 VPWR VGND sg13g2_decap_8
XFILLER_58_876 VPWR VGND sg13g2_fill_1
XFILLER_18_729 VPWR VGND sg13g2_decap_4
X_11860_ VPWR _03281_ net712 VGND sg13g2_inv_1
XFILLER_45_548 VPWR VGND sg13g2_fill_1
XFILLER_73_868 VPWR VGND sg13g2_decap_8
XFILLER_27_76 VPWR VGND sg13g2_decap_8
X_11791_ VPWR _03212_ u_LMS.count\[31\] VGND sg13g2_inv_1
X_20989_ _01578_ VPWR _01629_ VGND _01628_ _01627_ sg13g2_o21ai_1
X_23777_ net992 VGND VPWR _00017_ u_spi_slave.bit_cnt\[2\] clknet_3_2__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_26_795 VPWR VGND sg13g2_decap_4
X_13530_ _04862_ net751 net879 VPWR VGND sg13g2_nand2_1
X_22728_ u_debug_unit.mon_w1_sync\[1\] net329 _03082_ VPWR VGND sg13g2_nor2_1
X_13461_ VGND VPWR _04799_ _04800_ _04801_ net415 sg13g2_a21oi_1
X_22659_ coeff_force_packed\[31\] net467 _03065_ _00651_ VPWR VGND sg13g2_mux2_1
X_15200_ _06471_ _06463_ _06469_ VPWR VGND sg13g2_xnor2_1
XFILLER_40_286 VPWR VGND sg13g2_decap_8
X_12412_ VGND VPWR _03789_ _03770_ _03768_ sg13g2_or2_1
X_16180_ _07415_ _07416_ _07417_ _07418_ VPWR VGND sg13g2_nor3_1
X_13392_ _04707_ _04734_ _04735_ VPWR VGND sg13g2_nor2b_1
XFILLER_126_303 VPWR VGND sg13g2_fill_2
X_15131_ _06404_ _06374_ _06403_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_611 VPWR VGND sg13g2_fill_1
X_12343_ _03694_ VPWR _03722_ VGND _03654_ _03685_ sg13g2_o21ai_1
XFILLER_126_325 VPWR VGND sg13g2_decap_8
XFILLER_5_633 VPWR VGND sg13g2_decap_8
X_15062_ VGND VPWR net484 _06335_ _00161_ _06336_ sg13g2_a21oi_1
X_12274_ _03655_ net907 net720 net894 net721 VPWR VGND sg13g2_a22oi_1
XFILLER_5_677 VPWR VGND sg13g2_fill_2
XFILLER_4_154 VPWR VGND sg13g2_fill_1
XFILLER_4_14 VPWR VGND sg13g2_decap_8
X_14013_ _05327_ net763 net878 VPWR VGND sg13g2_nand2_1
X_19870_ _10916_ _10917_ _00388_ VPWR VGND sg13g2_nor2_1
XFILLER_4_187 VPWR VGND sg13g2_decap_8
XFILLER_122_520 VPWR VGND sg13g2_decap_4
XFILLER_96_916 VPWR VGND sg13g2_fill_1
X_18821_ _09902_ _09907_ _09908_ VPWR VGND sg13g2_nor2_1
XFILLER_68_50 VPWR VGND sg13g2_decap_4
X_18752_ _09838_ _09808_ _09839_ VPWR VGND sg13g2_xor2_1
XFILLER_68_94 VPWR VGND sg13g2_decap_4
XFILLER_0_382 VPWR VGND sg13g2_decap_8
X_15964_ _07207_ u_FIR.sum\[6\]\[17\] net391 VPWR VGND sg13g2_xnor2_1
XFILLER_0_393 VPWR VGND sg13g2_fill_2
XFILLER_48_331 VPWR VGND sg13g2_fill_2
X_17703_ _08836_ net258 net688 net242 net690 VPWR VGND sg13g2_a22oi_1
X_14915_ _06193_ _06195_ _06198_ VPWR VGND sg13g2_nor2_1
X_18683_ _09769_ _09763_ _09770_ VPWR VGND sg13g2_nor2b_1
XFILLER_76_673 VPWR VGND sg13g2_decap_8
XFILLER_49_887 VPWR VGND sg13g2_decap_8
X_15895_ _07140_ _07118_ _07142_ VPWR VGND sg13g2_xor2_1
XFILLER_48_375 VPWR VGND sg13g2_fill_2
XFILLER_36_526 VPWR VGND sg13g2_decap_4
X_17634_ _08766_ VPWR _08767_ VGND _08742_ _08764_ sg13g2_o21ai_1
XFILLER_1_1010 VPWR VGND sg13g2_decap_8
X_14846_ VPWR _06132_ _06131_ VGND sg13g2_inv_1
XFILLER_63_367 VPWR VGND sg13g2_decap_4
X_17565_ _08649_ _08624_ _08698_ VPWR VGND sg13g2_xor2_1
X_14777_ _06065_ _06056_ _06063_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_698 VPWR VGND sg13g2_fill_2
X_11989_ _03398_ spi_addr\[0\] _03406_ VPWR VGND net474 sg13g2_nand3b_1
X_19304_ VGND VPWR _10359_ _10367_ _10368_ _10357_ sg13g2_a21oi_1
XFILLER_44_581 VPWR VGND sg13g2_fill_2
X_16516_ u_LMS.w\[1\]\[19\] u_LMS.w\[1\]\[18\] u_LMS.w\[1\]\[20\] _07728_ VPWR VGND
+ sg13g2_nand3_1
X_13728_ _05055_ u_FIR.w\[5\]\[3\] u_FIR.w\[5\]\[2\] net809 VPWR VGND sg13g2_and3_1
X_17496_ VGND VPWR _08627_ _08628_ _08629_ _08621_ sg13g2_a21oi_1
X_19235_ _10311_ _10255_ _10310_ VPWR VGND sg13g2_xnor2_1
XFILLER_31_253 VPWR VGND sg13g2_decap_4
Xclkbuf_3_6__f_spi_sclk clknet_3_6__leaf_spi_sclk clknet_0_spi_sclk VPWR VGND sg13g2_buf_16
X_16447_ _07676_ _07675_ _07666_ VPWR VGND sg13g2_nand2b_1
X_13659_ _04988_ u_FIR.sum\[2\]\[7\] net404 VPWR VGND sg13g2_xnor2_1
XFILLER_31_286 VPWR VGND sg13g2_fill_1
X_19166_ _10253_ u_LMS.w\[3\]\[22\] net67 VPWR VGND sg13g2_nand2_1
X_16378_ _07597_ VPWR _07610_ VGND net271 _07595_ sg13g2_o21ai_1
XFILLER_118_826 VPWR VGND sg13g2_decap_4
X_18117_ net421 net420 net106 net90 _09227_ VPWR VGND sg13g2_nor4_1
XFILLER_9_994 VPWR VGND sg13g2_decap_8
X_15329_ _06597_ _06571_ _06596_ VPWR VGND sg13g2_xnor2_1
XFILLER_118_848 VPWR VGND sg13g2_decap_4
X_19097_ _03335_ _10183_ _10184_ VPWR VGND sg13g2_nor2_1
X_18048_ net359 VPWR _09163_ VGND u_LMS.w\[1\]\[7\] net375 sg13g2_o21ai_1
XFILLER_132_317 VPWR VGND sg13g2_decap_8
X_23380__1209 VPWR VGND net1208 sg13g2_tiehi
X_20010_ VGND VPWR _11049_ _11050_ _11051_ _11045_ sg13g2_a21oi_1
Xfanout406 _04540_ net406 VPWR VGND sg13g2_buf_1
XFILLER_98_242 VPWR VGND sg13g2_decap_8
Xfanout417 _03282_ net417 VPWR VGND sg13g2_buf_1
XFILLER_101_704 VPWR VGND sg13g2_fill_2
Xfanout428 u_spi_slave.bit_cnt\[3\] net428 VPWR VGND sg13g2_buf_1
Xfanout439 net440 net439 VPWR VGND sg13g2_buf_1
XFILLER_59_629 VPWR VGND sg13g2_decap_4
XFILLER_58_106 VPWR VGND sg13g2_fill_2
XFILLER_100_203 VPWR VGND sg13g2_decap_8
X_19999_ _10950_ VPWR _11040_ VGND _11037_ _11038_ sg13g2_o21ai_1
XFILLER_98_275 VPWR VGND sg13g2_fill_1
XFILLER_86_426 VPWR VGND sg13g2_decap_8
XFILLER_100_214 VPWR VGND sg13g2_fill_1
XFILLER_101_759 VPWR VGND sg13g2_decap_8
XFILLER_39_331 VPWR VGND sg13g2_decap_8
XFILLER_100_269 VPWR VGND sg13g2_decap_8
X_21961_ net585 net130 _02555_ VPWR VGND sg13g2_and2_1
XFILLER_54_312 VPWR VGND sg13g2_fill_2
X_23700_ net1516 VGND VPWR _00762_ u_p2s_output.reg_sh\[1\] clknet_leaf_47_clkA sg13g2_dfrbpq_1
XFILLER_39_397 VPWR VGND sg13g2_decap_8
X_20912_ _01220_ _01551_ _01203_ _01552_ VPWR VGND sg13g2_nand3_1
XFILLER_94_492 VPWR VGND sg13g2_fill_1
XFILLER_66_183 VPWR VGND sg13g2_decap_4
X_21892_ _02480_ _02485_ _02486_ VPWR VGND sg13g2_nor2_1
XFILLER_82_665 VPWR VGND sg13g2_fill_1
XFILLER_55_879 VPWR VGND sg13g2_decap_8
X_20843_ _01481_ _01478_ _01483_ VPWR VGND sg13g2_xor2_1
X_23631_ net974 VGND VPWR _00693_ u_debug_unit.error_signal_sync\[5\] clknet_leaf_48_clkA
+ sg13g2_dfrbpq_1
XFILLER_81_164 VPWR VGND sg13g2_decap_8
XFILLER_120_14 VPWR VGND sg13g2_decap_8
XFILLER_35_581 VPWR VGND sg13g2_fill_2
Xfanout13 _02249_ net13 VPWR VGND sg13g2_buf_2
X_20774_ _01412_ _01411_ _01414_ VPWR VGND sg13g2_xor2_1
X_23562_ net953 VGND VPWR _00624_ coeff_force_packed\[7\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
Xfanout24 _10905_ net24 VPWR VGND sg13g2_buf_2
Xfanout35 _09679_ net35 VPWR VGND sg13g2_buf_1
Xfanout46 _08495_ net46 VPWR VGND sg13g2_buf_1
X_22513_ _03000_ _03007_ _03008_ _00562_ VPWR VGND sg13g2_nor3_1
Xfanout57 _09093_ net57 VPWR VGND sg13g2_buf_1
XFILLER_50_562 VPWR VGND sg13g2_fill_1
X_23493_ net1436 VGND VPWR _00555_ u_LMS.x_r\[8\]\[4\] clknet_leaf_7_clkA sg13g2_dfrbpq_1
Xfanout68 net2080 net68 VPWR VGND sg13g2_buf_8
Xfanout79 net79 net81 VPWR VGND sg13g2_buf_4
XFILLER_11_938 VPWR VGND sg13g2_fill_1
XFILLER_22_286 VPWR VGND sg13g2_fill_2
X_22444_ VGND VPWR net443 _03247_ _00530_ _02971_ sg13g2_a21oi_1
XFILLER_13_45 VPWR VGND sg13g2_decap_4
XFILLER_10_459 VPWR VGND sg13g2_fill_2
XFILLER_129_56 VPWR VGND sg13g2_decap_8
X_22375_ net969 VPWR _02937_ VGND net456 u_LMS.x_r\[1\]\[1\] sg13g2_o21ai_1
X_21326_ _01941_ _01939_ _01943_ VPWR VGND sg13g2_xor2_1
XFILLER_2_614 VPWR VGND sg13g2_decap_8
XFILLER_104_520 VPWR VGND sg13g2_fill_1
X_21257_ _01874_ _01841_ _01872_ VPWR VGND sg13g2_nand2_1
XFILLER_123_339 VPWR VGND sg13g2_fill_1
Xrebuffer2160 _07949_ net2159 VPWR VGND sg13g2_buf_1
XFILLER_89_242 VPWR VGND sg13g2_fill_1
X_20208_ _00855_ _00870_ _00871_ VPWR VGND sg13g2_and2_1
Xrebuffer2171 _02823_ net2170 VPWR VGND sg13g2_buf_1
X_21188_ _01805_ _01791_ _01803_ VPWR VGND sg13g2_xnor2_1
XFILLER_89_275 VPWR VGND sg13g2_fill_1
Xfanout940 net941 net940 VPWR VGND sg13g2_buf_1
XFILLER_89_286 VPWR VGND sg13g2_fill_2
XFILLER_78_949 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_5_clkA clknet_4_8_0_clkA clknet_leaf_5_clkA VPWR VGND sg13g2_buf_8
X_23727__1327 VPWR VGND net1326 sg13g2_tiehi
X_20139_ _11179_ _11174_ _11180_ VPWR VGND sg13g2_xor2_1
Xfanout951 net952 net951 VPWR VGND sg13g2_buf_1
XFILLER_49_139 VPWR VGND sg13g2_decap_8
Xfanout962 net968 net962 VPWR VGND sg13g2_buf_1
Xfanout973 net978 net973 VPWR VGND sg13g2_buf_1
XFILLER_58_640 VPWR VGND sg13g2_fill_1
Xfanout984 net985 net984 VPWR VGND sg13g2_buf_1
XFILLER_93_919 VPWR VGND sg13g2_fill_1
Xfanout995 net996 net995 VPWR VGND sg13g2_buf_1
X_12961_ _04289_ _04291_ _04319_ VPWR VGND sg13g2_nor2_1
XFILLER_86_982 VPWR VGND sg13g2_decap_8
XFILLER_86_993 VPWR VGND sg13g2_fill_1
X_14700_ _05943_ VPWR _05990_ VGND _05900_ _05941_ sg13g2_o21ai_1
X_11912_ VPWR _03333_ net717 VGND sg13g2_inv_1
X_15680_ _06896_ _06932_ _06933_ VPWR VGND sg13g2_nor2b_1
XFILLER_45_334 VPWR VGND sg13g2_fill_1
X_12892_ _04226_ VPWR _04252_ VGND _04217_ _04227_ sg13g2_o21ai_1
X_14631_ _05923_ _05883_ _05886_ _05922_ VPWR VGND sg13g2_and3_1
X_11843_ VPWR _03264_ net678 VGND sg13g2_inv_1
X_17350_ _08505_ net315 u_LMS.w\[0\]\[13\] coeff_force_packed\[1\] net564 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_60_337 VPWR VGND sg13g2_decap_8
X_14562_ _05855_ net768 net890 VPWR VGND sg13g2_nand2_1
X_16301_ _07535_ net271 _07536_ VPWR VGND sg13g2_xor2_1
XFILLER_13_242 VPWR VGND sg13g2_fill_1
X_13513_ _04846_ net751 net904 VPWR VGND sg13g2_nand2_1
X_17281_ _08436_ _08435_ _08437_ VPWR VGND sg13g2_nor2b_1
X_23489__1452 VPWR VGND net1451 sg13g2_tiehi
X_14493_ VPWR _05789_ _05788_ VGND sg13g2_inv_1
XFILLER_14_798 VPWR VGND sg13g2_fill_2
X_19020_ _10107_ _10098_ _10100_ VPWR VGND sg13g2_xnor2_1
XFILLER_110_91 VPWR VGND sg13g2_decap_4
X_16232_ _07469_ _07427_ _07467_ VPWR VGND sg13g2_xnor2_1
X_13444_ _04770_ VPWR _04784_ VGND net283 _04768_ sg13g2_o21ai_1
XFILLER_10_971 VPWR VGND sg13g2_fill_2
Xclkload16 clknet_leaf_57_clkA clkload16/X VPWR VGND sg13g2_buf_8
X_16163_ VGND VPWR _07362_ _07398_ _07401_ _07397_ sg13g2_a21oi_1
Xclkload27 VPWR clkload27/Y clknet_leaf_39_clkA VGND sg13g2_inv_1
X_13375_ _04716_ _04680_ _04718_ VPWR VGND sg13g2_xor2_1
Xclkload38 clknet_leaf_11_clkA clkload38/Y VPWR VGND sg13g2_inv_4
Xclkload49 clkload49/Y clknet_leaf_22_clkA VPWR VGND sg13g2_inv_2
X_15114_ _06387_ _06345_ _06385_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_667 VPWR VGND sg13g2_decap_8
X_12326_ _03706_ _03649_ _03705_ VPWR VGND sg13g2_xnor2_1
X_16094_ _07332_ _07329_ _07334_ VPWR VGND sg13g2_xor2_1
XFILLER_55_7 VPWR VGND sg13g2_decap_4
XFILLER_6_997 VPWR VGND sg13g2_decap_8
X_19922_ _10945_ VPWR _10963_ VGND _10942_ _10943_ sg13g2_o21ai_1
X_15045_ _06297_ _06299_ _06320_ VPWR VGND sg13g2_and2_1
XFILLER_114_339 VPWR VGND sg13g2_decap_4
XFILLER_107_380 VPWR VGND sg13g2_fill_1
X_12257_ _03616_ _03638_ _03639_ VPWR VGND sg13g2_nor2_1
X_19853_ net930 _10904_ _00384_ VPWR VGND sg13g2_nor2_1
X_12188_ net945 _03572_ _03577_ _00017_ VPWR VGND sg13g2_nor3_1
X_18804_ _09891_ _09855_ _09889_ VPWR VGND sg13g2_nand2_1
XFILLER_1_680 VPWR VGND sg13g2_fill_2
XFILLER_1_691 VPWR VGND sg13g2_fill_2
X_19784_ _10843_ VPWR _10848_ VGND _03325_ _10830_ sg13g2_o21ai_1
X_16996_ _08145_ VPWR _08152_ VGND _08113_ _08143_ sg13g2_o21ai_1
XFILLER_84_908 VPWR VGND sg13g2_fill_2
X_18735_ _09822_ _09808_ _09820_ VPWR VGND sg13g2_xnor2_1
X_15947_ _07191_ _07166_ _07189_ VPWR VGND sg13g2_xnor2_1
XFILLER_48_172 VPWR VGND sg13g2_fill_1
X_18666_ net356 VPWR _09755_ VGND u_LMS.w\[2\]\[10\] net372 sg13g2_o21ai_1
X_15878_ net275 _07122_ _07125_ VPWR VGND sg13g2_and2_1
XFILLER_37_879 VPWR VGND sg13g2_decap_8
XFILLER_36_356 VPWR VGND sg13g2_decap_4
XFILLER_63_153 VPWR VGND sg13g2_fill_2
X_17617_ _08750_ _08748_ _08749_ VPWR VGND sg13g2_nand2_1
X_14829_ _06114_ _06085_ _06116_ VPWR VGND sg13g2_xor2_1
X_18597_ _09700_ net34 net35 _09701_ VPWR VGND sg13g2_a21o_1
XFILLER_91_484 VPWR VGND sg13g2_fill_1
XFILLER_63_175 VPWR VGND sg13g2_decap_8
XFILLER_91_495 VPWR VGND sg13g2_decap_4
X_17548_ _03271_ net92 _08681_ VPWR VGND sg13g2_nor2_1
XFILLER_32_540 VPWR VGND sg13g2_decap_8
XFILLER_32_551 VPWR VGND sg13g2_fill_2
X_17479_ net419 net129 _08612_ VPWR VGND sg13g2_nor2_1
XFILLER_60_882 VPWR VGND sg13g2_decap_4
XFILLER_81_0 VPWR VGND sg13g2_decap_8
X_19218_ VGND VPWR _10296_ _10297_ _00356_ net927 sg13g2_a21oi_1
X_20490_ _01135_ _01016_ _01017_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_779 VPWR VGND sg13g2_decap_8
X_19149_ _10236_ _10235_ _10180_ VPWR VGND sg13g2_nand2b_1
XFILLER_30_1026 VPWR VGND sg13g2_decap_8
X_22160_ _02421_ _02424_ _02754_ VPWR VGND sg13g2_nor2_1
X_21111_ _01730_ _01731_ _00437_ VPWR VGND sg13g2_nor2_1
X_22091_ _02685_ _02684_ _02675_ VPWR VGND sg13g2_nand2b_1
X_21042_ VGND VPWR _01676_ _01677_ _00422_ net936 sg13g2_a21oi_1
Xfanout203 net204 net203 VPWR VGND sg13g2_buf_1
Xfanout214 net215 net214 VPWR VGND sg13g2_buf_1
XFILLER_99_573 VPWR VGND sg13g2_decap_8
XFILLER_101_512 VPWR VGND sg13g2_fill_2
Xfanout225 net234 net225 VPWR VGND sg13g2_buf_1
XFILLER_99_584 VPWR VGND sg13g2_fill_1
Xfanout236 net237 net236 VPWR VGND sg13g2_buf_1
Xfanout247 net248 net247 VPWR VGND sg13g2_buf_1
Xfanout258 net259 net258 VPWR VGND sg13g2_buf_1
Xfanout269 _06055_ net269 VPWR VGND sg13g2_buf_1
X_23352__1250 VPWR VGND net1249 sg13g2_tiehi
XFILLER_68_971 VPWR VGND sg13g2_decap_8
X_22993_ net1216 VGND VPWR _00055_ u_FIR.sum\[0\]\[5\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
X_21944_ _02538_ _02535_ _02537_ VPWR VGND sg13g2_nand2_1
XFILLER_28_868 VPWR VGND sg13g2_fill_1
XFILLER_131_46 VPWR VGND sg13g2_decap_8
XFILLER_83_996 VPWR VGND sg13g2_fill_1
XFILLER_43_827 VPWR VGND sg13g2_decap_8
XFILLER_82_473 VPWR VGND sg13g2_fill_2
X_21875_ _02469_ net579 net130 VPWR VGND sg13g2_nand2_1
XFILLER_27_389 VPWR VGND sg13g2_fill_1
XFILLER_91_28 VPWR VGND sg13g2_decap_8
XFILLER_54_186 VPWR VGND sg13g2_decap_8
X_23614_ net965 VGND VPWR _00676_ coeff_force_packed\[53\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
X_20826_ _01466_ _01366_ _01436_ VPWR VGND sg13g2_xnor2_1
XFILLER_24_33 VPWR VGND sg13g2_fill_1
XFILLER_126_1021 VPWR VGND sg13g2_decap_8
XFILLER_24_44 VPWR VGND sg13g2_decap_8
X_23545_ net955 VGND VPWR _00607_ debug_load_bus\[7\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
XFILLER_10_201 VPWR VGND sg13g2_fill_2
X_20757_ _01391_ VPWR _01397_ VGND _01387_ _01392_ sg13g2_o21ai_1
XFILLER_50_392 VPWR VGND sg13g2_fill_1
X_20688_ _01328_ _01323_ _01326_ VPWR VGND sg13g2_xnor2_1
X_23476_ net1497 VGND VPWR _00538_ u_LMS.x_r\[6\]\[3\] clknet_leaf_11_clkA sg13g2_dfrbpq_1
XFILLER_11_779 VPWR VGND sg13g2_decap_8
XFILLER_108_111 VPWR VGND sg13g2_decap_4
X_22427_ net949 VPWR _02963_ VGND net437 net646 sg13g2_o21ai_1
XFILLER_108_122 VPWR VGND sg13g2_fill_2
XFILLER_40_32 VPWR VGND sg13g2_fill_2
XFILLER_109_656 VPWR VGND sg13g2_decap_8
X_23459__1555 VPWR VGND net1554 sg13g2_tiehi
X_13160_ _04477_ _04508_ _04509_ VPWR VGND sg13g2_nor2_1
X_22358_ VGND VPWR net454 _03290_ _00487_ _02928_ sg13g2_a21oi_1
XFILLER_3_923 VPWR VGND sg13g2_fill_2
XFILLER_123_103 VPWR VGND sg13g2_decap_8
X_12111_ u_debug_unit.mon_w6_sync\[2\] _03412_ _03522_ VPWR VGND sg13g2_and2_1
X_21309_ _01926_ net600 net189 VPWR VGND sg13g2_nand2_1
X_13091_ _04434_ VPWR _04441_ VGND _04405_ _04432_ sg13g2_o21ai_1
X_22289_ VGND VPWR u_LMS.w\[8\]\[19\] net308 _02876_ _02871_ sg13g2_a21oi_1
X_12042_ _03457_ net291 coeff_force_packed\[48\] net296 coeff_force_packed\[13\] VPWR
+ VGND sg13g2_a22oi_1
XFILLER_46_1022 VPWR VGND sg13g2_fill_2
XFILLER_46_1055 VPWR VGND sg13g2_decap_4
XFILLER_104_383 VPWR VGND sg13g2_decap_4
X_16850_ _07980_ VPWR _08006_ VGND _07977_ _07978_ sg13g2_o21ai_1
XFILLER_66_908 VPWR VGND sg13g2_decap_8
XFILLER_77_256 VPWR VGND sg13g2_fill_1
Xfanout770 u_FIR.w\[3\]\[3\] net770 VPWR VGND sg13g2_buf_1
X_15801_ net1003 VPWR _07051_ VGND net495 u_FIR.sum\[7\]\[10\] sg13g2_o21ai_1
XFILLER_19_802 VPWR VGND sg13g2_decap_8
Xfanout781 u_FIR.w\[2\]\[1\] net781 VPWR VGND sg13g2_buf_1
Xfanout792 u_FIR.w\[1\]\[0\] net792 VPWR VGND sg13g2_buf_1
X_16781_ _07919_ _07935_ _07937_ VPWR VGND sg13g2_nor2_1
XFILLER_77_278 VPWR VGND sg13g2_fill_2
X_13993_ _05308_ net904 net762 net892 net763 VPWR VGND sg13g2_a22oi_1
XFILLER_93_738 VPWR VGND sg13g2_decap_8
X_18520_ _09630_ _09628_ _09629_ VPWR VGND sg13g2_nand2b_1
X_15732_ net847 _06982_ net784 _06983_ VPWR VGND sg13g2_nand3_1
XFILLER_74_941 VPWR VGND sg13g2_decap_8
X_12944_ _04297_ _04302_ _04303_ VPWR VGND sg13g2_nor2b_1
XFILLER_18_334 VPWR VGND sg13g2_decap_8
XFILLER_46_665 VPWR VGND sg13g2_decap_8
XFILLER_34_805 VPWR VGND sg13g2_decap_4
X_18451_ _09353_ _09355_ _09325_ _09561_ VPWR VGND sg13g2_nand3_1
X_15663_ _06916_ _06909_ _06914_ VPWR VGND sg13g2_xnor2_1
X_12875_ _04236_ _04192_ _04234_ VPWR VGND sg13g2_xnor2_1
X_17402_ VGND VPWR _08545_ _08546_ _00291_ net939 sg13g2_a21oi_1
X_14614_ _05906_ _05898_ _05904_ VPWR VGND sg13g2_xnor2_1
X_18382_ _09492_ _09462_ _09468_ VPWR VGND sg13g2_xnor2_1
X_11826_ VPWR _03247_ net646 VGND sg13g2_inv_1
XFILLER_60_134 VPWR VGND sg13g2_fill_2
X_15594_ _06812_ _06848_ _06849_ VPWR VGND sg13g2_nor2_1
XFILLER_33_359 VPWR VGND sg13g2_decap_4
XFILLER_61_679 VPWR VGND sg13g2_decap_8
X_23169__1535 VPWR VGND net1534 sg13g2_tiehi
X_17333_ _08489_ u_LMS.w\[0\]\[24\] net72 VPWR VGND sg13g2_nand2_1
XFILLER_81_50 VPWR VGND sg13g2_decap_8
XFILLER_53_1015 VPWR VGND sg13g2_fill_1
X_14545_ _05839_ _05837_ _05838_ VPWR VGND sg13g2_nand2_1
X_17264_ _08420_ u_LMS.w\[0\]\[9\] _08419_ VPWR VGND sg13g2_nand2_1
X_14476_ net1008 VPWR _05775_ VGND net512 u_FIR.sum\[4\]\[18\] sg13g2_o21ai_1
XFILLER_128_910 VPWR VGND sg13g2_decap_8
X_19003_ _10089_ VPWR _10090_ VGND _03258_ net177 sg13g2_o21ai_1
X_16215_ _07452_ _07451_ _07447_ VPWR VGND sg13g2_nand2b_1
X_13427_ _04768_ u_FIR.sum\[1\]\[14\] net406 VPWR VGND sg13g2_xnor2_1
X_17195_ _08280_ _08279_ _08351_ VPWR VGND sg13g2_xor2_1
X_16146_ _07348_ u_FIR.w\[0\]\[6\] _07346_ _07385_ VPWR VGND sg13g2_a21o_1
X_13358_ _04675_ _04701_ _04702_ VPWR VGND sg13g2_nor2_1
XFILLER_128_998 VPWR VGND sg13g2_decap_8
XFILLER_6_772 VPWR VGND sg13g2_fill_1
XFILLER_114_103 VPWR VGND sg13g2_fill_2
X_12309_ _03689_ net724 net854 VPWR VGND sg13g2_nand2_1
X_16077_ _07266_ _07317_ _07318_ VPWR VGND sg13g2_nor2_1
X_13289_ _04628_ _04631_ _04634_ VPWR VGND sg13g2_nor2_1
X_19905_ _10946_ _10941_ _10944_ VPWR VGND sg13g2_xnor2_1
X_15028_ _06302_ _06303_ _06304_ VPWR VGND sg13g2_nor2b_1
XFILLER_96_521 VPWR VGND sg13g2_fill_2
XFILLER_69_746 VPWR VGND sg13g2_decap_4
X_19836_ _10891_ _10836_ _10886_ VPWR VGND sg13g2_nand2_1
XFILLER_110_331 VPWR VGND sg13g2_decap_8
XFILLER_96_554 VPWR VGND sg13g2_fill_1
XFILLER_110_342 VPWR VGND sg13g2_fill_2
X_19767_ _10831_ _03326_ net66 VPWR VGND sg13g2_xnor2_1
Xinput3 spi_ss_n net3 VPWR VGND sg13g2_buf_1
X_16979_ _08135_ net705 net232 VPWR VGND sg13g2_nand2_1
XFILLER_83_237 VPWR VGND sg13g2_decap_4
X_18718_ VGND VPWR _09803_ _09804_ _09805_ _09797_ sg13g2_a21oi_1
XFILLER_65_963 VPWR VGND sg13g2_decap_4
X_19698_ _03323_ _10761_ _10762_ VPWR VGND sg13g2_nor2_1
XFILLER_65_985 VPWR VGND sg13g2_decap_4
X_18649_ VGND VPWR net56 _09741_ _09742_ net32 sg13g2_a21oi_1
XFILLER_91_270 VPWR VGND sg13g2_fill_1
X_21660_ _02272_ net312 u_LMS.w\[7\]\[17\] coeff_force_packed\[54\] net563 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_80_977 VPWR VGND sg13g2_fill_1
XFILLER_101_49 VPWR VGND sg13g2_fill_1
X_20611_ _01250_ _01164_ _01251_ VPWR VGND sg13g2_xor2_1
X_21591_ u_LMS.w\[7\]\[9\] _02176_ _02208_ VPWR VGND sg13g2_nor2_1
XFILLER_33_893 VPWR VGND sg13g2_fill_2
X_20542_ VGND VPWR net608 net111 _01182_ _01179_ sg13g2_a21oi_1
X_23330_ net1271 VGND VPWR _00392_ u_LMS.w\[4\]\[9\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
XFILLER_20_543 VPWR VGND sg13g2_fill_2
X_20473_ _01121_ _01122_ _00408_ VPWR VGND sg13g2_nor2_1
X_23261_ net1371 VGND VPWR _00323_ u_LMS.w\[1\]\[9\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
X_22212_ _02806_ _03291_ _02771_ VPWR VGND sg13g2_nand2_1
X_23192_ net1494 VGND VPWR _00254_ u_FIR.w\[5\]\[2\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
XFILLER_69_1044 VPWR VGND sg13g2_fill_1
X_23232__1424 VPWR VGND net1423 sg13g2_tiehi
X_22143_ _02418_ VPWR _02737_ VGND _02385_ _02419_ sg13g2_o21ai_1
XFILLER_126_35 VPWR VGND sg13g2_decap_8
X_22074_ _02654_ _02667_ _02668_ VPWR VGND sg13g2_nor2_1
Xfanout1009 net1043 net1009 VPWR VGND sg13g2_buf_1
X_21025_ VGND VPWR _01663_ _01664_ _00418_ net936 sg13g2_a21oi_1
XFILLER_120_139 VPWR VGND sg13g2_decap_8
XFILLER_74_204 VPWR VGND sg13g2_fill_2
X_21927_ _02521_ net582 net185 VPWR VGND sg13g2_nand2_1
XFILLER_28_698 VPWR VGND sg13g2_decap_4
XFILLER_83_793 VPWR VGND sg13g2_decap_8
XFILLER_27_175 VPWR VGND sg13g2_fill_2
XFILLER_42_112 VPWR VGND sg13g2_decap_8
X_12660_ _04026_ net733 net869 VPWR VGND sg13g2_nand2_1
XFILLER_35_65 VPWR VGND sg13g2_decap_8
X_21858_ _02450_ _02451_ _02452_ VPWR VGND sg13g2_nor2b_1
XFILLER_70_454 VPWR VGND sg13g2_fill_2
XFILLER_42_156 VPWR VGND sg13g2_decap_8
XFILLER_30_307 VPWR VGND sg13g2_fill_2
X_20809_ _01447_ _01446_ _01449_ VPWR VGND sg13g2_xor2_1
X_12591_ _03957_ _03959_ _03945_ _03960_ VPWR VGND sg13g2_nand3_1
XFILLER_24_893 VPWR VGND sg13g2_fill_2
X_21789_ _02351_ VPWR _02383_ VGND _02349_ _02359_ sg13g2_o21ai_1
XFILLER_23_381 VPWR VGND sg13g2_decap_8
X_14330_ _05621_ VPWR _05635_ VGND net278 _05619_ sg13g2_o21ai_1
XFILLER_23_392 VPWR VGND sg13g2_fill_2
X_23528_ net1308 VGND VPWR _00590_ u_LMS.count\[31\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
X_14261_ net807 VPWR _05568_ VGND u_FIR.w\[4\]\[3\] u_FIR.w\[4\]\[2\] sg13g2_o21ai_1
XFILLER_129_0 VPWR VGND sg13g2_decap_8
X_23459_ net1554 VGND VPWR _00521_ u_LMS.x_r\[4\]\[2\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
X_23410__1119 VPWR VGND net1118 sg13g2_tiehi
X_16000_ _07241_ net796 net886 VPWR VGND sg13g2_nand2_1
XFILLER_125_902 VPWR VGND sg13g2_decap_4
X_13212_ _04559_ _04523_ _04526_ VPWR VGND sg13g2_nand2_1
X_14192_ _05497_ VPWR _05501_ VGND _05498_ _05499_ sg13g2_o21ai_1
X_13143_ _04491_ _04487_ _04492_ VPWR VGND sg13g2_xor2_1
XFILLER_125_979 VPWR VGND sg13g2_decap_8
X_17951_ VPWR _09084_ _09083_ VGND sg13g2_inv_1
X_13074_ net855 u_FIR.sum\[1\]\[4\] net747 _04425_ VPWR VGND sg13g2_nand3_1
X_16902_ _08058_ _08005_ _08057_ VPWR VGND sg13g2_xnor2_1
X_12025_ _03442_ _03438_ u_debug_unit.error_signal_sync\[7\] _03434_ u_debug_unit.mon_w0_sync\[6\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_2_296 VPWR VGND sg13g2_decap_4
X_17882_ VGND VPWR u_LMS.w\[1\]\[4\] _09005_ _09015_ _09014_ sg13g2_a21oi_1
XFILLER_39_908 VPWR VGND sg13g2_fill_1
XFILLER_78_565 VPWR VGND sg13g2_decap_8
X_19621_ _10656_ _10684_ _10685_ VPWR VGND sg13g2_and2_1
X_16833_ _07989_ _07907_ _07952_ VPWR VGND sg13g2_nand2_1
XFILLER_18_7 VPWR VGND sg13g2_fill_1
XFILLER_66_749 VPWR VGND sg13g2_fill_1
XFILLER_65_237 VPWR VGND sg13g2_fill_1
XFILLER_59_790 VPWR VGND sg13g2_decap_8
X_19552_ _10615_ _10614_ _10616_ VPWR VGND sg13g2_xor2_1
X_16764_ _07920_ net913 _07915_ VPWR VGND sg13g2_nand2_1
XFILLER_47_952 VPWR VGND sg13g2_fill_2
X_13976_ net905 u_FIR.sum\[3\]\[0\] net765 _05293_ VPWR VGND sg13g2_nand3_1
X_18503_ _09613_ net681 net253 VPWR VGND sg13g2_nand2_1
X_15715_ _06967_ _06938_ _06966_ VPWR VGND sg13g2_nand2b_1
X_12927_ VGND VPWR _04254_ _04259_ _04286_ _04258_ sg13g2_a21oi_1
XFILLER_80_218 VPWR VGND sg13g2_decap_8
X_19483_ _10545_ _10546_ _10547_ VPWR VGND sg13g2_nor2b_1
X_16695_ VGND VPWR net519 _07860_ _00269_ _07861_ sg13g2_a21oi_1
X_18434_ _09497_ _09496_ _09544_ VPWR VGND sg13g2_nor2b_1
X_15646_ _06885_ VPWR _06899_ VGND _06836_ _06875_ sg13g2_o21ai_1
X_12858_ _04219_ net731 net830 VPWR VGND sg13g2_nand2_1
XFILLER_61_454 VPWR VGND sg13g2_fill_1
X_18365_ _09467_ _09463_ _09474_ _09475_ VPWR VGND sg13g2_a21o_1
X_11809_ VPWR _03230_ net612 VGND sg13g2_inv_1
XFILLER_21_318 VPWR VGND sg13g2_decap_4
X_15577_ VGND VPWR _06832_ _06830_ _06798_ sg13g2_or2_1
XFILLER_109_1060 VPWR VGND sg13g2_fill_1
X_12789_ _04152_ _04134_ _04150_ VPWR VGND sg13g2_xnor2_1
X_17316_ _08472_ _03355_ net71 VPWR VGND sg13g2_xnor2_1
X_14528_ _05823_ _05801_ _05821_ VPWR VGND sg13g2_xnor2_1
X_18296_ net422 _09405_ _09406_ VPWR VGND sg13g2_nor2_1
X_17247_ _08403_ u_LMS.w\[0\]\[16\] _08402_ VPWR VGND sg13g2_nand2_1
XFILLER_30_896 VPWR VGND sg13g2_decap_8
X_14459_ _05758_ _05753_ _05759_ VPWR VGND sg13g2_xor2_1
X_17178_ _08334_ _08311_ _08333_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_250 VPWR VGND sg13g2_decap_8
X_16129_ _07368_ net795 net859 VPWR VGND sg13g2_nand2_1
XFILLER_44_0 VPWR VGND sg13g2_decap_8
XFILLER_115_467 VPWR VGND sg13g2_fill_1
XFILLER_102_128 VPWR VGND sg13g2_fill_2
XFILLER_97_863 VPWR VGND sg13g2_decap_8
XFILLER_96_351 VPWR VGND sg13g2_decap_8
X_19819_ net2134 _10876_ _10877_ VPWR VGND sg13g2_and2_1
XFILLER_99_1015 VPWR VGND sg13g2_fill_2
XFILLER_84_513 VPWR VGND sg13g2_decap_8
XFILLER_29_418 VPWR VGND sg13g2_fill_2
XFILLER_84_524 VPWR VGND sg13g2_fill_1
X_22830_ u_debug_unit.mon_w8_sync\[3\] net338 _03133_ VPWR VGND sg13g2_nor2_1
XFILLER_2_91 VPWR VGND sg13g2_decap_8
XFILLER_65_771 VPWR VGND sg13g2_fill_2
X_22761_ VGND VPWR _07781_ net335 _00720_ _03098_ sg13g2_a21oi_1
XFILLER_80_741 VPWR VGND sg13g2_fill_1
X_21712_ _02312_ _02313_ _00456_ VPWR VGND sg13g2_nor2_1
X_22692_ coeff_force_packed\[56\] net472 _03069_ _00680_ VPWR VGND sg13g2_mux2_1
XFILLER_52_465 VPWR VGND sg13g2_fill_1
X_23276__1342 VPWR VGND net1341 sg13g2_tiehi
XFILLER_36_1010 VPWR VGND sg13g2_decap_8
X_21643_ _02258_ net2141 _02223_ VPWR VGND sg13g2_xnor2_1
XFILLER_52_498 VPWR VGND sg13g2_fill_1
XFILLER_21_841 VPWR VGND sg13g2_fill_1
X_21574_ _02187_ u_LMS.w\[7\]\[3\] _02191_ VPWR VGND sg13g2_xor2_1
XFILLER_123_1024 VPWR VGND sg13g2_decap_8
X_23313_ net1288 VGND VPWR _00375_ u_LMS.w\[4\]\[15\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
X_20525_ net614 net151 net612 _01165_ VPWR VGND sg13g2_nand3_1
XFILLER_20_373 VPWR VGND sg13g2_fill_1
XFILLER_122_7 VPWR VGND sg13g2_decap_8
XFILLER_21_34 VPWR VGND sg13g2_fill_2
XFILLER_21_45 VPWR VGND sg13g2_fill_1
X_20456_ _01064_ _01062_ _01109_ VPWR VGND sg13g2_xor2_1
X_23244_ net1402 VGND VPWR _00306_ u_LMS.w\[1\]\[15\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
XFILLER_106_412 VPWR VGND sg13g2_fill_1
XFILLER_118_272 VPWR VGND sg13g2_fill_1
X_20387_ _00972_ _01049_ _01050_ VPWR VGND sg13g2_and2_1
X_23175_ net1524 VGND VPWR _00237_ u_FIR.w\[2\]\[6\] clknet_leaf_49_clkA sg13g2_dfrbpq_1
X_22126_ _02720_ _02718_ _02719_ VPWR VGND sg13g2_nand2b_1
XFILLER_88_852 VPWR VGND sg13g2_decap_8
X_22057_ VGND VPWR _02649_ _02650_ _02651_ _02648_ sg13g2_a21oi_1
XFILLER_88_863 VPWR VGND sg13g2_fill_1
X_21008_ VGND VPWR u_LMS.w\[6\]\[21\] u_LMS.w\[6\]\[20\] _01648_ net74 sg13g2_a21oi_1
X_23194__1492 VPWR VGND net1491 sg13g2_tiehi
XFILLER_75_535 VPWR VGND sg13g2_decap_4
XFILLER_29_930 VPWR VGND sg13g2_fill_1
XFILLER_47_237 VPWR VGND sg13g2_fill_2
XFILLER_130_1039 VPWR VGND sg13g2_decap_8
X_13830_ _05130_ VPWR _05154_ VGND net282 _05131_ sg13g2_o21ai_1
XFILLER_29_952 VPWR VGND sg13g2_decap_8
XFILLER_29_963 VPWR VGND sg13g2_fill_1
X_13761_ _05014_ net754 _05086_ _05087_ VPWR VGND sg13g2_mux2_1
X_22959_ _07702_ VPWR _00816_ VGND _03285_ net524 sg13g2_o21ai_1
XFILLER_16_635 VPWR VGND sg13g2_fill_1
X_15500_ VPWR _06758_ _06757_ VGND sg13g2_inv_1
XFILLER_44_955 VPWR VGND sg13g2_decap_8
X_12712_ _04077_ _04076_ _04036_ VPWR VGND sg13g2_nand2b_1
X_16480_ _07702_ u_FIR.x\[5\] net524 VPWR VGND sg13g2_nand2_1
X_13692_ _05013_ _05019_ _05020_ VPWR VGND sg13g2_nor2b_1
XFILLER_16_679 VPWR VGND sg13g2_fill_1
XFILLER_31_616 VPWR VGND sg13g2_decap_8
XFILLER_102_81 VPWR VGND sg13g2_decap_8
X_15431_ _06693_ _06694_ _06695_ VPWR VGND sg13g2_and2_1
X_12643_ _04009_ _03982_ _04010_ VPWR VGND sg13g2_xor2_1
X_18150_ _09260_ _09240_ _09257_ VPWR VGND sg13g2_xnor2_1
X_15362_ _06629_ _06605_ _06628_ VPWR VGND sg13g2_xnor2_1
XFILLER_12_852 VPWR VGND sg13g2_decap_8
X_12574_ _03944_ net735 net906 VPWR VGND sg13g2_nand2_1
XFILLER_8_812 VPWR VGND sg13g2_decap_4
XFILLER_129_515 VPWR VGND sg13g2_decap_8
X_17101_ _08257_ net707 net246 VPWR VGND sg13g2_nand2_1
XFILLER_7_14 VPWR VGND sg13g2_decap_8
X_14313_ _05619_ u_FIR.sum\[3\]\[11\] net400 VPWR VGND sg13g2_xnor2_1
X_18081_ _09191_ net674 net79 VPWR VGND sg13g2_nand2_1
X_15293_ _06562_ _06534_ _06560_ VPWR VGND sg13g2_xnor2_1
X_17032_ _03278_ net180 _08188_ VPWR VGND sg13g2_nor2_1
XFILLER_116_209 VPWR VGND sg13g2_fill_2
X_14244_ _05544_ _05551_ _05552_ VPWR VGND sg13g2_nor2b_1
X_14175_ VGND VPWR _05447_ _05475_ _05484_ _05477_ sg13g2_a21oi_1
XFILLER_124_231 VPWR VGND sg13g2_decap_8
X_13126_ net1033 VPWR _04476_ VGND net533 u_FIR.sum\[2\]\[5\] sg13g2_o21ai_1
X_18983_ _10069_ _10042_ _10070_ VPWR VGND sg13g2_xor2_1
XFILLER_3_583 VPWR VGND sg13g2_fill_2
XFILLER_79_841 VPWR VGND sg13g2_decap_4
X_17934_ _09066_ _09051_ _09067_ VPWR VGND sg13g2_xor2_1
X_13057_ _04409_ _04406_ _04407_ VPWR VGND sg13g2_xnor2_1
XFILLER_87_71 VPWR VGND sg13g2_fill_1
XFILLER_66_502 VPWR VGND sg13g2_decap_8
X_12008_ net474 _03402_ net326 _03425_ VPWR VGND sg13g2_nor3_1
X_17865_ _08998_ u_LMS.w\[1\]\[9\] _08997_ VPWR VGND sg13g2_nand2_1
XFILLER_94_833 VPWR VGND sg13g2_fill_2
XFILLER_78_395 VPWR VGND sg13g2_decap_8
XFILLER_66_535 VPWR VGND sg13g2_fill_2
XFILLER_16_4 VPWR VGND sg13g2_fill_1
X_19604_ _10665_ _10664_ _10668_ VPWR VGND sg13g2_xor2_1
X_16816_ _07957_ _07956_ _07969_ _07972_ VPWR VGND sg13g2_nor3_2
XFILLER_66_568 VPWR VGND sg13g2_decap_8
X_17796_ net205 _08928_ net698 _08929_ VPWR VGND sg13g2_nand3_1
X_23707__1468 VPWR VGND net1467 sg13g2_tiehi
X_19535_ _10565_ _10598_ _10599_ VPWR VGND sg13g2_nor2_1
XFILLER_59_1021 VPWR VGND sg13g2_decap_4
XFILLER_19_473 VPWR VGND sg13g2_decap_4
X_16747_ _07899_ _07902_ _07903_ VPWR VGND sg13g2_nor2_1
X_13959_ _05261_ _05263_ _05277_ _05278_ VPWR VGND sg13g2_nor3_1
XFILLER_74_590 VPWR VGND sg13g2_decap_8
XFILLER_35_955 VPWR VGND sg13g2_fill_1
X_19466_ _10499_ _10529_ _10530_ VPWR VGND sg13g2_nor2b_1
X_16678_ u_LMS.w\[7\]\[23\] u_LMS.w\[7\]\[22\] u_LMS.w\[7\]\[24\] _07848_ VPWR VGND
+ u_LMS.w\[7\]\[21\] sg13g2_nand4_1
XFILLER_35_977 VPWR VGND sg13g2_decap_8
XFILLER_61_240 VPWR VGND sg13g2_fill_1
XFILLER_50_914 VPWR VGND sg13g2_decap_8
XFILLER_22_605 VPWR VGND sg13g2_fill_2
X_18417_ _09525_ _09479_ _09527_ VPWR VGND sg13g2_xor2_1
XFILLER_34_487 VPWR VGND sg13g2_fill_1
X_15629_ _06883_ _06882_ _06841_ VPWR VGND sg13g2_nand2b_1
XFILLER_21_115 VPWR VGND sg13g2_fill_2
X_19397_ _10461_ _10460_ _10459_ VPWR VGND sg13g2_nand2b_1
XFILLER_21_126 VPWR VGND sg13g2_fill_1
X_23507__1388 VPWR VGND net1387 sg13g2_tiehi
X_18348_ _09457_ _09426_ _09458_ VPWR VGND sg13g2_xor2_1
X_18279_ _09389_ _09369_ _09370_ VPWR VGND sg13g2_xnor2_1
X_20310_ _11056_ _00956_ _00973_ VPWR VGND sg13g2_nor2b_1
X_21290_ _01907_ _01903_ _01906_ VPWR VGND sg13g2_nand2_1
X_20241_ VGND VPWR _00901_ _00903_ _00904_ _00900_ sg13g2_a21oi_1
XFILLER_107_37 VPWR VGND sg13g2_decap_8
X_20172_ _00833_ _00834_ _00835_ VPWR VGND sg13g2_nor2b_1
XFILLER_88_104 VPWR VGND sg13g2_fill_2
XFILLER_131_746 VPWR VGND sg13g2_fill_2
XFILLER_130_234 VPWR VGND sg13g2_decap_8
XFILLER_69_351 VPWR VGND sg13g2_fill_1
XFILLER_69_362 VPWR VGND sg13g2_fill_2
XFILLER_29_215 VPWR VGND sg13g2_decap_8
XFILLER_111_481 VPWR VGND sg13g2_fill_1
XFILLER_123_14 VPWR VGND sg13g2_decap_8
X_22813_ VGND VPWR _07856_ net349 _00746_ _03124_ sg13g2_a21oi_1
XFILLER_38_793 VPWR VGND sg13g2_fill_2
XFILLER_26_933 VPWR VGND sg13g2_fill_1
XFILLER_26_955 VPWR VGND sg13g2_fill_2
XFILLER_16_34 VPWR VGND sg13g2_fill_2
X_22744_ u_debug_unit.mon_w2_sync\[2\] net334 _03090_ VPWR VGND sg13g2_nor2_1
X_22675_ coeff_force_packed\[43\] net471 _03067_ _00665_ VPWR VGND sg13g2_mux2_1
XFILLER_12_137 VPWR VGND sg13g2_fill_2
X_21626_ VPWR _02243_ _02242_ VGND sg13g2_inv_1
XFILLER_21_660 VPWR VGND sg13g2_fill_2
X_21557_ _02174_ net2151 net2161 VPWR VGND sg13g2_xnor2_1
XFILLER_32_77 VPWR VGND sg13g2_fill_2
XFILLER_20_192 VPWR VGND sg13g2_fill_1
X_20508_ net367 VPWR _01149_ VGND u_LMS.w\[5\]\[11\] net384 sg13g2_o21ai_1
X_12290_ _03635_ _03670_ _03671_ VPWR VGND sg13g2_nor2_1
X_21488_ _02057_ _02056_ _02105_ VPWR VGND sg13g2_xor2_1
XFILLER_5_837 VPWR VGND sg13g2_decap_4
XFILLER_10_1035 VPWR VGND sg13g2_decap_8
X_23227_ net1432 VGND VPWR _00289_ u_LMS.w\[0\]\[21\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
X_20439_ VGND VPWR _01093_ _01095_ _00401_ net940 sg13g2_a21oi_1
XFILLER_4_347 VPWR VGND sg13g2_fill_2
XFILLER_106_264 VPWR VGND sg13g2_decap_8
X_23158_ net1552 VGND VPWR _00220_ u_FIR.w\[0\]\[3\] clknet_leaf_47_clkA sg13g2_dfrbpq_1
X_22109_ _02703_ _02631_ _02632_ VPWR VGND sg13g2_xnor2_1
X_15980_ _07221_ VPWR _07222_ VGND net274 _07207_ sg13g2_o21ai_1
X_23089_ net1072 VGND VPWR _00151_ u_FIR.sum\[5\]\[13\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
XFILLER_122_779 VPWR VGND sg13g2_decap_8
XFILLER_76_811 VPWR VGND sg13g2_decap_8
X_14931_ _06214_ _06199_ _06212_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_118 VPWR VGND sg13g2_fill_1
XFILLER_48_513 VPWR VGND sg13g2_decap_8
XFILLER_57_52 VPWR VGND sg13g2_fill_2
XFILLER_75_332 VPWR VGND sg13g2_decap_8
XFILLER_75_343 VPWR VGND sg13g2_fill_1
X_17650_ _08781_ _08782_ _08783_ VPWR VGND sg13g2_nor2_1
X_14862_ _06146_ _06118_ _06148_ VPWR VGND sg13g2_xor2_1
XFILLER_76_877 VPWR VGND sg13g2_decap_8
XFILLER_36_708 VPWR VGND sg13g2_fill_1
X_16601_ _07792_ _07790_ _07791_ VPWR VGND sg13g2_nand2_1
X_13813_ _05138_ _05137_ _05102_ VPWR VGND sg13g2_nand2b_1
X_17581_ _08714_ net109 net693 net129 net691 VPWR VGND sg13g2_a22oi_1
XFILLER_90_313 VPWR VGND sg13g2_decap_8
XFILLER_35_229 VPWR VGND sg13g2_decap_8
X_14793_ _06079_ _06048_ _06081_ VPWR VGND sg13g2_xor2_1
XFILLER_91_858 VPWR VGND sg13g2_fill_2
XFILLER_17_955 VPWR VGND sg13g2_fill_2
XFILLER_113_80 VPWR VGND sg13g2_fill_2
X_19320_ _10384_ _10372_ _10383_ VPWR VGND sg13g2_xnor2_1
X_16532_ VGND VPWR u_LMS.w\[1\]\[15\] _07733_ _07741_ _07734_ sg13g2_a21oi_1
X_13744_ _05043_ _05070_ _05071_ VPWR VGND sg13g2_nor2b_1
XFILLER_44_752 VPWR VGND sg13g2_fill_1
X_23721__1375 VPWR VGND net1374 sg13g2_tiehi
XFILLER_73_62 VPWR VGND sg13g2_fill_2
X_19251_ _10324_ net55 _10323_ VPWR VGND sg13g2_nand2_1
X_16463_ net1002 VPWR _07691_ VGND net503 net2208 sg13g2_o21ai_1
Xclkbuf_3_5__f_spi_sclk clknet_3_5__leaf_spi_sclk clknet_0_spi_sclk VPWR VGND sg13g2_buf_16
X_13675_ _04982_ VPWR _05003_ VGND _04983_ _04991_ sg13g2_o21ai_1
XFILLER_16_498 VPWR VGND sg13g2_decap_8
X_23703__1496 VPWR VGND net1495 sg13g2_tiehi
XFILLER_43_295 VPWR VGND sg13g2_fill_2
X_18202_ _09312_ _09310_ _09311_ VPWR VGND sg13g2_nand2_1
X_15414_ _06677_ _06665_ _06679_ VPWR VGND sg13g2_xor2_1
XFILLER_19_1060 VPWR VGND sg13g2_fill_1
X_19182_ net30 VPWR _10269_ VGND net28 _10268_ sg13g2_o21ai_1
X_12626_ _03993_ net732 net883 VPWR VGND sg13g2_nand2_1
X_16394_ net1001 VPWR _07626_ VGND net497 u_FIR.sum\[8\]\[14\] sg13g2_o21ai_1
XFILLER_106_1030 VPWR VGND sg13g2_fill_1
X_18133_ VGND VPWR _09243_ _09229_ _09227_ sg13g2_or2_1
X_15345_ _06612_ _06609_ _06610_ VPWR VGND sg13g2_xnor2_1
X_12557_ _03930_ _03913_ _03929_ VPWR VGND sg13g2_xnor2_1
XFILLER_11_181 VPWR VGND sg13g2_decap_4
X_18064_ net421 net420 net182 net159 _09174_ VPWR VGND sg13g2_nor4_1
X_15276_ _06543_ _06544_ _06545_ VPWR VGND sg13g2_and2_1
X_12488_ _03841_ VPWR _03863_ VGND _03832_ _03842_ sg13g2_o21ai_1
X_17015_ _08170_ _08169_ _08171_ VPWR VGND sg13g2_xor2_1
X_23260__1374 VPWR VGND net1373 sg13g2_tiehi
X_14227_ _05535_ _05529_ _05533_ VPWR VGND sg13g2_xnor2_1
XFILLER_99_903 VPWR VGND sg13g2_decap_8
XFILLER_4_870 VPWR VGND sg13g2_fill_1
X_14158_ _05419_ VPWR _05468_ VGND _05416_ _05420_ sg13g2_o21ai_1
X_13109_ _04418_ _04420_ _04459_ VPWR VGND sg13g2_and2_1
XFILLER_112_245 VPWR VGND sg13g2_fill_2
X_18966_ _10025_ VPWR _10053_ VGND _03258_ net139 sg13g2_o21ai_1
X_14089_ _05399_ _05370_ _05401_ VPWR VGND sg13g2_xor2_1
XFILLER_113_779 VPWR VGND sg13g2_fill_2
XFILLER_67_811 VPWR VGND sg13g2_fill_2
XFILLER_26_1042 VPWR VGND sg13g2_fill_1
X_17917_ _08668_ _08699_ _09050_ VPWR VGND sg13g2_and2_1
X_18897_ _09984_ net660 net218 VPWR VGND sg13g2_nand2_1
XFILLER_113_1023 VPWR VGND sg13g2_fill_1
X_17848_ _08976_ _08974_ _08981_ VPWR VGND sg13g2_xor2_1
XFILLER_39_568 VPWR VGND sg13g2_decap_8
XFILLER_66_365 VPWR VGND sg13g2_fill_2
X_17779_ VPWR _08912_ _08911_ VGND sg13g2_inv_1
XFILLER_82_858 VPWR VGND sg13g2_fill_2
XFILLER_19_281 VPWR VGND sg13g2_fill_2
X_19518_ _03250_ net126 net125 net123 _10582_ VPWR VGND sg13g2_nor4_1
X_20790_ _01410_ _01408_ _01430_ VPWR VGND sg13g2_xor2_1
XFILLER_23_914 VPWR VGND sg13g2_decap_8
XFILLER_62_571 VPWR VGND sg13g2_fill_2
X_19449_ _10513_ _10508_ _10511_ VPWR VGND sg13g2_xnor2_1
XFILLER_62_593 VPWR VGND sg13g2_decap_8
XFILLER_23_947 VPWR VGND sg13g2_decap_4
XFILLER_50_766 VPWR VGND sg13g2_decap_4
X_22460_ VGND VPWR net450 _03239_ _00538_ _02979_ sg13g2_a21oi_1
XFILLER_22_468 VPWR VGND sg13g2_decap_4
X_21411_ _02028_ _02024_ _02026_ VPWR VGND sg13g2_xnor2_1
XFILLER_31_991 VPWR VGND sg13g2_decap_8
X_22391_ net947 VPWR _02945_ VGND net435 net681 sg13g2_o21ai_1
XFILLER_33_1057 VPWR VGND sg13g2_decap_4
X_21342_ _03224_ net143 _01959_ VPWR VGND sg13g2_nor2_1
XFILLER_118_14 VPWR VGND sg13g2_fill_2
XFILLER_118_25 VPWR VGND sg13g2_fill_2
X_21273_ _01890_ _01887_ _01888_ VPWR VGND sg13g2_xnor2_1
XFILLER_118_69 VPWR VGND sg13g2_decap_8
X_23012_ net1188 VGND VPWR _00074_ u_FIR.sum\[1\]\[9\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
XFILLER_1_306 VPWR VGND sg13g2_fill_2
X_20224_ _00887_ net633 net230 VPWR VGND sg13g2_nand2_1
XFILLER_89_424 VPWR VGND sg13g2_decap_8
XFILLER_103_212 VPWR VGND sg13g2_fill_2
XFILLER_104_757 VPWR VGND sg13g2_decap_8
XFILLER_104_768 VPWR VGND sg13g2_fill_2
X_20155_ _11156_ _11195_ _11196_ VPWR VGND sg13g2_nor2_1
XFILLER_131_554 VPWR VGND sg13g2_decap_8
Xrebuffer1652 net1652 net1651 VPWR VGND sg13g2_buf_1
Xrebuffer1663 net1663 net1662 VPWR VGND sg13g2_buf_1
X_20086_ _11126_ VPWR _11127_ VGND _11101_ _11123_ sg13g2_o21ai_1
XFILLER_58_833 VPWR VGND sg13g2_decap_8
XFILLER_100_941 VPWR VGND sg13g2_fill_2
XFILLER_27_11 VPWR VGND sg13g2_fill_2
XFILLER_72_313 VPWR VGND sg13g2_fill_2
XFILLER_45_527 VPWR VGND sg13g2_fill_1
X_23776_ net991 VGND VPWR _00016_ u_spi_slave.bit_cnt\[1\] clknet_3_2__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_11790_ VPWR _03211_ net4 VGND sg13g2_inv_1
X_20988_ _01628_ u_LMS.w\[6\]\[13\] net2058 VPWR VGND sg13g2_xnor2_1
XFILLER_26_774 VPWR VGND sg13g2_fill_2
XFILLER_53_582 VPWR VGND sg13g2_decap_8
X_22727_ VGND VPWR _07735_ net329 _00703_ _03081_ sg13g2_a21oi_1
XFILLER_43_21 VPWR VGND sg13g2_fill_2
XFILLER_14_958 VPWR VGND sg13g2_decap_8
XFILLER_25_295 VPWR VGND sg13g2_fill_2
XFILLER_41_755 VPWR VGND sg13g2_fill_2
X_13460_ _04798_ VPWR _04800_ VGND _04777_ _04780_ sg13g2_o21ai_1
XFILLER_43_65 VPWR VGND sg13g2_fill_1
XFILLER_41_777 VPWR VGND sg13g2_fill_2
X_22658_ coeff_force_packed\[30\] net468 _03065_ _00650_ VPWR VGND sg13g2_mux2_1
XFILLER_40_254 VPWR VGND sg13g2_decap_4
X_12411_ VGND VPWR _03756_ _03776_ _03788_ _03775_ sg13g2_a21oi_1
X_21609_ _02162_ _02164_ _02225_ _02226_ VPWR VGND sg13g2_nor3_2
XFILLER_22_991 VPWR VGND sg13g2_decap_4
X_13391_ _04732_ _04708_ _04734_ VPWR VGND sg13g2_xor2_1
XFILLER_127_805 VPWR VGND sg13g2_decap_8
X_22589_ net952 VPWR _03057_ VGND _03212_ _03055_ sg13g2_o21ai_1
X_15130_ _06401_ _06375_ _06403_ VPWR VGND sg13g2_xor2_1
X_12342_ VPWR _03721_ _03720_ VGND sg13g2_inv_1
XFILLER_111_0 VPWR VGND sg13g2_decap_8
X_15061_ net980 VPWR _06336_ VGND net484 u_FIR.sum\[6\]\[4\] sg13g2_o21ai_1
X_12273_ VGND VPWR _03654_ _03652_ _03623_ sg13g2_or2_1
XFILLER_5_656 VPWR VGND sg13g2_fill_1
X_14012_ _05326_ _05310_ _05325_ VPWR VGND sg13g2_xnor2_1
X_18820_ _09907_ _09904_ _09905_ VPWR VGND sg13g2_xnor2_1
XFILLER_49_811 VPWR VGND sg13g2_fill_1
XFILLER_95_427 VPWR VGND sg13g2_decap_8
X_18751_ _09838_ _09828_ _09837_ VPWR VGND sg13g2_xnor2_1
XFILLER_95_438 VPWR VGND sg13g2_fill_2
X_15963_ u_FIR.sum\[6\]\[17\] net390 _07206_ VPWR VGND sg13g2_nor2b_1
XFILLER_76_630 VPWR VGND sg13g2_decap_8
X_17702_ _08835_ _08831_ _08833_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_652 VPWR VGND sg13g2_fill_2
X_14914_ VGND VPWR net509 _06196_ _00152_ _06197_ sg13g2_a21oi_1
X_18682_ _09769_ _09764_ _09767_ VPWR VGND sg13g2_xnor2_1
X_15894_ _07118_ _07140_ _07141_ VPWR VGND sg13g2_nor2_1
XFILLER_76_685 VPWR VGND sg13g2_decap_8
XFILLER_91_622 VPWR VGND sg13g2_decap_4
X_17633_ net130 _08765_ net696 _08766_ VPWR VGND sg13g2_nand3_1
X_14845_ _06131_ _06123_ _06129_ VPWR VGND sg13g2_xnor2_1
X_17564_ _08690_ _08696_ _08697_ VPWR VGND sg13g2_nor2b_1
X_14776_ _06064_ _06056_ _06063_ VPWR VGND sg13g2_nand2_1
X_23306__1296 VPWR VGND net1295 sg13g2_tiehi
X_11988_ net474 net327 _03402_ _03405_ VPWR VGND sg13g2_nor3_1
XFILLER_63_379 VPWR VGND sg13g2_fill_1
X_19303_ _10367_ _10360_ _10365_ VPWR VGND sg13g2_xnor2_1
X_16515_ VGND VPWR _03353_ net488 _00223_ _07727_ sg13g2_a21oi_1
X_13727_ _05054_ net825 u_FIR.w\[5\]\[3\] net809 u_FIR.w\[5\]\[2\] VPWR VGND sg13g2_a22oi_1
X_17495_ _08620_ _08605_ _08628_ VPWR VGND sg13g2_xor2_1
XFILLER_56_1057 VPWR VGND sg13g2_decap_4
XFILLER_20_906 VPWR VGND sg13g2_fill_2
X_19234_ _10253_ VPWR _10310_ VGND _10252_ _10254_ sg13g2_o21ai_1
X_16446_ _07675_ _07665_ _07674_ VPWR VGND sg13g2_xnor2_1
X_13658_ _04987_ u_FIR.sum\[2\]\[7\] net404 VPWR VGND sg13g2_nand2_1
XFILLER_20_939 VPWR VGND sg13g2_fill_2
X_12609_ _03977_ net732 net909 VPWR VGND sg13g2_nand2_1
XFILLER_129_120 VPWR VGND sg13g2_fill_2
X_19165_ VGND VPWR _10252_ _10251_ _10250_ sg13g2_or2_1
X_16377_ VGND VPWR _07582_ _07602_ _07609_ _07601_ sg13g2_a21oi_1
XFILLER_31_298 VPWR VGND sg13g2_fill_1
X_13589_ _04884_ _04882_ _04918_ _04920_ VPWR VGND sg13g2_a21o_1
XFILLER_118_805 VPWR VGND sg13g2_decap_8
X_18116_ _09226_ net673 net144 VPWR VGND sg13g2_nand2_1
X_15328_ _06596_ _06572_ _06594_ VPWR VGND sg13g2_xnor2_1
X_19096_ _10183_ _10013_ net2084 VPWR VGND sg13g2_xnor2_1
Xclkbuf_leaf_20_clkA clknet_4_12_0_clkA clknet_leaf_20_clkA VPWR VGND sg13g2_buf_8
X_18047_ _09162_ net57 _09161_ VPWR VGND sg13g2_nand2_1
X_15259_ net496 VPWR _06529_ VGND _06527_ _06528_ sg13g2_o21ai_1
XFILLER_126_871 VPWR VGND sg13g2_fill_2
Xfanout407 _04115_ net407 VPWR VGND sg13g2_buf_1
XFILLER_63_1017 VPWR VGND sg13g2_decap_8
Xfanout418 _03275_ net418 VPWR VGND sg13g2_buf_1
XFILLER_63_1028 VPWR VGND sg13g2_fill_1
XFILLER_113_565 VPWR VGND sg13g2_decap_8
X_19998_ _10950_ _11037_ _11038_ _11039_ VPWR VGND sg13g2_nor3_1
Xfanout429 spi_wr_en net429 VPWR VGND sg13g2_buf_1
XFILLER_86_405 VPWR VGND sg13g2_fill_1
XFILLER_99_799 VPWR VGND sg13g2_decap_8
XFILLER_87_939 VPWR VGND sg13g2_fill_2
X_18949_ _10032_ _10031_ _10036_ VPWR VGND sg13g2_xor2_1
XFILLER_39_321 VPWR VGND sg13g2_fill_2
X_21960_ _03225_ net126 net2198 _02554_ VGND VPWR net123 sg13g2_nor4_2
XFILLER_95_994 VPWR VGND sg13g2_decap_8
X_20911_ _01551_ net606 net158 VPWR VGND sg13g2_nand2_1
X_23049__1133 VPWR VGND net1132 sg13g2_tiehi
X_21891_ _02485_ _02482_ _02483_ VPWR VGND sg13g2_xnor2_1
XFILLER_55_858 VPWR VGND sg13g2_decap_4
X_23630_ net972 VGND VPWR _00692_ u_debug_unit.error_signal_sync\[4\] clknet_leaf_47_clkA
+ sg13g2_dfrbpq_1
X_20842_ _01478_ _01480_ net2060 _01482_ VPWR VGND sg13g2_nand3_1
XFILLER_54_368 VPWR VGND sg13g2_fill_2
X_23561_ net965 VGND VPWR _00623_ u_debug_unit.force_w0\[7\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
X_20773_ _01411_ _01412_ _01413_ VPWR VGND sg13g2_nor2_1
Xfanout14 _01710_ net14 VPWR VGND sg13g2_buf_2
Xfanout25 _10855_ net25 VPWR VGND sg13g2_buf_2
Xfanout36 _09679_ net36 VPWR VGND sg13g2_buf_1
X_22512_ u_LMS.count\[3\] _03006_ _03008_ VPWR VGND sg13g2_nor2_1
Xfanout47 net48 net47 VPWR VGND sg13g2_buf_1
Xfanout58 net59 net58 VPWR VGND sg13g2_buf_1
X_23492_ net1440 VGND VPWR _00554_ u_LMS.x_r\[8\]\[3\] clknet_leaf_7_clkA sg13g2_dfrbpq_1
Xfanout69 net1650 net69 VPWR VGND sg13g2_buf_1
XFILLER_10_416 VPWR VGND sg13g2_decap_8
X_22443_ net959 VPWR _02971_ VGND net443 net629 sg13g2_o21ai_1
XFILLER_129_35 VPWR VGND sg13g2_decap_8
X_22374_ VGND VPWR net452 net417 _00495_ _02936_ sg13g2_a21oi_1
XFILLER_108_337 VPWR VGND sg13g2_fill_1
X_21325_ net216 _01941_ net594 _01942_ VPWR VGND sg13g2_nand3_1
XFILLER_124_819 VPWR VGND sg13g2_decap_4
XFILLER_123_307 VPWR VGND sg13g2_decap_8
X_21256_ _01873_ net598 net132 VPWR VGND sg13g2_nand2_1
Xrebuffer2150 net138 net2149 VPWR VGND sg13g2_buf_2
X_20207_ _00854_ VPWR _00870_ VGND _03242_ net161 sg13g2_o21ai_1
Xrebuffer2161 _02109_ net2160 VPWR VGND sg13g2_buf_1
Xrebuffer2172 _02847_ net2171 VPWR VGND sg13g2_buf_1
XFILLER_1_147 VPWR VGND sg13g2_decap_8
X_21187_ _01804_ _01803_ _01791_ VPWR VGND sg13g2_nand2b_1
XFILLER_1_158 VPWR VGND sg13g2_fill_2
XFILLER_132_874 VPWR VGND sg13g2_decap_8
XFILLER_104_576 VPWR VGND sg13g2_decap_8
XFILLER_132_885 VPWR VGND sg13g2_fill_2
Xfanout930 net931 net930 VPWR VGND sg13g2_buf_1
Xrebuffer2194 _08228_ net2193 VPWR VGND sg13g2_buf_1
Xfanout941 net942 net941 VPWR VGND sg13g2_buf_1
X_20138_ _11179_ _11175_ _11177_ VPWR VGND sg13g2_xnor2_1
Xfanout952 net957 net952 VPWR VGND sg13g2_buf_1
Xfanout963 net966 net963 VPWR VGND sg13g2_buf_1
XFILLER_131_395 VPWR VGND sg13g2_decap_8
Xfanout974 net977 net974 VPWR VGND sg13g2_buf_1
Xfanout985 net990 net985 VPWR VGND sg13g2_buf_1
X_20069_ _11110_ _11107_ _11108_ VPWR VGND sg13g2_xnor2_1
Xfanout996 net999 net996 VPWR VGND sg13g2_buf_1
X_12960_ _04288_ _04317_ _04255_ _04318_ VPWR VGND sg13g2_nand3_1
XFILLER_85_460 VPWR VGND sg13g2_decap_8
X_11911_ VPWR _03332_ u_LMS.w\[3\]\[5\] VGND sg13g2_inv_1
X_12891_ VGND VPWR _04212_ _04228_ _04251_ _04237_ sg13g2_a21oi_1
XFILLER_46_858 VPWR VGND sg13g2_fill_2
X_14630_ _05922_ _05889_ _05920_ VPWR VGND sg13g2_xnor2_1
X_11842_ VPWR _03263_ net676 VGND sg13g2_inv_1
XFILLER_72_165 VPWR VGND sg13g2_decap_4
XFILLER_14_711 VPWR VGND sg13g2_decap_8
X_14561_ _05841_ VPWR _05854_ VGND _05836_ _05839_ sg13g2_o21ai_1
X_23759_ net991 VGND VPWR _00006_ u_spi_slave.rx_shift\[1\] clknet_3_2__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_60_349 VPWR VGND sg13g2_decap_8
XFILLER_13_221 VPWR VGND sg13g2_decap_8
X_16300_ _07535_ u_FIR.sum\[7\]\[11\] net389 VPWR VGND sg13g2_xnor2_1
X_13512_ _04845_ net751 net892 VPWR VGND sg13g2_nand2_1
X_17280_ _08436_ u_LMS.w\[0\]\[4\] _08428_ VPWR VGND sg13g2_xnor2_1
X_14492_ net876 u_FIR.sum\[4\]\[2\] net773 _05788_ VPWR VGND sg13g2_nand3_1
XFILLER_9_214 VPWR VGND sg13g2_fill_1
XFILLER_110_70 VPWR VGND sg13g2_decap_8
X_16231_ _07468_ _07467_ _07427_ VPWR VGND sg13g2_nand2b_1
XFILLER_9_236 VPWR VGND sg13g2_decap_4
X_13443_ _04775_ _04766_ _04774_ _04783_ VPWR VGND sg13g2_a21o_1
Xclkbuf_leaf_43_clkA clknet_4_5_0_clkA clknet_leaf_43_clkA VPWR VGND sg13g2_buf_8
XFILLER_10_961 VPWR VGND sg13g2_fill_2
X_16162_ VGND VPWR net475 _07399_ _00197_ _07400_ sg13g2_a21oi_1
Xclkload17 clkload17/Y clknet_leaf_58_clkA VPWR VGND sg13g2_inv_2
X_13374_ _04717_ _04680_ _04716_ VPWR VGND sg13g2_nand2_1
Xclkload28 clkload28/Y clknet_leaf_41_clkA VPWR VGND sg13g2_inv_2
Xclkload39 clkload39/Y clknet_leaf_12_clkA VPWR VGND sg13g2_inv_2
X_15113_ VGND VPWR _06386_ _06384_ _06346_ sg13g2_or2_1
X_12325_ _03703_ _03679_ _03705_ VPWR VGND sg13g2_xor2_1
XFILLER_6_954 VPWR VGND sg13g2_decap_4
X_16093_ _07333_ _07332_ _07329_ VPWR VGND sg13g2_nand2b_1
XFILLER_126_145 VPWR VGND sg13g2_decap_4
XFILLER_115_819 VPWR VGND sg13g2_fill_2
XFILLER_6_976 VPWR VGND sg13g2_decap_4
X_19921_ _10961_ VPWR _10962_ VGND _03240_ _10960_ sg13g2_o21ai_1
X_15044_ _06319_ _06310_ _06317_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_475 VPWR VGND sg13g2_decap_8
X_12256_ _03638_ _03632_ _03636_ VPWR VGND sg13g2_xnor2_1
XFILLER_126_189 VPWR VGND sg13g2_decap_8
XFILLER_123_830 VPWR VGND sg13g2_decap_8
XFILLER_48_7 VPWR VGND sg13g2_decap_8
X_19852_ VPWR VGND _10903_ _10879_ _10902_ u_LMS.w\[4\]\[24\] _10904_ net311 sg13g2_a221oi_1
X_12187_ VGND VPWR u_spi_slave.bit_cnt\[1\] u_spi_slave.bit_cnt\[0\] _03577_ u_spi_slave.bit_cnt\[2\]
+ sg13g2_a21oi_1
XFILLER_122_351 VPWR VGND sg13g2_fill_2
XFILLER_123_885 VPWR VGND sg13g2_decap_8
X_18803_ _09890_ net660 net128 VPWR VGND sg13g2_nand2_1
XFILLER_68_427 VPWR VGND sg13g2_fill_1
X_19783_ _10839_ _10841_ _10844_ _10846_ _10847_ VPWR VGND sg13g2_and4_1
X_16995_ _08151_ _08148_ _08149_ VPWR VGND sg13g2_xnor2_1
XFILLER_23_1001 VPWR VGND sg13g2_fill_2
XFILLER_95_246 VPWR VGND sg13g2_fill_2
X_18734_ _09821_ _09820_ _09808_ VPWR VGND sg13g2_nand2b_1
XFILLER_37_803 VPWR VGND sg13g2_fill_1
XFILLER_110_579 VPWR VGND sg13g2_decap_8
X_15946_ _07190_ _07189_ _07166_ VPWR VGND sg13g2_nand2b_1
XFILLER_83_419 VPWR VGND sg13g2_fill_2
XFILLER_77_972 VPWR VGND sg13g2_decap_8
XFILLER_110_1004 VPWR VGND sg13g2_fill_1
XFILLER_77_994 VPWR VGND sg13g2_fill_1
X_18665_ VGND VPWR net56 _09753_ _09754_ net32 sg13g2_a21oi_1
XFILLER_64_633 VPWR VGND sg13g2_decap_8
XFILLER_37_858 VPWR VGND sg13g2_fill_2
X_15877_ _07058_ _07123_ _07124_ VPWR VGND sg13g2_nor2_1
XFILLER_110_1059 VPWR VGND sg13g2_fill_2
X_17616_ _08749_ _08709_ _08716_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_452 VPWR VGND sg13g2_fill_1
XFILLER_36_368 VPWR VGND sg13g2_decap_8
X_14828_ _06085_ _06114_ _06115_ VPWR VGND sg13g2_nor2b_1
X_18596_ _09700_ net2091 net2092 VPWR VGND sg13g2_xnor2_1
XFILLER_63_165 VPWR VGND sg13g2_fill_1
X_17547_ _03270_ net99 _08680_ VPWR VGND sg13g2_nor2_2
X_14759_ _06041_ _06044_ _06047_ VPWR VGND sg13g2_nor2_1
X_17478_ _08611_ net689 net81 VPWR VGND sg13g2_nand2_1
X_19217_ VGND VPWR u_LMS.w\[3\]\[19\] net304 _10297_ _10292_ sg13g2_a21oi_1
X_16429_ _07657_ _07656_ _07659_ VPWR VGND sg13g2_xor2_1
XFILLER_20_747 VPWR VGND sg13g2_fill_1
XFILLER_74_0 VPWR VGND sg13g2_decap_8
XFILLER_118_613 VPWR VGND sg13g2_fill_2
X_19148_ _10235_ _03334_ _10179_ VPWR VGND sg13g2_nand2_1
XFILLER_118_657 VPWR VGND sg13g2_fill_1
XFILLER_106_819 VPWR VGND sg13g2_fill_2
X_19079_ _09840_ _09841_ _09807_ _10166_ VPWR VGND sg13g2_mux2_1
XFILLER_105_307 VPWR VGND sg13g2_fill_1
X_21110_ net361 VPWR _01731_ VGND u_LMS.w\[6\]\[8\] net379 sg13g2_o21ai_1
X_22090_ _02682_ VPWR _02684_ VGND net221 _02683_ sg13g2_o21ai_1
XFILLER_114_841 VPWR VGND sg13g2_fill_2
X_21041_ _01677_ net317 u_LMS.w\[6\]\[16\] coeff_force_packed\[46\] net565 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_119_1040 VPWR VGND sg13g2_decap_8
Xfanout204 net207 net204 VPWR VGND sg13g2_buf_1
XFILLER_5_91 VPWR VGND sg13g2_decap_8
Xfanout215 net216 net215 VPWR VGND sg13g2_buf_1
Xfanout226 net234 net226 VPWR VGND sg13g2_buf_1
Xfanout237 _07917_ net237 VPWR VGND sg13g2_buf_1
XFILLER_101_524 VPWR VGND sg13g2_decap_4
XFILLER_115_37 VPWR VGND sg13g2_decap_8
XFILLER_101_535 VPWR VGND sg13g2_decap_8
Xfanout248 net249 net248 VPWR VGND sg13g2_buf_1
Xfanout259 net260 net259 VPWR VGND sg13g2_buf_1
XFILLER_86_246 VPWR VGND sg13g2_decap_4
X_22992_ net1218 VGND VPWR _00054_ u_FIR.sum\[0\]\[4\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
XFILLER_86_279 VPWR VGND sg13g2_fill_2
XFILLER_28_836 VPWR VGND sg13g2_decap_8
X_21943_ _02536_ _02529_ _02537_ VPWR VGND sg13g2_xor2_1
XFILLER_27_346 VPWR VGND sg13g2_fill_2
XFILLER_131_25 VPWR VGND sg13g2_decap_8
XFILLER_82_452 VPWR VGND sg13g2_decap_4
XFILLER_55_666 VPWR VGND sg13g2_fill_1
X_21874_ _02468_ net580 net130 VPWR VGND sg13g2_nand2_1
XFILLER_54_165 VPWR VGND sg13g2_decap_8
XFILLER_36_880 VPWR VGND sg13g2_fill_2
X_23613_ net967 VGND VPWR _00675_ coeff_force_packed\[52\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
X_20825_ _01465_ net2060 _01463_ VPWR VGND sg13g2_xnor2_1
XFILLER_126_1000 VPWR VGND sg13g2_decap_8
XFILLER_23_541 VPWR VGND sg13g2_fill_2
X_23544_ net964 VGND VPWR _00606_ debug_load_bus\[6\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_20756_ _01394_ _01395_ _01396_ VPWR VGND sg13g2_nor2_1
XFILLER_11_736 VPWR VGND sg13g2_decap_8
XFILLER_11_747 VPWR VGND sg13g2_fill_1
X_23475_ net1500 VGND VPWR _00537_ u_LMS.x_r\[6\]\[2\] clknet_leaf_11_clkA sg13g2_dfrbpq_1
X_20687_ _01327_ _01323_ _01326_ VPWR VGND sg13g2_nand2_1
XFILLER_7_718 VPWR VGND sg13g2_decap_8
XFILLER_108_101 VPWR VGND sg13g2_fill_2
X_22426_ VGND VPWR net438 _03256_ _00521_ _02962_ sg13g2_a21oi_1
XFILLER_6_239 VPWR VGND sg13g2_decap_8
X_22357_ net1027 VPWR _02928_ VGND net454 u_LMS.x_r\[0\]\[0\] sg13g2_o21ai_1
X_12110_ _03521_ _03438_ u_debug_unit.error_signal_sync\[2\] _03407_ u_debug_unit.mon_w1_sync\[2\]
+ VPWR VGND sg13g2_a22oi_1
X_21308_ _01925_ _01894_ _01924_ VPWR VGND sg13g2_nand2_1
X_13090_ VGND VPWR net522 _04439_ _00085_ _04440_ sg13g2_a21oi_1
X_22288_ net8 VPWR _02875_ VGND net7 _02874_ sg13g2_o21ai_1
XFILLER_123_126 VPWR VGND sg13g2_fill_1
X_12041_ _03456_ net290 coeff_force_packed\[6\] net293 coeff_force_packed\[55\] VPWR
+ VGND sg13g2_a22oi_1
XFILLER_3_979 VPWR VGND sg13g2_decap_4
X_21239_ _01854_ _01855_ _01856_ VPWR VGND sg13g2_nor2b_1
XFILLER_78_714 VPWR VGND sg13g2_fill_1
XFILLER_105_885 VPWR VGND sg13g2_fill_2
XFILLER_120_811 VPWR VGND sg13g2_decap_8
XFILLER_132_682 VPWR VGND sg13g2_decap_8
XFILLER_77_224 VPWR VGND sg13g2_decap_8
XFILLER_78_758 VPWR VGND sg13g2_decap_8
XFILLER_78_769 VPWR VGND sg13g2_fill_1
Xfanout760 u_FIR.w\[4\]\[4\] net760 VPWR VGND sg13g2_buf_1
Xfanout771 u_FIR.w\[3\]\[2\] net771 VPWR VGND sg13g2_buf_1
X_15800_ _07048_ _07015_ _07050_ VPWR VGND sg13g2_xor2_1
Xfanout782 net783 net782 VPWR VGND sg13g2_buf_1
X_16780_ VPWR _07936_ _07935_ VGND sg13g2_inv_1
X_13992_ VPWR _05307_ _05306_ VGND sg13g2_inv_1
XFILLER_93_728 VPWR VGND sg13g2_fill_1
Xfanout793 net794 net793 VPWR VGND sg13g2_buf_1
XFILLER_58_460 VPWR VGND sg13g2_fill_2
XFILLER_59_994 VPWR VGND sg13g2_fill_1
XFILLER_1_49 VPWR VGND sg13g2_decap_8
XFILLER_58_482 VPWR VGND sg13g2_decap_8
X_15731_ _03373_ net860 _06982_ VPWR VGND sg13g2_nor2_1
X_12943_ _04302_ _04266_ _04300_ VPWR VGND sg13g2_xnor2_1
XFILLER_100_590 VPWR VGND sg13g2_fill_1
X_18450_ _09557_ _09559_ _09560_ VPWR VGND sg13g2_nor2_1
XFILLER_34_817 VPWR VGND sg13g2_decap_8
X_15662_ _06909_ _06914_ _06915_ VPWR VGND sg13g2_nor2b_1
X_12874_ _04235_ _04234_ _04192_ VPWR VGND sg13g2_nand2b_1
XFILLER_34_828 VPWR VGND sg13g2_fill_1
X_17401_ VGND VPWR u_LMS.w\[0\]\[23\] net314 _08546_ _08524_ sg13g2_a21oi_1
XFILLER_33_327 VPWR VGND sg13g2_decap_8
X_14613_ _05905_ _05898_ _05904_ VPWR VGND sg13g2_nand2_1
X_11825_ VPWR _03246_ net645 VGND sg13g2_inv_1
XFILLER_33_338 VPWR VGND sg13g2_fill_2
X_18381_ _09491_ _09489_ _09490_ VPWR VGND sg13g2_nand2_1
X_15593_ _06848_ _06839_ _06846_ VPWR VGND sg13g2_xnor2_1
XFILLER_26_390 VPWR VGND sg13g2_fill_1
X_17332_ _08483_ VPWR _08488_ VGND _03354_ _08395_ sg13g2_o21ai_1
X_14544_ net849 net774 u_FIR.sum\[4\]\[4\] _05838_ VPWR VGND sg13g2_a21o_1
XFILLER_42_883 VPWR VGND sg13g2_decap_8
X_17263_ _08349_ _08348_ _08419_ VPWR VGND sg13g2_xor2_1
X_14475_ _05774_ _05765_ _05773_ VPWR VGND sg13g2_xnor2_1
X_19002_ _10089_ net664 net219 VPWR VGND sg13g2_nand2_1
X_16214_ _07449_ _07450_ _07451_ VPWR VGND sg13g2_and2_1
X_13426_ VGND VPWR _04741_ _04747_ _04767_ _04754_ sg13g2_a21oi_1
X_17194_ VGND VPWR _08301_ _08350_ _08349_ _08348_ sg13g2_a21oi_2
X_16145_ _07384_ _07366_ _07382_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_977 VPWR VGND sg13g2_fill_2
X_13357_ _04701_ _04676_ _04700_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_465 VPWR VGND sg13g2_fill_1
X_12308_ _03688_ net723 net857 VPWR VGND sg13g2_nand2_1
X_16076_ _07317_ _07308_ _07315_ VPWR VGND sg13g2_xnor2_1
X_13288_ net941 _04633_ _00090_ VPWR VGND sg13g2_nor2_1
XFILLER_114_126 VPWR VGND sg13g2_fill_2
XFILLER_46_4 VPWR VGND sg13g2_fill_1
X_19904_ _10945_ _10941_ _10944_ VPWR VGND sg13g2_nand2_1
X_15027_ _06282_ _06277_ _06275_ _06303_ VPWR VGND sg13g2_a21o_1
XFILLER_130_608 VPWR VGND sg13g2_fill_2
X_12239_ net1037 VPWR _03622_ VGND net540 u_FIR.sum\[0\]\[3\] sg13g2_o21ai_1
XFILLER_96_500 VPWR VGND sg13g2_decap_8
X_19835_ _10890_ u_LMS.w\[4\]\[21\] net65 VPWR VGND sg13g2_xnor2_1
XFILLER_60_1009 VPWR VGND sg13g2_decap_8
XFILLER_69_769 VPWR VGND sg13g2_decap_8
XFILLER_110_354 VPWR VGND sg13g2_fill_2
XFILLER_110_365 VPWR VGND sg13g2_fill_2
X_19766_ VPWR _10830_ net66 VGND sg13g2_inv_1
XFILLER_96_588 VPWR VGND sg13g2_fill_2
X_16978_ net704 net236 u_LMS.x_r\[0\]\[7\] _08134_ VPWR VGND net214 sg13g2_nand4_1
Xinput4 x_serial net4 VPWR VGND sg13g2_buf_1
XFILLER_77_791 VPWR VGND sg13g2_decap_8
X_18717_ _09796_ _09781_ _09804_ VPWR VGND sg13g2_xor2_1
X_15929_ _07125_ _07155_ _07172_ _07174_ VPWR VGND sg13g2_or3_1
XFILLER_65_942 VPWR VGND sg13g2_fill_2
X_19697_ _10761_ _10715_ _10716_ VPWR VGND sg13g2_xnor2_1
XFILLER_36_143 VPWR VGND sg13g2_fill_1
X_18648_ _09741_ _09625_ _09626_ VPWR VGND sg13g2_xnor2_1
XFILLER_37_688 VPWR VGND sg13g2_decap_8
XFILLER_92_794 VPWR VGND sg13g2_decap_8
XFILLER_64_485 VPWR VGND sg13g2_decap_8
X_18579_ VGND VPWR _09686_ _09687_ _00327_ net921 sg13g2_a21oi_1
X_20610_ _01250_ _01247_ _01248_ VPWR VGND sg13g2_xnor2_1
XFILLER_51_168 VPWR VGND sg13g2_fill_1
X_21590_ VGND VPWR _02204_ _02205_ _02207_ _02179_ sg13g2_a21oi_1
X_20541_ net111 _01179_ net608 _01181_ VPWR VGND sg13g2_nand3_1
XFILLER_119_900 VPWR VGND sg13g2_decap_8
X_23260_ net1373 VGND VPWR _00322_ u_LMS.w\[1\]\[8\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
X_20472_ net363 VPWR _01122_ VGND u_LMS.w\[5\]\[2\] net381 sg13g2_o21ai_1
X_22211_ _02774_ VPWR _02805_ VGND _02802_ _02803_ sg13g2_o21ai_1
X_23191_ net1496 VGND VPWR _00253_ u_FIR.w\[5\]\[1\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
XFILLER_10_14 VPWR VGND sg13g2_decap_8
XFILLER_69_1056 VPWR VGND sg13g2_fill_1
X_22142_ _02422_ VPWR _02736_ VGND _02424_ _02735_ sg13g2_o21ai_1
XFILLER_10_36 VPWR VGND sg13g2_decap_8
XFILLER_105_137 VPWR VGND sg13g2_decap_4
XFILLER_10_47 VPWR VGND sg13g2_fill_2
XFILLER_126_14 VPWR VGND sg13g2_decap_8
X_22073_ _02667_ _02664_ _02666_ VPWR VGND sg13g2_nand2_1
XFILLER_87_500 VPWR VGND sg13g2_fill_2
XFILLER_114_660 VPWR VGND sg13g2_decap_4
XFILLER_86_29 VPWR VGND sg13g2_decap_8
X_21024_ _01664_ net317 u_LMS.w\[6\]\[12\] coeff_force_packed\[42\] net565 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_102_844 VPWR VGND sg13g2_decap_8
XFILLER_101_321 VPWR VGND sg13g2_fill_2
XFILLER_87_555 VPWR VGND sg13g2_decap_8
X_21926_ _02520_ _02489_ _02519_ VPWR VGND sg13g2_nand2_1
XFILLER_16_828 VPWR VGND sg13g2_fill_2
XFILLER_82_271 VPWR VGND sg13g2_fill_1
X_21857_ _02451_ _02379_ _02380_ VPWR VGND sg13g2_xnor2_1
XFILLER_71_989 VPWR VGND sg13g2_decap_8
XFILLER_24_861 VPWR VGND sg13g2_fill_1
X_20808_ _01446_ _01447_ _01448_ VPWR VGND sg13g2_nor2_1
X_12590_ net883 net737 u_FIR.sum\[0\]\[2\] _03959_ VPWR VGND sg13g2_a21o_1
X_21788_ _02374_ _02381_ _02382_ VPWR VGND sg13g2_nor2_1
XFILLER_23_360 VPWR VGND sg13g2_fill_1
X_23527_ net1311 VGND VPWR _00589_ u_LMS.count\[30\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
XFILLER_129_708 VPWR VGND sg13g2_fill_2
X_20739_ VGND VPWR _01368_ _01369_ _01379_ _01378_ sg13g2_a21oi_1
XFILLER_51_54 VPWR VGND sg13g2_fill_2
X_14260_ _05535_ _05528_ _05542_ _05567_ VPWR VGND sg13g2_a21o_1
X_23003__1202 VPWR VGND net1201 sg13g2_tiehi
X_23165__1542 VPWR VGND net1541 sg13g2_tiehi
X_23458_ net1557 VGND VPWR _00520_ u_LMS.x_r\[4\]\[1\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
X_13211_ VGND VPWR _04520_ _04527_ _04558_ _04534_ sg13g2_a21oi_1
XFILLER_109_454 VPWR VGND sg13g2_fill_2
X_22409_ net947 VPWR _02954_ VGND net433 net662 sg13g2_o21ai_1
XFILLER_100_1014 VPWR VGND sg13g2_decap_8
X_14191_ _05497_ _05498_ _05499_ _05500_ VPWR VGND sg13g2_nor3_1
XFILLER_100_1025 VPWR VGND sg13g2_fill_1
X_23389_ net1181 VGND VPWR _00451_ u_LMS.w\[7\]\[22\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
X_13142_ _04491_ _04449_ _04489_ VPWR VGND sg13g2_xnor2_1
XFILLER_4_0 VPWR VGND sg13g2_decap_8
X_17950_ net78 u_LMS.w\[1\]\[22\] _09083_ VPWR VGND sg13g2_xor2_1
X_13073_ _04401_ _04403_ _04424_ VPWR VGND sg13g2_and2_1
XFILLER_111_107 VPWR VGND sg13g2_fill_1
X_16901_ _08055_ _08049_ _08057_ VPWR VGND sg13g2_xor2_1
X_12024_ _03417_ _03427_ _03441_ VPWR VGND sg13g2_nor2_1
XFILLER_2_275 VPWR VGND sg13g2_decap_8
X_17881_ _09013_ _09012_ _09014_ VPWR VGND sg13g2_nor2b_1
X_19620_ net206 net647 _10655_ _10684_ VPWR VGND sg13g2_a21o_1
X_16832_ _07988_ net711 net155 VPWR VGND sg13g2_nand2_1
XFILLER_120_663 VPWR VGND sg13g2_fill_1
Xfanout590 u_LMS.x_r\[7\]\[7\] net590 VPWR VGND sg13g2_buf_1
XFILLER_19_622 VPWR VGND sg13g2_decap_4
X_19551_ _10604_ VPWR _10615_ VGND _10571_ _10602_ sg13g2_o21ai_1
X_16763_ _07919_ net915 _07913_ VPWR VGND sg13g2_nand2_1
X_13975_ _05291_ _05292_ _00118_ VPWR VGND sg13g2_nor2_1
XFILLER_47_964 VPWR VGND sg13g2_fill_1
XFILLER_19_655 VPWR VGND sg13g2_decap_8
X_18502_ _09612_ _09503_ _09534_ VPWR VGND sg13g2_xnor2_1
X_15714_ _06966_ _06958_ _06965_ VPWR VGND sg13g2_xnor2_1
XFILLER_34_603 VPWR VGND sg13g2_fill_1
XFILLER_19_677 VPWR VGND sg13g2_decap_8
X_19482_ _10514_ _10513_ _10546_ VPWR VGND sg13g2_xor2_1
X_12926_ _04261_ VPWR _04285_ VGND _04217_ _04262_ sg13g2_o21ai_1
XFILLER_20_1059 VPWR VGND sg13g2_fill_2
X_16694_ net1023 VPWR _07861_ VGND net519 u_FIR.w\[7\]\[3\] sg13g2_o21ai_1
XFILLER_73_282 VPWR VGND sg13g2_decap_8
X_18433_ VGND VPWR _09541_ _09542_ _09543_ _09519_ sg13g2_a21oi_1
XFILLER_62_956 VPWR VGND sg13g2_fill_2
X_15645_ _06883_ VPWR _06898_ VGND _06877_ _06881_ sg13g2_o21ai_1
X_12857_ _04218_ _04176_ _04179_ VPWR VGND sg13g2_nand2_1
XFILLER_62_978 VPWR VGND sg13g2_decap_8
XFILLER_22_809 VPWR VGND sg13g2_fill_1
XFILLER_33_146 VPWR VGND sg13g2_decap_4
X_18364_ _09465_ _09466_ _09474_ VPWR VGND sg13g2_nor2b_1
X_11808_ VPWR _03229_ net610 VGND sg13g2_inv_1
X_15576_ _06831_ net788 net858 VPWR VGND sg13g2_nand2_1
X_12788_ _04134_ _04150_ _04151_ VPWR VGND sg13g2_nor2b_1
X_17315_ VGND VPWR _08403_ _08469_ _08471_ _08470_ sg13g2_a21oi_1
X_14527_ _05822_ _05801_ _05821_ VPWR VGND sg13g2_nand2_1
X_18295_ _09405_ _09403_ _09404_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_218 VPWR VGND sg13g2_fill_1
X_23343__1259 VPWR VGND net1258 sg13g2_tiehi
X_17246_ _08402_ _08377_ _08398_ VPWR VGND sg13g2_xnor2_1
X_14458_ _05756_ _05734_ _05758_ VPWR VGND sg13g2_xor2_1
X_13409_ _04750_ net283 _04751_ VPWR VGND sg13g2_xor2_1
X_17177_ _08325_ _08332_ _08333_ VPWR VGND sg13g2_nor2b_1
X_14389_ net1006 VPWR _05693_ VGND net512 u_FIR.sum\[4\]\[13\] sg13g2_o21ai_1
X_16128_ _07367_ _07331_ _07333_ VPWR VGND sg13g2_nand2_1
XFILLER_115_424 VPWR VGND sg13g2_fill_1
X_16059_ _07300_ net797 net858 VPWR VGND sg13g2_nand2_1
XFILLER_88_319 VPWR VGND sg13g2_decap_8
XFILLER_130_405 VPWR VGND sg13g2_fill_2
XFILLER_131_939 VPWR VGND sg13g2_decap_8
XFILLER_37_0 VPWR VGND sg13g2_fill_2
XFILLER_130_449 VPWR VGND sg13g2_fill_1
XFILLER_123_490 VPWR VGND sg13g2_decap_4
XFILLER_96_341 VPWR VGND sg13g2_fill_1
XFILLER_5_1009 VPWR VGND sg13g2_decap_8
X_19818_ _10741_ _10810_ _10831_ _10876_ VPWR VGND sg13g2_or3_1
XFILLER_2_70 VPWR VGND sg13g2_decap_8
X_19749_ _10811_ _10812_ _10433_ _10813_ VPWR VGND sg13g2_nand3_1
XFILLER_72_709 VPWR VGND sg13g2_decap_8
XFILLER_65_761 VPWR VGND sg13g2_fill_2
X_22760_ u_debug_unit.mon_w3_sync\[3\] net335 _03098_ VPWR VGND sg13g2_nor2_1
XFILLER_53_923 VPWR VGND sg13g2_decap_8
XFILLER_38_997 VPWR VGND sg13g2_fill_1
X_21711_ net362 VPWR _02313_ VGND u_LMS.w\[7\]\[4\] net380 sg13g2_o21ai_1
X_23519__1341 VPWR VGND net1340 sg13g2_tiehi
XFILLER_92_591 VPWR VGND sg13g2_decap_8
X_22691_ net429 net288 _03069_ VPWR VGND sg13g2_and2_1
XFILLER_80_764 VPWR VGND sg13g2_decap_8
XFILLER_12_308 VPWR VGND sg13g2_decap_8
X_21642_ VGND VPWR _02256_ _02257_ _00442_ net930 sg13g2_a21oi_1
XFILLER_75_1060 VPWR VGND sg13g2_fill_1
X_21573_ u_LMS.w\[7\]\[3\] _02187_ _02190_ VPWR VGND sg13g2_nor2_1
X_23312_ net1289 VGND VPWR _00374_ u_LMS.w\[4\]\[14\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
X_20524_ _01164_ net616 net151 VPWR VGND sg13g2_nand2_1
X_23319__1283 VPWR VGND net1282 sg13g2_tiehi
X_23243_ net1404 VGND VPWR _00305_ u_LMS.w\[1\]\[14\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
XFILLER_119_763 VPWR VGND sg13g2_fill_2
X_20455_ VGND VPWR _01107_ _01108_ _00404_ net937 sg13g2_a21oi_1
XFILLER_4_518 VPWR VGND sg13g2_fill_1
XFILLER_119_785 VPWR VGND sg13g2_fill_2
XFILLER_115_7 VPWR VGND sg13g2_decap_8
XFILLER_107_936 VPWR VGND sg13g2_fill_1
XFILLER_21_68 VPWR VGND sg13g2_decap_4
XFILLER_119_796 VPWR VGND sg13g2_fill_1
X_23174_ net1526 VGND VPWR _00236_ u_FIR.w\[2\]\[5\] clknet_leaf_45_clkA sg13g2_dfrbpq_1
X_20386_ _01049_ net75 u_LMS.w\[5\]\[18\] VPWR VGND sg13g2_xnor2_1
X_22125_ _02513_ _02518_ _02719_ VPWR VGND sg13g2_xor2_1
XFILLER_97_39 VPWR VGND sg13g2_fill_2
XFILLER_82_1020 VPWR VGND sg13g2_fill_2
XFILLER_121_438 VPWR VGND sg13g2_fill_1
X_22056_ _02647_ _02646_ _02650_ VPWR VGND sg13g2_xor2_1
XFILLER_88_842 VPWR VGND sg13g2_fill_2
X_21007_ u_LMS.w\[6\]\[20\] net73 _01647_ VPWR VGND sg13g2_nor2_1
XFILLER_87_352 VPWR VGND sg13g2_fill_1
XFILLER_130_1018 VPWR VGND sg13g2_decap_8
XFILLER_46_43 VPWR VGND sg13g2_fill_2
X_13760_ _05055_ _05085_ _05086_ VPWR VGND sg13g2_nor2_1
X_22958_ _07700_ VPWR _00815_ VGND _03286_ net524 sg13g2_o21ai_1
XFILLER_90_528 VPWR VGND sg13g2_decap_4
XFILLER_43_400 VPWR VGND sg13g2_fill_2
XFILLER_15_102 VPWR VGND sg13g2_fill_1
XFILLER_46_98 VPWR VGND sg13g2_decap_4
X_21909_ _02503_ _02498_ _02501_ VPWR VGND sg13g2_xnor2_1
X_12711_ _04075_ _04071_ _04076_ VPWR VGND sg13g2_xor2_1
X_13691_ _05017_ _05018_ _05019_ VPWR VGND sg13g2_nor2b_1
X_22889_ _03173_ net297 u_FIR.x\[1\] net298 u_s2p_input.reg_sh\[0\] VPWR VGND sg13g2_a22oi_1
XFILLER_16_669 VPWR VGND sg13g2_fill_1
XFILLER_102_60 VPWR VGND sg13g2_decap_4
Xclkbuf_3_4__f_spi_sclk clknet_3_4__leaf_spi_sclk clknet_0_spi_sclk VPWR VGND sg13g2_buf_16
XFILLER_62_20 VPWR VGND sg13g2_decap_8
X_15430_ _06643_ _06673_ _06692_ _06694_ VPWR VGND sg13g2_or3_1
X_12642_ _04009_ _04000_ _04007_ VPWR VGND sg13g2_xnor2_1
XFILLER_71_786 VPWR VGND sg13g2_decap_8
XFILLER_62_53 VPWR VGND sg13g2_decap_8
XFILLER_30_127 VPWR VGND sg13g2_decap_4
X_15361_ _06628_ _06606_ _06626_ VPWR VGND sg13g2_xnor2_1
X_12573_ _03942_ _03943_ _00065_ VPWR VGND sg13g2_nor2_1
XFILLER_30_149 VPWR VGND sg13g2_fill_2
XFILLER_11_341 VPWR VGND sg13g2_decap_8
X_17100_ VGND VPWR _08256_ _08255_ _08170_ sg13g2_or2_1
X_14312_ _05618_ u_FIR.sum\[3\]\[11\] net400 VPWR VGND sg13g2_nand2_1
X_18080_ net676 net144 net674 _09190_ VPWR VGND sg13g2_nand3_1
X_15292_ _06534_ _06560_ _06561_ VPWR VGND sg13g2_nor2b_1
XFILLER_8_868 VPWR VGND sg13g2_decap_8
X_17031_ _08187_ net710 net172 VPWR VGND sg13g2_nand2_1
X_14243_ _05551_ _05509_ _05549_ VPWR VGND sg13g2_xnor2_1
X_14174_ VGND VPWR net506 _05482_ _00126_ _05483_ sg13g2_a21oi_1
XFILLER_125_766 VPWR VGND sg13g2_fill_2
X_13125_ VGND VPWR _04473_ _04474_ _04475_ net416 sg13g2_a21oi_1
X_18982_ _10069_ net658 net254 VPWR VGND sg13g2_nand2_1
XFILLER_124_265 VPWR VGND sg13g2_decap_8
XFILLER_98_639 VPWR VGND sg13g2_decap_8
XFILLER_97_116 VPWR VGND sg13g2_fill_2
XFILLER_124_276 VPWR VGND sg13g2_fill_1
X_17933_ _09066_ _09052_ _09065_ VPWR VGND sg13g2_xnor2_1
X_13056_ _04406_ _04407_ _04408_ VPWR VGND sg13g2_nor2b_1
XFILLER_30_7 VPWR VGND sg13g2_fill_1
XFILLER_78_341 VPWR VGND sg13g2_decap_8
X_12007_ _03406_ net326 _03424_ VPWR VGND sg13g2_nor2_1
XFILLER_94_801 VPWR VGND sg13g2_fill_2
X_17864_ _08997_ _08951_ _08953_ VPWR VGND sg13g2_xnor2_1
XFILLER_78_374 VPWR VGND sg13g2_decap_8
XFILLER_120_460 VPWR VGND sg13g2_decap_8
XFILLER_39_739 VPWR VGND sg13g2_decap_8
X_19603_ _10659_ _10657_ _10661_ _10667_ VPWR VGND sg13g2_a21o_1
X_16815_ VPWR VGND _07955_ _07970_ _07958_ _07908_ _07971_ _07952_ sg13g2_a221oi_1
X_17795_ _08928_ net701 net243 VPWR VGND sg13g2_nand2_1
XFILLER_47_750 VPWR VGND sg13g2_decap_4
XFILLER_4_1053 VPWR VGND sg13g2_decap_8
XFILLER_19_452 VPWR VGND sg13g2_decap_8
X_19534_ VGND VPWR _10596_ _10597_ _10598_ _10595_ sg13g2_a21oi_1
X_16746_ u_FIR.sum\[8\]\[8\] _03378_ net1643 _07902_ VPWR VGND sg13g2_mux2_2
XFILLER_98_1060 VPWR VGND sg13g2_fill_1
X_13958_ _05277_ _05267_ _05275_ VPWR VGND sg13g2_xnor2_1
XFILLER_47_783 VPWR VGND sg13g2_fill_2
X_23387__1188 VPWR VGND net1187 sg13g2_tiehi
XFILLER_59_1033 VPWR VGND sg13g2_fill_1
XFILLER_34_422 VPWR VGND sg13g2_decap_8
X_19465_ _10527_ VPWR _10529_ VGND _10523_ _10528_ sg13g2_o21ai_1
X_12909_ _04269_ _04268_ _04232_ VPWR VGND sg13g2_nand2b_1
XFILLER_46_293 VPWR VGND sg13g2_fill_2
X_16677_ u_LMS.w\[7\]\[19\] u_LMS.w\[7\]\[18\] u_LMS.w\[7\]\[20\] _07847_ VPWR VGND
+ sg13g2_nand3_1
X_13889_ VGND VPWR _05184_ _05203_ _05211_ _05202_ sg13g2_a21oi_1
XFILLER_35_989 VPWR VGND sg13g2_decap_8
XFILLER_34_466 VPWR VGND sg13g2_fill_1
X_18416_ _09526_ net681 net239 VPWR VGND sg13g2_nand2_1
X_15628_ _06881_ _06877_ _06882_ VPWR VGND sg13g2_xor2_1
XFILLER_107_1009 VPWR VGND sg13g2_fill_1
X_19396_ _10460_ _10390_ _10392_ VPWR VGND sg13g2_xnor2_1
X_18347_ _09457_ net675 net238 VPWR VGND sg13g2_nand2_1
X_15559_ _06815_ _06814_ _06794_ VPWR VGND sg13g2_nand2b_1
X_18278_ _09388_ _09366_ _09387_ VPWR VGND sg13g2_xnor2_1
X_17229_ _08385_ _08056_ _08384_ _08055_ _08004_ VPWR VGND sg13g2_a22oi_1
X_20240_ _00902_ VPWR _00903_ VGND _00893_ _00895_ sg13g2_o21ai_1
X_23279__1336 VPWR VGND net1335 sg13g2_tiehi
XFILLER_66_1004 VPWR VGND sg13g2_fill_1
XFILLER_131_703 VPWR VGND sg13g2_fill_2
X_20171_ _00831_ _00830_ _00834_ VPWR VGND sg13g2_xor2_1
X_23123__1605 VPWR VGND net1604 sg13g2_tiehi
XFILLER_131_714 VPWR VGND sg13g2_fill_2
XFILLER_104_939 VPWR VGND sg13g2_fill_1
XFILLER_66_1059 VPWR VGND sg13g2_fill_2
XFILLER_112_961 VPWR VGND sg13g2_fill_2
XFILLER_97_694 VPWR VGND sg13g2_decap_8
XFILLER_84_322 VPWR VGND sg13g2_decap_8
XFILLER_57_547 VPWR VGND sg13g2_decap_8
XFILLER_85_878 VPWR VGND sg13g2_decap_8
X_22812_ u_debug_unit.mon_w7_sync\[1\] net349 _03124_ VPWR VGND sg13g2_nor2_1
XFILLER_25_422 VPWR VGND sg13g2_decap_8
X_22743_ VGND VPWR _07757_ net333 _00711_ _03089_ sg13g2_a21oi_1
XFILLER_53_742 VPWR VGND sg13g2_fill_1
XFILLER_25_433 VPWR VGND sg13g2_fill_1
XFILLER_41_915 VPWR VGND sg13g2_decap_8
XFILLER_73_1019 VPWR VGND sg13g2_decap_8
XFILLER_52_252 VPWR VGND sg13g2_decap_8
XFILLER_16_68 VPWR VGND sg13g2_fill_1
XFILLER_40_403 VPWR VGND sg13g2_fill_1
X_22674_ coeff_force_packed\[42\] net473 _03067_ _00664_ VPWR VGND sg13g2_mux2_1
XFILLER_80_583 VPWR VGND sg13g2_fill_1
X_23197__1486 VPWR VGND net1485 sg13g2_tiehi
XFILLER_52_296 VPWR VGND sg13g2_decap_8
X_21625_ net62 u_LMS.w\[7\]\[22\] _02242_ VPWR VGND sg13g2_xor2_1
X_21556_ _02173_ u_LMS.w\[7\]\[11\] _02172_ VPWR VGND sg13g2_nand2_1
X_20507_ VGND VPWR net51 _01147_ _01148_ net19 sg13g2_a21oi_1
X_21487_ _02056_ _02057_ _02104_ VPWR VGND sg13g2_and2_1
XFILLER_10_1014 VPWR VGND sg13g2_decap_8
XFILLER_113_4 VPWR VGND sg13g2_fill_2
X_23226_ net1434 VGND VPWR _00288_ u_LMS.w\[0\]\[20\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
X_20438_ VGND VPWR u_LMS.w\[5\]\[18\] net318 _01095_ _01094_ sg13g2_a21oi_1
X_23076__1093 VPWR VGND net1092 sg13g2_tiehi
XFILLER_107_777 VPWR VGND sg13g2_fill_2
X_23157_ net1553 VGND VPWR _00219_ u_FIR.w\[0\]\[2\] clknet_leaf_47_clkA sg13g2_dfrbpq_1
X_20369_ _01032_ _03321_ _00985_ VPWR VGND sg13g2_nand2_1
XFILLER_106_287 VPWR VGND sg13g2_fill_2
XFILLER_121_213 VPWR VGND sg13g2_decap_8
X_22108_ _02653_ VPWR _02702_ VGND _02699_ _02700_ sg13g2_o21ai_1
XFILLER_122_747 VPWR VGND sg13g2_decap_8
X_23088_ net1074 VGND VPWR _00150_ u_FIR.sum\[5\]\[12\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
XFILLER_0_543 VPWR VGND sg13g2_fill_2
XFILLER_121_246 VPWR VGND sg13g2_decap_8
XFILLER_88_661 VPWR VGND sg13g2_decap_4
X_22039_ _02631_ _02632_ _02633_ VPWR VGND sg13g2_nor2b_1
X_14930_ _06199_ _06212_ _06213_ VPWR VGND sg13g2_nor2b_1
XFILLER_102_482 VPWR VGND sg13g2_fill_1
XFILLER_130_791 VPWR VGND sg13g2_fill_2
X_14861_ _06118_ _06146_ _06147_ VPWR VGND sg13g2_nor2b_1
XFILLER_76_867 VPWR VGND sg13g2_fill_1
XFILLER_57_75 VPWR VGND sg13g2_fill_2
X_16600_ u_LMS.w\[4\]\[24\] u_LMS.w\[4\]\[23\] u_LMS.w\[4\]\[22\] u_LMS.w\[4\]\[21\]
+ _07791_ VPWR VGND sg13g2_nor4_1
X_13812_ _05136_ net280 _05137_ VPWR VGND sg13g2_xor2_1
X_17580_ _08713_ _08680_ _08711_ VPWR VGND sg13g2_nand2_1
X_14792_ _06048_ _06079_ _06080_ VPWR VGND sg13g2_nor2_1
XFILLER_75_399 VPWR VGND sg13g2_fill_2
X_16531_ VGND VPWR net481 _07739_ _00226_ _07740_ sg13g2_a21oi_1
X_13743_ _05070_ _05061_ _05068_ VPWR VGND sg13g2_xnor2_1
XFILLER_73_41 VPWR VGND sg13g2_decap_8
XFILLER_17_967 VPWR VGND sg13g2_fill_1
XFILLER_73_52 VPWR VGND sg13g2_fill_1
XFILLER_73_74 VPWR VGND sg13g2_fill_1
XFILLER_43_252 VPWR VGND sg13g2_fill_1
X_19250_ _10323_ _10203_ _10205_ VPWR VGND sg13g2_xnor2_1
X_16462_ VGND VPWR _07681_ _07688_ _07690_ _07689_ sg13g2_a21oi_1
XFILLER_43_274 VPWR VGND sg13g2_fill_2
X_13674_ VGND VPWR _04984_ _04990_ _05002_ _04989_ sg13g2_a21oi_1
X_18201_ _09311_ _09270_ _09276_ VPWR VGND sg13g2_xnor2_1
X_15413_ _06665_ _06677_ _06678_ VPWR VGND sg13g2_nor2_1
X_19181_ _10268_ net2087 _10231_ VPWR VGND sg13g2_xnor2_1
X_12625_ _03992_ net735 net867 VPWR VGND sg13g2_nand2_1
XFILLER_31_458 VPWR VGND sg13g2_decap_8
X_16393_ _07625_ _07624_ _07623_ VPWR VGND sg13g2_nand2b_1
XFILLER_31_469 VPWR VGND sg13g2_fill_2
X_18132_ _09232_ VPWR _09242_ VGND _09201_ _09233_ sg13g2_o21ai_1
X_15344_ _06611_ _06610_ _06609_ VPWR VGND sg13g2_nand2b_1
X_12556_ _03929_ _03914_ _03928_ VPWR VGND sg13g2_xnor2_1
XFILLER_89_1004 VPWR VGND sg13g2_decap_4
XFILLER_78_7 VPWR VGND sg13g2_fill_1
XFILLER_7_131 VPWR VGND sg13g2_fill_1
XFILLER_129_357 VPWR VGND sg13g2_decap_4
X_18063_ VGND VPWR net37 _09172_ _00325_ _09173_ sg13g2_a21oi_1
XFILLER_7_142 VPWR VGND sg13g2_fill_1
X_15275_ net835 net775 _06542_ _06544_ VPWR VGND sg13g2_a21o_1
X_12487_ VGND VPWR _03862_ _03861_ _03860_ sg13g2_or2_1
XFILLER_89_1059 VPWR VGND sg13g2_fill_2
X_17014_ _08170_ net707 net212 VPWR VGND sg13g2_nand2_1
X_14226_ _05534_ _05533_ _05529_ VPWR VGND sg13g2_nand2b_1
XFILLER_125_552 VPWR VGND sg13g2_fill_2
X_14157_ _05428_ u_FIR.w\[4\]\[6\] _05426_ _05467_ VPWR VGND sg13g2_a21o_1
XFILLER_113_714 VPWR VGND sg13g2_fill_2
XFILLER_125_574 VPWR VGND sg13g2_decap_8
XFILLER_98_425 VPWR VGND sg13g2_decap_8
XFILLER_4_893 VPWR VGND sg13g2_decap_4
X_13108_ _04458_ _04422_ _04456_ VPWR VGND sg13g2_xnor2_1
X_18965_ _10046_ VPWR _10052_ VGND _10015_ _10042_ sg13g2_o21ai_1
X_14088_ _05400_ _05370_ _05399_ VPWR VGND sg13g2_nand2b_1
XFILLER_113_769 VPWR VGND sg13g2_decap_4
XFILLER_79_650 VPWR VGND sg13g2_fill_1
X_17916_ _09049_ _08669_ _08975_ VPWR VGND sg13g2_nand2_1
X_13039_ VGND VPWR net522 _04390_ _00083_ _04391_ sg13g2_a21oi_1
XFILLER_85_119 VPWR VGND sg13g2_fill_2
X_18896_ _09983_ net662 net165 VPWR VGND sg13g2_nand2_1
XFILLER_66_300 VPWR VGND sg13g2_decap_4
XFILLER_78_182 VPWR VGND sg13g2_decap_8
XFILLER_66_322 VPWR VGND sg13g2_fill_2
X_17847_ VPWR _08980_ _08979_ VGND sg13g2_inv_1
XFILLER_96_1008 VPWR VGND sg13g2_fill_1
XFILLER_66_377 VPWR VGND sg13g2_decap_4
XFILLER_82_837 VPWR VGND sg13g2_decap_4
X_17778_ net697 net242 net694 _08911_ VPWR VGND net258 sg13g2_nand4_1
XFILLER_66_399 VPWR VGND sg13g2_decap_8
X_19517_ _10579_ _10578_ _10581_ VPWR VGND sg13g2_xor2_1
X_16729_ net1031 VPWR _07886_ VGND net718 net528 sg13g2_o21ai_1
XFILLER_62_561 VPWR VGND sg13g2_decap_4
X_19448_ _10512_ _10508_ _10511_ VPWR VGND sg13g2_nand2_1
XFILLER_90_892 VPWR VGND sg13g2_decap_8
XFILLER_34_296 VPWR VGND sg13g2_fill_2
X_19379_ _10441_ _10442_ _10443_ VPWR VGND sg13g2_and2_1
X_21410_ _02027_ _02024_ _02026_ VPWR VGND sg13g2_nand2_1
XFILLER_33_1025 VPWR VGND sg13g2_fill_2
X_22390_ VGND VPWR net435 _03274_ _00503_ _02944_ sg13g2_a21oi_1
XFILLER_33_1036 VPWR VGND sg13g2_fill_1
XFILLER_108_519 VPWR VGND sg13g2_decap_8
X_21341_ _03226_ net1641 net125 _01958_ VGND VPWR net1668 sg13g2_nor4_2
X_21272_ _01887_ _01888_ _01889_ VPWR VGND sg13g2_and2_1
XFILLER_128_390 VPWR VGND sg13g2_decap_8
XFILLER_118_48 VPWR VGND sg13g2_decap_8
X_23011_ net1189 VGND VPWR _00073_ u_FIR.sum\[1\]\[8\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
X_20223_ _00886_ _00876_ _00877_ VPWR VGND sg13g2_xnor2_1
XFILLER_89_403 VPWR VGND sg13g2_fill_2
XFILLER_104_736 VPWR VGND sg13g2_decap_4
XFILLER_103_224 VPWR VGND sg13g2_decap_8
XFILLER_131_533 VPWR VGND sg13g2_decap_8
X_20154_ _11195_ net261 net625 net247 u_LMS.x_r\[5\]\[5\] VPWR VGND sg13g2_a22oi_1
Xrebuffer1642 net1642 net1641 VPWR VGND sg13g2_buf_1
XFILLER_77_609 VPWR VGND sg13g2_fill_1
Xrebuffer1653 _01624_ net1652 VPWR VGND sg13g2_buf_2
Xrebuffer1664 _09643_ net1663 VPWR VGND sg13g2_buf_2
X_20085_ _11126_ _11124_ _11125_ VPWR VGND sg13g2_nand2_1
XFILLER_97_491 VPWR VGND sg13g2_fill_1
XFILLER_69_182 VPWR VGND sg13g2_fill_2
XFILLER_40_1029 VPWR VGND sg13g2_decap_8
XFILLER_45_506 VPWR VGND sg13g2_fill_1
XFILLER_27_23 VPWR VGND sg13g2_fill_1
XFILLER_17_208 VPWR VGND sg13g2_fill_2
X_23775_ net991 VGND VPWR _00015_ u_spi_slave.bit_cnt\[0\] clknet_3_2__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_20987_ VGND VPWR net1652 _01625_ _01627_ _01580_ sg13g2_a21oi_1
XFILLER_129_1042 VPWR VGND sg13g2_decap_8
X_22726_ u_debug_unit.mon_w1_sync\[0\] net329 _03081_ VPWR VGND sg13g2_nor2_1
XFILLER_25_274 VPWR VGND sg13g2_fill_2
XFILLER_41_734 VPWR VGND sg13g2_fill_1
XFILLER_13_436 VPWR VGND sg13g2_fill_2
XFILLER_43_55 VPWR VGND sg13g2_fill_2
X_22657_ coeff_force_packed\[29\] net471 _03065_ _00649_ VPWR VGND sg13g2_mux2_1
XFILLER_9_418 VPWR VGND sg13g2_decap_8
XFILLER_13_469 VPWR VGND sg13g2_fill_2
X_12410_ _03778_ VPWR _03787_ VGND _03718_ _03779_ sg13g2_o21ai_1
X_21608_ VPWR VGND _02222_ _02166_ _02221_ _02163_ _02225_ u_LMS.w\[7\]\[15\] sg13g2_a221oi_1
X_13390_ _04708_ _04732_ _04733_ VPWR VGND sg13g2_nor2_1
X_22588_ VGND VPWR _03213_ _03053_ _00589_ _03056_ sg13g2_a21oi_1
X_12341_ _03718_ _03719_ _03720_ VPWR VGND sg13g2_and2_1
X_21539_ VPWR _02156_ _02155_ VGND sg13g2_inv_1
XFILLER_126_305 VPWR VGND sg13g2_fill_1
X_15060_ _06335_ _06306_ _06333_ VPWR VGND sg13g2_xnor2_1
XFILLER_4_112 VPWR VGND sg13g2_decap_8
X_12272_ _03623_ _03652_ _03653_ VPWR VGND sg13g2_nor2_1
XFILLER_107_541 VPWR VGND sg13g2_fill_2
X_14011_ _05323_ _05306_ _05325_ VPWR VGND sg13g2_xor2_1
XFILLER_104_0 VPWR VGND sg13g2_decap_8
X_23209_ net1464 VGND VPWR _00271_ u_FIR.w\[7\]\[5\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
XFILLER_5_679 VPWR VGND sg13g2_fill_1
XFILLER_49_1032 VPWR VGND sg13g2_fill_1
XFILLER_107_574 VPWR VGND sg13g2_decap_4
XFILLER_4_49 VPWR VGND sg13g2_decap_8
XFILLER_108_81 VPWR VGND sg13g2_fill_2
XFILLER_0_351 VPWR VGND sg13g2_decap_8
X_18750_ _09837_ _09785_ _09836_ VPWR VGND sg13g2_xnor2_1
XFILLER_89_981 VPWR VGND sg13g2_fill_1
XFILLER_0_362 VPWR VGND sg13g2_fill_2
X_15962_ _07190_ VPWR _07205_ VGND net273 _07188_ sg13g2_o21ai_1
X_23245__1401 VPWR VGND net1400 sg13g2_tiehi
X_17701_ _08834_ _08833_ _08831_ VPWR VGND sg13g2_nand2b_1
X_14913_ net1007 VPWR _06197_ VGND net509 u_FIR.sum\[5\]\[14\] sg13g2_o21ai_1
XFILLER_102_290 VPWR VGND sg13g2_fill_1
X_18681_ _09768_ _09764_ _09767_ VPWR VGND sg13g2_nand2_1
X_23263__1368 VPWR VGND net1367 sg13g2_tiehi
X_15893_ _07140_ _07119_ _07139_ VPWR VGND sg13g2_xnor2_1
XFILLER_49_878 VPWR VGND sg13g2_decap_4
XFILLER_91_601 VPWR VGND sg13g2_decap_8
X_17632_ _08764_ _08742_ _08765_ VPWR VGND sg13g2_xor2_1
XFILLER_75_163 VPWR VGND sg13g2_decap_8
X_14844_ _06130_ _06129_ _06123_ VPWR VGND sg13g2_nand2b_1
XFILLER_75_174 VPWR VGND sg13g2_fill_2
XFILLER_63_314 VPWR VGND sg13g2_decap_8
XFILLER_64_848 VPWR VGND sg13g2_fill_2
XFILLER_48_399 VPWR VGND sg13g2_fill_2
X_17563_ _08696_ _08693_ _08694_ VPWR VGND sg13g2_xnor2_1
XFILLER_1_1045 VPWR VGND sg13g2_decap_8
X_14775_ _06063_ _06057_ _06061_ VPWR VGND sg13g2_xnor2_1
XFILLER_51_509 VPWR VGND sg13g2_decap_8
XFILLER_17_764 VPWR VGND sg13g2_fill_1
X_11987_ net327 _03403_ _03404_ VPWR VGND sg13g2_nor2_1
X_19302_ _10366_ _10365_ _10360_ VPWR VGND sg13g2_nand2b_1
X_16514_ net982 VPWR _07727_ VGND net488 u_FIR.w\[0\]\[6\] sg13g2_o21ai_1
X_13726_ _05053_ _05045_ _05052_ VPWR VGND sg13g2_xnor2_1
X_17494_ VPWR _08627_ _08626_ VGND sg13g2_inv_1
XFILLER_16_285 VPWR VGND sg13g2_decap_8
X_19233_ VGND VPWR _10308_ _10309_ _00359_ net921 sg13g2_a21oi_1
X_16445_ _07672_ _07667_ _07674_ VPWR VGND sg13g2_xor2_1
X_13657_ net756 net810 _04986_ VPWR VGND sg13g2_and2_1
XFILLER_32_778 VPWR VGND sg13g2_fill_1
X_19164_ VGND VPWR u_LMS.w\[3\]\[21\] u_LMS.w\[3\]\[20\] _10251_ net68 sg13g2_a21oi_1
X_12608_ _03976_ net732 net897 VPWR VGND sg13g2_nand2_1
X_16376_ VGND VPWR net496 _07607_ _00203_ _07608_ sg13g2_a21oi_1
X_13588_ _04884_ _04918_ _04882_ _04919_ VPWR VGND sg13g2_nand3_1
X_18115_ _09206_ VPWR _09225_ VGND _09203_ _09207_ sg13g2_o21ai_1
X_15327_ _06572_ _06594_ _06595_ VPWR VGND sg13g2_nor2b_1
X_19095_ _10182_ u_LMS.w\[3\]\[13\] net2085 VPWR VGND sg13g2_nand2_1
X_12539_ net940 _03912_ _00062_ VPWR VGND sg13g2_nor2_1
XFILLER_117_316 VPWR VGND sg13g2_fill_2
X_18046_ _09161_ _09021_ _09022_ VPWR VGND sg13g2_xnor2_1
X_15258_ VGND VPWR _06485_ _06488_ _06528_ _06526_ sg13g2_a21oi_1
X_14209_ _05518_ _05517_ _05484_ VPWR VGND sg13g2_nand2b_1
X_15189_ _06458_ _06459_ _06460_ VPWR VGND sg13g2_and2_1
XFILLER_113_533 VPWR VGND sg13g2_fill_2
XFILLER_125_393 VPWR VGND sg13g2_decap_4
Xfanout408 _04115_ net408 VPWR VGND sg13g2_buf_1
X_19997_ _11038_ net87 net629 net113 net627 VPWR VGND sg13g2_a22oi_1
Xfanout419 _03267_ net419 VPWR VGND sg13g2_buf_1
XFILLER_101_706 VPWR VGND sg13g2_fill_1
XFILLER_98_266 VPWR VGND sg13g2_decap_8
XFILLER_101_739 VPWR VGND sg13g2_decap_4
X_23034__1156 VPWR VGND net1155 sg13g2_tiehi
X_18948_ _10034_ VPWR _10035_ VGND net2119 _10029_ sg13g2_o21ai_1
XFILLER_98_299 VPWR VGND sg13g2_fill_1
XFILLER_100_227 VPWR VGND sg13g2_fill_2
XFILLER_100_249 VPWR VGND sg13g2_decap_4
XFILLER_67_642 VPWR VGND sg13g2_decap_8
X_18879_ _09962_ _09965_ _09966_ VPWR VGND sg13g2_and2_1
XFILLER_66_141 VPWR VGND sg13g2_decap_4
X_20910_ VGND VPWR _01225_ _01227_ _01550_ _01549_ sg13g2_a21oi_1
XFILLER_54_314 VPWR VGND sg13g2_fill_1
X_21890_ _02482_ _02483_ _02484_ VPWR VGND sg13g2_and2_1
XFILLER_54_336 VPWR VGND sg13g2_fill_2
X_20841_ _01481_ _01456_ _01480_ VPWR VGND sg13g2_nand2_1
XFILLER_70_818 VPWR VGND sg13g2_decap_8
XFILLER_70_829 VPWR VGND sg13g2_fill_1
X_23560_ net967 VGND VPWR _00622_ coeff_force_packed\[6\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
X_20772_ _01412_ _01370_ _01377_ VPWR VGND sg13g2_xnor2_1
XFILLER_120_38 VPWR VGND sg13g2_decap_8
Xfanout15 _01661_ net15 VPWR VGND sg13g2_buf_2
XFILLER_35_594 VPWR VGND sg13g2_decap_4
XFILLER_23_734 VPWR VGND sg13g2_fill_1
Xfanout26 net26 _10851_ VPWR VGND sg13g2_buf_4
XFILLER_50_531 VPWR VGND sg13g2_decap_8
X_22511_ u_LMS.count\[3\] _03006_ _03007_ VPWR VGND sg13g2_and2_1
XFILLER_23_756 VPWR VGND sg13g2_decap_8
Xfanout37 _09147_ net37 VPWR VGND sg13g2_buf_1
XFILLER_23_767 VPWR VGND sg13g2_fill_1
XFILLER_11_907 VPWR VGND sg13g2_decap_8
X_23491_ net1443 VGND VPWR _00553_ u_LMS.x_r\[8\]\[2\] clknet_leaf_7_clkA sg13g2_dfrbpq_1
Xfanout48 _02844_ net48 VPWR VGND sg13g2_buf_2
Xfanout59 _08490_ net59 VPWR VGND sg13g2_buf_2
XFILLER_13_14 VPWR VGND sg13g2_fill_1
X_22442_ VGND VPWR net443 _03248_ _00529_ _02970_ sg13g2_a21oi_1
XFILLER_22_288 VPWR VGND sg13g2_fill_1
XFILLER_129_14 VPWR VGND sg13g2_decap_8
X_22373_ net962 VPWR _02936_ VGND net452 u_LMS.x_r\[1\]\[0\] sg13g2_o21ai_1
X_21324_ _01940_ _01933_ _01941_ VPWR VGND sg13g2_xor2_1
X_21255_ _03222_ net143 _01872_ VPWR VGND sg13g2_nor2_1
XFILLER_104_511 VPWR VGND sg13g2_decap_8
XFILLER_2_627 VPWR VGND sg13g2_fill_1
XFILLER_117_894 VPWR VGND sg13g2_decap_8
XFILLER_132_831 VPWR VGND sg13g2_decap_8
Xrebuffer2140 _02216_ net2139 VPWR VGND sg13g2_buf_1
XFILLER_8_7 VPWR VGND sg13g2_decap_8
X_20206_ _00868_ VPWR _00869_ VGND _00841_ _00866_ sg13g2_o21ai_1
Xrebuffer2151 _02102_ net2150 VPWR VGND sg13g2_buf_1
XFILLER_1_126 VPWR VGND sg13g2_decap_8
X_23356__1246 VPWR VGND net1245 sg13g2_tiehi
X_21186_ _01802_ _01792_ _01803_ VPWR VGND sg13g2_xor2_1
Xrebuffer2162 _02107_ net2161 VPWR VGND sg13g2_buf_1
XFILLER_78_918 VPWR VGND sg13g2_decap_8
Xrebuffer2173 net2173 net2172 VPWR VGND sg13g2_buf_1
XFILLER_78_929 VPWR VGND sg13g2_fill_2
Xfanout920 net928 net920 VPWR VGND sg13g2_buf_1
Xfanout931 net935 net931 VPWR VGND sg13g2_buf_1
Xrebuffer2195 _08473_ net2194 VPWR VGND sg13g2_buf_1
X_20137_ _11178_ _11175_ _11177_ VPWR VGND sg13g2_nand2_1
XFILLER_89_288 VPWR VGND sg13g2_fill_1
XFILLER_131_374 VPWR VGND sg13g2_decap_8
Xfanout942 _03384_ net942 VPWR VGND sg13g2_buf_1
XFILLER_77_439 VPWR VGND sg13g2_decap_4
Xfanout953 net955 net953 VPWR VGND sg13g2_buf_1
Xfanout964 net966 net964 VPWR VGND sg13g2_buf_1
Xfanout975 net977 net975 VPWR VGND sg13g2_buf_1
Xfanout986 net990 net986 VPWR VGND sg13g2_buf_1
X_20068_ _11109_ _11107_ _11108_ VPWR VGND sg13g2_nand2_1
XFILLER_58_653 VPWR VGND sg13g2_fill_2
X_23417__1098 VPWR VGND net1097 sg13g2_tiehi
Xfanout997 net999 net997 VPWR VGND sg13g2_buf_1
XFILLER_46_826 VPWR VGND sg13g2_fill_2
X_11910_ VPWR _03331_ u_LMS.w\[3\]\[6\] VGND sg13g2_inv_1
XFILLER_79_1025 VPWR VGND sg13g2_fill_1
XFILLER_72_100 VPWR VGND sg13g2_decap_8
X_12890_ _04235_ VPWR _04250_ VGND _04231_ _04233_ sg13g2_o21ai_1
XFILLER_72_111 VPWR VGND sg13g2_fill_1
XFILLER_72_133 VPWR VGND sg13g2_fill_2
X_11841_ VPWR _03262_ net674 VGND sg13g2_inv_1
XFILLER_45_369 VPWR VGND sg13g2_fill_2
X_23456__1564 VPWR VGND net1563 sg13g2_tiehi
XFILLER_26_572 VPWR VGND sg13g2_decap_8
X_14560_ _05846_ VPWR _05853_ VGND _05817_ _05844_ sg13g2_o21ai_1
XFILLER_26_583 VPWR VGND sg13g2_fill_2
X_23758_ net994 VGND VPWR _00000_ u_spi_slave.rx_shift\[0\] clknet_3_3__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_41_531 VPWR VGND sg13g2_fill_2
XFILLER_14_756 VPWR VGND sg13g2_decap_4
X_13511_ _04844_ net753 net878 VPWR VGND sg13g2_nand2_1
X_22709_ _07966_ _03071_ _03073_ VPWR VGND sg13g2_nor2_1
X_14491_ VGND VPWR net490 _05786_ _00139_ _05787_ sg13g2_a21oi_1
X_23689_ net1020 VGND VPWR _00751_ u_debug_unit.mon_w7_sync\[6\] clknet_leaf_36_clkA
+ sg13g2_dfrbpq_1
X_16230_ _07467_ _07463_ _07466_ VPWR VGND sg13g2_xnor2_1
XFILLER_41_586 VPWR VGND sg13g2_decap_4
X_13442_ net941 _04782_ _00095_ VPWR VGND sg13g2_nor2_1
XFILLER_103_1023 VPWR VGND sg13g2_fill_2
X_16161_ net971 VPWR _07400_ VGND net475 u_FIR.sum\[8\]\[7\] sg13g2_o21ai_1
X_13373_ _04716_ _04713_ _04714_ VPWR VGND sg13g2_xnor2_1
Xclkload18 VPWR clkload18/Y clknet_leaf_0_clkA VGND sg13g2_inv_1
XFILLER_70_97 VPWR VGND sg13g2_decap_4
Xclkload29 VPWR clkload29/Y clknet_leaf_50_clkA VGND sg13g2_inv_1
XFILLER_6_933 VPWR VGND sg13g2_decap_4
X_15112_ _06385_ net780 net846 VPWR VGND sg13g2_nand2_1
X_12324_ _03679_ _03703_ _03704_ VPWR VGND sg13g2_nor2_1
X_16092_ _07332_ _07293_ _07330_ VPWR VGND sg13g2_xnor2_1
X_19920_ _10961_ _10950_ _10960_ VPWR VGND sg13g2_nand2_1
X_15043_ _06318_ _06317_ _06310_ VPWR VGND sg13g2_nand2b_1
X_12255_ _03637_ _03632_ _03636_ VPWR VGND sg13g2_nand2_1
XFILLER_123_820 VPWR VGND sg13g2_decap_4
X_19851_ VGND VPWR _03324_ _10830_ _10903_ _08494_ sg13g2_a21oi_1
XFILLER_69_907 VPWR VGND sg13g2_fill_2
X_12186_ VGND VPWR u_spi_slave.bit_cnt\[1\] u_spi_slave.bit_cnt\[0\] _00016_ _03576_
+ sg13g2_a21oi_1
XFILLER_69_929 VPWR VGND sg13g2_decap_8
X_18802_ _03255_ net139 _09889_ VPWR VGND sg13g2_nor2_1
XFILLER_96_737 VPWR VGND sg13g2_decap_8
X_19782_ _10846_ _03325_ net66 VPWR VGND sg13g2_xnor2_1
X_16994_ _08150_ _08148_ _08149_ VPWR VGND sg13g2_nand2_1
XFILLER_68_439 VPWR VGND sg13g2_fill_1
XFILLER_62_1040 VPWR VGND sg13g2_fill_1
XFILLER_1_682 VPWR VGND sg13g2_fill_1
X_18733_ _09819_ _09809_ _09820_ VPWR VGND sg13g2_xor2_1
X_15945_ _07188_ net273 _07189_ VPWR VGND sg13g2_xor2_1
XFILLER_77_962 VPWR VGND sg13g2_decap_4
XFILLER_37_815 VPWR VGND sg13g2_fill_2
XFILLER_76_461 VPWR VGND sg13g2_decap_4
XFILLER_48_152 VPWR VGND sg13g2_fill_2
XFILLER_92_921 VPWR VGND sg13g2_decap_8
XFILLER_48_163 VPWR VGND sg13g2_decap_8
X_23030__1162 VPWR VGND net1161 sg13g2_tiehi
X_18664_ _09753_ _09637_ _09639_ VPWR VGND sg13g2_xnor2_1
XFILLER_63_100 VPWR VGND sg13g2_fill_2
X_15876_ _07091_ VPWR _07123_ VGND _03373_ net804 sg13g2_o21ai_1
X_17615_ _08740_ VPWR _08748_ VGND _08746_ _08747_ sg13g2_o21ai_1
XFILLER_91_442 VPWR VGND sg13g2_fill_1
XFILLER_63_133 VPWR VGND sg13g2_fill_1
X_14827_ _06112_ _06086_ _06114_ VPWR VGND sg13g2_xor2_1
X_18595_ VGND VPWR _09698_ _09699_ _00331_ net921 sg13g2_a21oi_1
XFILLER_91_475 VPWR VGND sg13g2_decap_8
X_17546_ _08679_ _08677_ _08678_ VPWR VGND sg13g2_xnor2_1
X_14758_ net929 _06046_ _00147_ VPWR VGND sg13g2_nor2_1
X_13709_ _04996_ _04998_ _05036_ _05037_ VPWR VGND sg13g2_nor3_1
X_17477_ _08592_ VPWR _08610_ VGND _08589_ _08590_ sg13g2_o21ai_1
XFILLER_20_704 VPWR VGND sg13g2_fill_2
X_14689_ _05979_ _05971_ _05978_ VPWR VGND sg13g2_xnor2_1
X_19216_ net30 VPWR _10296_ VGND net28 _10295_ sg13g2_o21ai_1
XFILLER_20_726 VPWR VGND sg13g2_fill_2
X_16428_ _07658_ _07656_ _07657_ VPWR VGND sg13g2_nand2_1
X_19147_ _10182_ VPWR _10234_ VGND _10233_ _10232_ sg13g2_o21ai_1
XFILLER_9_760 VPWR VGND sg13g2_decap_8
XFILLER_30_1006 VPWR VGND sg13g2_fill_1
X_16359_ _07592_ _07486_ _07590_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_270 VPWR VGND sg13g2_fill_2
XFILLER_117_124 VPWR VGND sg13g2_fill_2
XFILLER_67_0 VPWR VGND sg13g2_decap_4
X_19078_ _10165_ _10161_ _10164_ VPWR VGND sg13g2_xnor2_1
X_18029_ net57 _09148_ _09009_ _09149_ VPWR VGND sg13g2_nand3_1
XFILLER_132_105 VPWR VGND sg13g2_decap_8
XFILLER_114_831 VPWR VGND sg13g2_fill_1
X_21040_ net18 VPWR _01676_ VGND net16 _01675_ sg13g2_o21ai_1
XFILLER_5_70 VPWR VGND sg13g2_decap_8
XFILLER_114_853 VPWR VGND sg13g2_decap_4
Xfanout205 net207 net205 VPWR VGND sg13g2_buf_1
Xfanout216 net216 _08101_ VPWR VGND sg13g2_buf_4
Xfanout227 net233 net227 VPWR VGND sg13g2_buf_2
XFILLER_87_726 VPWR VGND sg13g2_decap_8
XFILLER_59_417 VPWR VGND sg13g2_decap_8
Xfanout238 net239 net238 VPWR VGND sg13g2_buf_1
Xfanout249 net2067 net249 VPWR VGND sg13g2_buf_2
X_22991_ net1219 VGND VPWR _00053_ u_FIR.sum\[0\]\[3\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
XFILLER_67_450 VPWR VGND sg13g2_decap_4
XFILLER_39_163 VPWR VGND sg13g2_decap_8
XFILLER_28_826 VPWR VGND sg13g2_fill_2
X_21942_ _02536_ net570 net251 VPWR VGND sg13g2_nand2_1
XFILLER_67_494 VPWR VGND sg13g2_fill_2
XFILLER_27_358 VPWR VGND sg13g2_fill_1
X_21873_ _02467_ net583 net82 VPWR VGND sg13g2_nand2_1
XFILLER_83_987 VPWR VGND sg13g2_decap_8
XFILLER_43_818 VPWR VGND sg13g2_fill_1
XFILLER_27_369 VPWR VGND sg13g2_decap_4
XFILLER_82_464 VPWR VGND sg13g2_fill_1
X_20824_ net2060 _01463_ _01464_ VPWR VGND sg13g2_nor2b_1
X_23612_ net965 VGND VPWR _00674_ coeff_force_packed\[51\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
XFILLER_36_892 VPWR VGND sg13g2_fill_2
XFILLER_24_24 VPWR VGND sg13g2_decap_8
X_20755_ _01395_ _01358_ _01360_ VPWR VGND sg13g2_xnor2_1
X_23543_ net1012 VGND VPWR _00605_ debug_load_bus\[5\] clknet_leaf_37_clkA sg13g2_dfrbpq_1
XFILLER_126_1056 VPWR VGND sg13g2_decap_4
X_23474_ net1504 VGND VPWR _00536_ u_LMS.x_r\[6\]\[1\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
XFILLER_10_225 VPWR VGND sg13g2_decap_8
X_20686_ VGND VPWR net94 _01324_ _01326_ _01190_ sg13g2_a21oi_1
X_22425_ net949 VPWR _02962_ VGND net436 net647 sg13g2_o21ai_1
XFILLER_10_269 VPWR VGND sg13g2_fill_2
XFILLER_40_45 VPWR VGND sg13g2_decap_8
XFILLER_108_135 VPWR VGND sg13g2_fill_2
X_22356_ _02926_ _02927_ _00486_ VPWR VGND sg13g2_nor2_1
XFILLER_108_168 VPWR VGND sg13g2_decap_8
X_21307_ _01922_ VPWR _01924_ VGND _01918_ net2212 sg13g2_o21ai_1
X_22287_ _02874_ _02753_ _02873_ VPWR VGND sg13g2_xnor2_1
XFILLER_3_958 VPWR VGND sg13g2_decap_8
X_12040_ _03455_ _03438_ u_debug_unit.error_signal_sync\[6\] _03434_ u_debug_unit.mon_w0_sync\[6\]
+ VPWR VGND sg13g2_a22oi_1
X_21238_ _01855_ _01784_ _01786_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_661 VPWR VGND sg13g2_decap_8
X_21169_ _01778_ _01763_ _01786_ VPWR VGND sg13g2_xor2_1
XFILLER_131_171 VPWR VGND sg13g2_fill_2
Xfanout750 u_FIR.w\[5\]\[4\] net750 VPWR VGND sg13g2_buf_1
Xfanout761 u_FIR.w\[4\]\[3\] net761 VPWR VGND sg13g2_buf_1
Xfanout772 u_FIR.w\[3\]\[1\] net772 VPWR VGND sg13g2_buf_1
Xfanout783 u_FIR.w\[2\]\[0\] net783 VPWR VGND sg13g2_buf_1
X_13991_ VGND VPWR _05306_ _05305_ _05297_ sg13g2_or2_1
XFILLER_77_269 VPWR VGND sg13g2_fill_1
XFILLER_1_28 VPWR VGND sg13g2_decap_8
Xfanout794 u_FIR.w\[0\]\[5\] net794 VPWR VGND sg13g2_buf_1
XFILLER_74_910 VPWR VGND sg13g2_decap_8
XFILLER_74_921 VPWR VGND sg13g2_fill_2
X_15730_ _06981_ net786 net834 VPWR VGND sg13g2_nand2_1
XFILLER_92_228 VPWR VGND sg13g2_decap_8
X_12942_ _04301_ _04300_ _04266_ VPWR VGND sg13g2_nand2b_1
XFILLER_92_239 VPWR VGND sg13g2_decap_8
X_23154__1559 VPWR VGND net1558 sg13g2_tiehi
X_15661_ _06912_ _06913_ _06914_ VPWR VGND sg13g2_and2_1
X_12873_ _04234_ _04230_ _04233_ VPWR VGND sg13g2_xnor2_1
Xclkbuf_leaf_10_clkA clknet_4_10_0_clkA clknet_leaf_10_clkA VPWR VGND sg13g2_buf_8
X_17400_ net45 VPWR _08545_ VGND net43 _08544_ sg13g2_o21ai_1
X_14612_ _05903_ _05899_ _05904_ VPWR VGND sg13g2_xor2_1
XFILLER_60_103 VPWR VGND sg13g2_decap_8
X_18380_ _09490_ _09390_ _09460_ VPWR VGND sg13g2_xnor2_1
X_11824_ VPWR _03245_ net643 VGND sg13g2_inv_1
XFILLER_73_497 VPWR VGND sg13g2_decap_4
X_15592_ _06847_ _06839_ _06846_ VPWR VGND sg13g2_nand2_1
XFILLER_92_1022 VPWR VGND sg13g2_decap_4
X_17331_ _08479_ _08481_ _08484_ _08486_ _08487_ VPWR VGND sg13g2_and4_1
X_14543_ net849 u_FIR.sum\[4\]\[4\] net774 _05837_ VPWR VGND sg13g2_nand3_1
X_17262_ _03350_ _08417_ _08418_ VPWR VGND sg13g2_nor2_1
X_14474_ _05773_ _05768_ _05772_ VPWR VGND sg13g2_xnor2_1
X_19001_ _10088_ _10077_ _10078_ VPWR VGND sg13g2_xnor2_1
X_16213_ net847 net793 _07448_ _07450_ VPWR VGND sg13g2_a21o_1
X_13425_ _04752_ VPWR _04766_ VGND net283 _04750_ sg13g2_o21ai_1
XFILLER_14_90 VPWR VGND sg13g2_fill_1
X_17193_ _08349_ _08299_ _08300_ VPWR VGND sg13g2_xnor2_1
XFILLER_128_956 VPWR VGND sg13g2_decap_8
XFILLER_6_730 VPWR VGND sg13g2_fill_1
X_16144_ _07383_ _07366_ _07382_ VPWR VGND sg13g2_nand2_1
X_13356_ _04700_ _04677_ _04698_ VPWR VGND sg13g2_xnor2_1
X_12307_ _03687_ net726 net841 VPWR VGND sg13g2_nand2_1
XFILLER_127_488 VPWR VGND sg13g2_fill_2
X_16075_ _07316_ _07308_ _07315_ VPWR VGND sg13g2_nand2_1
X_13287_ _04632_ VPWR _04633_ VGND net538 u_FIR.sum\[2\]\[9\] sg13g2_o21ai_1
XFILLER_6_796 VPWR VGND sg13g2_decap_8
X_19903_ _10943_ _10942_ _10944_ VPWR VGND sg13g2_xor2_1
X_15026_ _06302_ _06293_ _06300_ VPWR VGND sg13g2_xnor2_1
X_12238_ _03621_ _03604_ _03619_ VPWR VGND sg13g2_xnor2_1
XFILLER_123_683 VPWR VGND sg13g2_decap_8
X_19834_ VGND VPWR _10888_ _10889_ _00380_ net925 sg13g2_a21oi_1
X_12169_ net944 net2 _00000_ VPWR VGND sg13g2_nor2b_1
XFILLER_96_523 VPWR VGND sg13g2_fill_1
XFILLER_96_534 VPWR VGND sg13g2_decap_8
XFILLER_122_171 VPWR VGND sg13g2_decap_4
XFILLER_111_845 VPWR VGND sg13g2_fill_2
XFILLER_96_545 VPWR VGND sg13g2_fill_2
XFILLER_122_193 VPWR VGND sg13g2_fill_2
XFILLER_1_490 VPWR VGND sg13g2_decap_8
XFILLER_96_567 VPWR VGND sg13g2_decap_8
X_19765_ _10829_ _10813_ _10828_ VPWR VGND sg13g2_xnor2_1
X_16977_ _08133_ net702 net236 VPWR VGND sg13g2_nand2_1
XFILLER_77_781 VPWR VGND sg13g2_fill_2
XFILLER_65_921 VPWR VGND sg13g2_fill_2
X_18716_ VPWR _09803_ _09802_ VGND sg13g2_inv_1
X_15928_ _07172_ VPWR _07173_ VGND _07125_ _07155_ sg13g2_o21ai_1
X_19696_ _10760_ u_LMS.w\[4\]\[9\] _10759_ VPWR VGND sg13g2_nand2_1
XFILLER_76_280 VPWR VGND sg13g2_decap_8
X_18647_ _09739_ _09740_ _00342_ VPWR VGND sg13g2_nor2_1
XFILLER_92_762 VPWR VGND sg13g2_decap_4
X_15859_ _07101_ _07106_ _07107_ VPWR VGND sg13g2_nor2b_1
XFILLER_64_464 VPWR VGND sg13g2_decap_8
XFILLER_51_103 VPWR VGND sg13g2_decap_8
X_18578_ _09687_ net304 u_LMS.w\[2\]\[13\] coeff_force_packed\[15\] net559 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_36_199 VPWR VGND sg13g2_decap_8
XFILLER_101_29 VPWR VGND sg13g2_decap_8
X_17529_ _08662_ _08608_ _08661_ VPWR VGND sg13g2_xnor2_1
XFILLER_33_895 VPWR VGND sg13g2_fill_1
XFILLER_20_512 VPWR VGND sg13g2_decap_4
X_20540_ net426 _03228_ net136 net102 _01180_ VPWR VGND sg13g2_nor4_1
XFILLER_20_545 VPWR VGND sg13g2_fill_1
X_20471_ VGND VPWR net51 _01120_ _01121_ net19 sg13g2_a21oi_1
X_22210_ _02773_ u_LMS.w\[8\]\[9\] _02804_ VPWR VGND sg13g2_xor2_1
X_23190_ net1498 VGND VPWR _00252_ u_FIR.w\[5\]\[0\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
XFILLER_69_1024 VPWR VGND sg13g2_decap_8
XFILLER_118_455 VPWR VGND sg13g2_fill_2
X_22141_ _02457_ VPWR _02735_ VGND _02456_ _02733_ sg13g2_o21ai_1
XFILLER_105_116 VPWR VGND sg13g2_decap_8
X_22072_ _02638_ _02665_ _02666_ VPWR VGND sg13g2_and2_1
X_21023_ net17 VPWR _01663_ VGND net15 _01662_ sg13g2_o21ai_1
XFILLER_59_236 VPWR VGND sg13g2_fill_2
XFILLER_101_333 VPWR VGND sg13g2_decap_8
XFILLER_19_35 VPWR VGND sg13g2_fill_1
XFILLER_101_355 VPWR VGND sg13g2_decap_4
Xclkbuf_leaf_33_clkA clknet_4_13_0_clkA clknet_leaf_33_clkA VPWR VGND sg13g2_buf_8
XFILLER_28_601 VPWR VGND sg13g2_fill_1
XFILLER_56_943 VPWR VGND sg13g2_fill_1
XFILLER_27_111 VPWR VGND sg13g2_fill_2
XFILLER_16_807 VPWR VGND sg13g2_decap_8
X_21925_ _02517_ VPWR _02519_ VGND _02513_ _02518_ sg13g2_o21ai_1
XFILLER_76_1006 VPWR VGND sg13g2_decap_8
XFILLER_70_401 VPWR VGND sg13g2_fill_2
XFILLER_35_34 VPWR VGND sg13g2_fill_2
Xclkbuf_3_3__f_spi_sclk clknet_3_3__leaf_spi_sclk clknet_0_spi_sclk VPWR VGND sg13g2_buf_16
XFILLER_71_946 VPWR VGND sg13g2_decap_4
XFILLER_15_328 VPWR VGND sg13g2_fill_2
XFILLER_43_648 VPWR VGND sg13g2_fill_1
X_21856_ _02444_ _02449_ _02450_ VPWR VGND sg13g2_and2_1
XFILLER_24_840 VPWR VGND sg13g2_decap_8
X_20807_ _01447_ _01414_ _01420_ VPWR VGND sg13g2_xnor2_1
X_23150__1565 VPWR VGND net1564 sg13g2_tiehi
X_21787_ _02379_ _02380_ _02381_ VPWR VGND sg13g2_nor2b_1
XFILLER_23_372 VPWR VGND sg13g2_decap_4
X_23526_ net1314 VGND VPWR _00588_ u_LMS.count\[29\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
X_20738_ _01370_ _01377_ _01378_ VPWR VGND sg13g2_and2_1
XFILLER_51_33 VPWR VGND sg13g2_decap_8
XFILLER_51_44 VPWR VGND sg13g2_fill_2
XFILLER_109_400 VPWR VGND sg13g2_decap_4
X_20669_ _01305_ VPWR _01309_ VGND _01306_ _01308_ sg13g2_o21ai_1
X_23457_ net1560 VGND VPWR _00519_ u_LMS.x_r\[4\]\[0\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
XFILLER_7_538 VPWR VGND sg13g2_fill_2
X_13210_ _04536_ VPWR _04557_ VGND _04537_ _04545_ sg13g2_o21ai_1
X_22408_ VGND VPWR net434 _03265_ _00512_ _02953_ sg13g2_a21oi_1
XFILLER_13_1056 VPWR VGND sg13g2_decap_4
X_14190_ _05499_ net838 net761 net822 net762 VPWR VGND sg13g2_a22oi_1
X_23388_ net1184 VGND VPWR _00450_ u_LMS.w\[7\]\[21\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
X_13141_ VGND VPWR _04490_ _04488_ _04450_ sg13g2_or2_1
X_22339_ net357 VPWR _02915_ VGND u_LMS.w\[8\]\[7\] net374 sg13g2_o21ai_1
XFILLER_125_948 VPWR VGND sg13g2_fill_1
XFILLER_2_210 VPWR VGND sg13g2_fill_1
X_13072_ _04423_ _04414_ _04421_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_469 VPWR VGND sg13g2_fill_2
XFILLER_2_254 VPWR VGND sg13g2_decap_4
X_16900_ _08056_ _08049_ _08055_ VPWR VGND sg13g2_nand2_1
X_12023_ _03427_ _03433_ _03440_ VPWR VGND sg13g2_nor2_1
XFILLER_104_160 VPWR VGND sg13g2_fill_2
XFILLER_105_694 VPWR VGND sg13g2_decap_8
X_17880_ _09013_ u_LMS.w\[1\]\[4\] _09005_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_480 VPWR VGND sg13g2_decap_8
X_16831_ _07966_ _07985_ _07987_ VPWR VGND sg13g2_nor2_1
Xfanout580 u_LMS.x_r\[8\]\[3\] net580 VPWR VGND sg13g2_buf_1
XFILLER_76_63 VPWR VGND sg13g2_fill_1
Xfanout591 net592 net591 VPWR VGND sg13g2_buf_1
X_19550_ _10614_ net424 _10584_ VPWR VGND sg13g2_xnor2_1
XFILLER_59_781 VPWR VGND sg13g2_fill_1
X_16762_ VPWR VGND _07898_ _03382_ _07903_ _07900_ _07918_ _07902_ sg13g2_a221oi_1
X_13974_ net1036 VPWR _05292_ VGND net537 u_FIR.sum\[3\]\[18\] sg13g2_o21ai_1
XFILLER_47_943 VPWR VGND sg13g2_fill_1
XFILLER_19_634 VPWR VGND sg13g2_decap_8
X_18501_ _03340_ _09610_ _09611_ VPWR VGND sg13g2_nor2_1
X_15713_ _06965_ _06922_ _06963_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_1038 VPWR VGND sg13g2_decap_8
X_19481_ VGND VPWR _10536_ _10537_ _10545_ _10544_ sg13g2_a21oi_1
X_12925_ VGND VPWR _04252_ _04263_ _04284_ _04271_ sg13g2_a21oi_1
XFILLER_74_762 VPWR VGND sg13g2_fill_2
X_16693_ VGND VPWR u_LMS.w\[7\]\[15\] _07852_ _07860_ _07853_ sg13g2_a21oi_1
XFILLER_34_615 VPWR VGND sg13g2_fill_2
X_18432_ _09518_ _09517_ _09542_ VPWR VGND sg13g2_xor2_1
XFILLER_132_91 VPWR VGND sg13g2_decap_8
X_15644_ VGND VPWR _06859_ _06888_ _06897_ _06887_ sg13g2_a21oi_1
X_12856_ _04217_ _04215_ _04216_ VPWR VGND sg13g2_nand2_1
XFILLER_33_125 VPWR VGND sg13g2_decap_8
X_18363_ _09471_ _09470_ _09473_ VPWR VGND sg13g2_xor2_1
X_11807_ VPWR _03228_ net608 VGND sg13g2_inv_1
XFILLER_92_95 VPWR VGND sg13g2_fill_1
XFILLER_61_467 VPWR VGND sg13g2_fill_2
X_15575_ _06830_ net787 net858 VPWR VGND sg13g2_nand2_1
XFILLER_109_1040 VPWR VGND sg13g2_fill_1
X_12787_ _04150_ _04143_ _04148_ VPWR VGND sg13g2_xnor2_1
X_17314_ _08470_ u_LMS.w\[0\]\[17\] _08400_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_821 VPWR VGND sg13g2_fill_1
X_14526_ _05821_ _05818_ _05819_ VPWR VGND sg13g2_xnor2_1
X_18294_ _03265_ net139 _09404_ VPWR VGND sg13g2_nor2_1
X_17245_ u_LMS.w\[0\]\[17\] _08400_ _08401_ VPWR VGND sg13g2_and2_1
XFILLER_30_876 VPWR VGND sg13g2_decap_4
X_14457_ _05757_ _05756_ _05734_ VPWR VGND sg13g2_nand2b_1
XFILLER_128_720 VPWR VGND sg13g2_decap_4
X_23351__1251 VPWR VGND net1250 sg13g2_tiehi
X_13408_ _04750_ u_FIR.sum\[1\]\[13\] net406 VPWR VGND sg13g2_xnor2_1
X_17176_ _08332_ net714 net263 VPWR VGND sg13g2_nand2_1
X_14388_ _05690_ _05665_ _05692_ VPWR VGND sg13g2_xor2_1
XFILLER_6_560 VPWR VGND sg13g2_decap_8
XFILLER_127_263 VPWR VGND sg13g2_decap_8
X_16127_ _07342_ VPWR _07366_ VGND _07295_ _07334_ sg13g2_o21ai_1
XFILLER_127_274 VPWR VGND sg13g2_decap_8
X_13339_ _04681_ _04682_ _04683_ VPWR VGND sg13g2_nor2_1
X_23722__1367 VPWR VGND net1366 sg13g2_tiehi
X_16058_ _07299_ net796 net858 VPWR VGND sg13g2_nand2_1
Xclkbuf_leaf_56_clkA clknet_4_3_0_clkA clknet_leaf_56_clkA VPWR VGND sg13g2_buf_8
X_15009_ _06284_ _06283_ _06286_ VPWR VGND sg13g2_xor2_1
XFILLER_29_1052 VPWR VGND sg13g2_decap_8
X_19817_ VGND VPWR _10874_ _10875_ _00377_ net930 sg13g2_a21oi_1
X_23399__1152 VPWR VGND net1151 sg13g2_tiehi
XFILLER_99_1017 VPWR VGND sg13g2_fill_1
XFILLER_110_163 VPWR VGND sg13g2_decap_8
X_23235__1419 VPWR VGND net1418 sg13g2_tiehi
X_19748_ _10466_ _10736_ _10432_ _10812_ VPWR VGND sg13g2_nand3_1
XFILLER_84_559 VPWR VGND sg13g2_fill_1
XFILLER_37_431 VPWR VGND sg13g2_decap_8
XFILLER_53_902 VPWR VGND sg13g2_decap_4
X_23484__1470 VPWR VGND net1469 sg13g2_tiehi
XFILLER_25_604 VPWR VGND sg13g2_fill_2
X_19679_ u_LMS.w\[4\]\[16\] _10742_ _10743_ VPWR VGND sg13g2_and2_1
X_21710_ VGND VPWR net49 _02311_ _02312_ net10 sg13g2_a21oi_1
X_22690_ u_debug_unit.force_w7\[7\] net459 _03068_ _00679_ VPWR VGND sg13g2_mux2_1
XFILLER_52_445 VPWR VGND sg13g2_decap_8
X_21641_ _02257_ net312 u_LMS.w\[7\]\[13\] coeff_force_packed\[50\] net563 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_36_1034 VPWR VGND sg13g2_fill_1
X_21572_ u_LMS.w\[7\]\[2\] net262 net605 _02189_ VPWR VGND sg13g2_nand3_1
XFILLER_36_1056 VPWR VGND sg13g2_decap_4
XFILLER_32_180 VPWR VGND sg13g2_fill_1
XFILLER_21_854 VPWR VGND sg13g2_fill_1
X_20523_ VPWR _01163_ _01162_ VGND sg13g2_inv_1
X_23311_ net1290 VGND VPWR _00373_ u_LMS.w\[4\]\[13\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
XFILLER_123_1059 VPWR VGND sg13g2_fill_2
X_20454_ VGND VPWR u_LMS.w\[5\]\[21\] net318 _01108_ _01094_ sg13g2_a21oi_1
X_23242_ net1406 VGND VPWR _00304_ u_LMS.w\[1\]\[13\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
XFILLER_21_36 VPWR VGND sg13g2_fill_1
X_23173_ net1527 VGND VPWR _00235_ u_FIR.w\[2\]\[4\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
X_20385_ _03320_ net75 _01048_ VPWR VGND sg13g2_nor2_1
XFILLER_97_18 VPWR VGND sg13g2_decap_8
X_22124_ VGND VPWR _02708_ _02712_ _02718_ _02711_ sg13g2_a21oi_1
XFILLER_0_703 VPWR VGND sg13g2_decap_8
X_22055_ _02641_ _02639_ _02643_ _02649_ VPWR VGND sg13g2_a21o_1
XFILLER_114_491 VPWR VGND sg13g2_decap_8
XFILLER_0_758 VPWR VGND sg13g2_decap_8
XFILLER_99_191 VPWR VGND sg13g2_decap_8
XFILLER_0_769 VPWR VGND sg13g2_fill_2
X_21006_ VGND VPWR _01645_ _01646_ _01639_ _01561_ sg13g2_a21oi_2
XFILLER_88_876 VPWR VGND sg13g2_decap_8
XFILLER_102_686 VPWR VGND sg13g2_fill_2
XFILLER_101_163 VPWR VGND sg13g2_fill_2
XFILLER_47_217 VPWR VGND sg13g2_fill_2
XFILLER_29_987 VPWR VGND sg13g2_fill_1
X_22957_ _07698_ VPWR _00814_ VGND _03287_ net525 sg13g2_o21ai_1
XFILLER_55_250 VPWR VGND sg13g2_decap_4
XFILLER_55_272 VPWR VGND sg13g2_decap_4
X_12710_ _04075_ u_FIR.w\[7\]\[6\] _04074_ VPWR VGND sg13g2_xnor2_1
X_21908_ _02502_ _02498_ _02501_ VPWR VGND sg13g2_nand2_1
X_13690_ _05014_ VPWR _05018_ VGND _05015_ _05016_ sg13g2_o21ai_1
X_22888_ VPWR _00773_ _03172_ VGND sg13g2_inv_1
XFILLER_71_765 VPWR VGND sg13g2_fill_1
XFILLER_31_607 VPWR VGND sg13g2_fill_1
X_12641_ _04008_ _04000_ _04007_ VPWR VGND sg13g2_nand2_1
X_21839_ _02431_ _02432_ _02433_ VPWR VGND sg13g2_and2_1
XFILLER_30_106 VPWR VGND sg13g2_decap_8
XFILLER_52_990 VPWR VGND sg13g2_fill_1
X_15360_ _06606_ _06626_ _06627_ VPWR VGND sg13g2_nor2b_1
XFILLER_70_297 VPWR VGND sg13g2_decap_8
X_12572_ net1025 VPWR _03943_ VGND net522 u_FIR.sum\[1\]\[0\] sg13g2_o21ai_1
XFILLER_62_76 VPWR VGND sg13g2_fill_1
XFILLER_50_1009 VPWR VGND sg13g2_decap_4
X_14311_ VGND VPWR net764 _05569_ _05617_ _05538_ sg13g2_a21oi_1
X_23509_ net1380 VGND VPWR _00571_ u_LMS.count\[12\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
XFILLER_11_353 VPWR VGND sg13g2_fill_2
X_15291_ _06560_ _06551_ _06558_ VPWR VGND sg13g2_xnor2_1
XFILLER_12_898 VPWR VGND sg13g2_decap_4
X_17030_ _08186_ _08176_ _08185_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_49 VPWR VGND sg13g2_decap_8
X_14242_ _05550_ _05549_ _05509_ VPWR VGND sg13g2_nand2b_1
XFILLER_7_357 VPWR VGND sg13g2_fill_1
X_14173_ net1005 VPWR _05483_ VGND net506 u_FIR.sum\[4\]\[7\] sg13g2_o21ai_1
X_13124_ _04438_ _04436_ _04472_ _04474_ VPWR VGND sg13g2_a21o_1
XFILLER_124_244 VPWR VGND sg13g2_decap_8
XFILLER_98_618 VPWR VGND sg13g2_decap_8
XFILLER_11_91 VPWR VGND sg13g2_fill_2
X_18981_ net668 net187 net664 _10068_ VPWR VGND net219 sg13g2_nand4_1
XFILLER_106_970 VPWR VGND sg13g2_fill_2
XFILLER_3_563 VPWR VGND sg13g2_decap_8
XFILLER_127_91 VPWR VGND sg13g2_fill_1
X_17932_ _09065_ _09055_ _09064_ VPWR VGND sg13g2_xnor2_1
X_13055_ _04386_ _04380_ _04384_ _04407_ VPWR VGND sg13g2_a21o_1
XFILLER_79_865 VPWR VGND sg13g2_decap_8
X_12006_ _03423_ spi_addr\[4\] _03396_ VPWR VGND sg13g2_nand2_1
X_17863_ _03343_ _08995_ _08996_ VPWR VGND sg13g2_nor2_1
XFILLER_38_217 VPWR VGND sg13g2_decap_8
XFILLER_121_995 VPWR VGND sg13g2_decap_4
X_19602_ _10664_ _10665_ _10666_ VPWR VGND sg13g2_nor2_1
XFILLER_38_228 VPWR VGND sg13g2_fill_1
X_16814_ _07970_ _07936_ net2136 VPWR VGND sg13g2_xnor2_1
X_17794_ _08912_ _08926_ _08927_ VPWR VGND sg13g2_nor2_1
XFILLER_93_334 VPWR VGND sg13g2_fill_1
XFILLER_4_1032 VPWR VGND sg13g2_decap_8
XFILLER_19_442 VPWR VGND sg13g2_fill_1
X_19533_ _10594_ _10593_ _10597_ VPWR VGND sg13g2_xor2_1
X_16745_ _07901_ _07899_ _07898_ VPWR VGND sg13g2_xnor2_1
X_23369__1233 VPWR VGND net1232 sg13g2_tiehi
X_13957_ VPWR _05276_ _05275_ VGND sg13g2_inv_1
XFILLER_35_913 VPWR VGND sg13g2_decap_8
XFILLER_35_924 VPWR VGND sg13g2_fill_1
X_19464_ _10528_ _10525_ _10526_ VPWR VGND sg13g2_xnor2_1
X_12908_ _04267_ net284 _04268_ VPWR VGND sg13g2_xor2_1
XFILLER_46_283 VPWR VGND sg13g2_fill_2
X_16676_ VGND VPWR _03308_ net544 _00265_ _07846_ sg13g2_a21oi_1
X_13888_ _05205_ _05207_ _05210_ VPWR VGND sg13g2_nor2_1
XFILLER_22_607 VPWR VGND sg13g2_fill_1
X_18415_ net202 _09524_ net681 _09525_ VPWR VGND sg13g2_nand3_1
X_15627_ _06881_ u_FIR.w\[1\]\[6\] _06880_ VPWR VGND sg13g2_xnor2_1
X_19395_ _10453_ _10458_ _10459_ VPWR VGND sg13g2_and2_1
X_12839_ _04201_ _04170_ _04200_ VPWR VGND sg13g2_xnor2_1
XFILLER_50_938 VPWR VGND sg13g2_fill_1
XFILLER_21_117 VPWR VGND sg13g2_fill_1
X_18346_ _09456_ net677 net238 VPWR VGND sg13g2_nand2_1
X_15558_ _06813_ _06786_ _06814_ VPWR VGND sg13g2_xor2_1
X_14509_ net862 u_FIR.sum\[4\]\[3\] net774 _05804_ VPWR VGND sg13g2_nand3_1
X_23272__1350 VPWR VGND net1349 sg13g2_tiehi
X_18277_ _09387_ _09384_ _09385_ VPWR VGND sg13g2_xnor2_1
X_15489_ _06747_ _06748_ _00176_ VPWR VGND sg13g2_nor2_1
X_17228_ VGND VPWR _08384_ _08049_ _08005_ sg13g2_or2_1
XFILLER_128_550 VPWR VGND sg13g2_decap_8
XFILLER_116_723 VPWR VGND sg13g2_fill_2
XFILLER_115_200 VPWR VGND sg13g2_decap_4
X_17159_ _08286_ _08314_ _08315_ VPWR VGND sg13g2_and2_1
XFILLER_7_891 VPWR VGND sg13g2_decap_8
X_20170_ VGND VPWR _00825_ _00826_ _00833_ _00828_ sg13g2_a21oi_1
XFILLER_130_203 VPWR VGND sg13g2_decap_8
XFILLER_130_214 VPWR VGND sg13g2_fill_2
XFILLER_131_748 VPWR VGND sg13g2_fill_1
XFILLER_69_320 VPWR VGND sg13g2_fill_2
XFILLER_69_331 VPWR VGND sg13g2_fill_2
XFILLER_130_269 VPWR VGND sg13g2_decap_4
XFILLER_97_673 VPWR VGND sg13g2_fill_2
XFILLER_69_364 VPWR VGND sg13g2_fill_1
XFILLER_111_461 VPWR VGND sg13g2_decap_8
XFILLER_85_857 VPWR VGND sg13g2_fill_1
X_22811_ VGND VPWR _07854_ net349 _00745_ _03123_ sg13g2_a21oi_1
XFILLER_44_209 VPWR VGND sg13g2_fill_2
XFILLER_38_795 VPWR VGND sg13g2_fill_1
XFILLER_65_592 VPWR VGND sg13g2_decap_4
X_22742_ u_debug_unit.mon_w2_sync\[1\] net333 _03089_ VPWR VGND sg13g2_nor2_1
XFILLER_16_36 VPWR VGND sg13g2_fill_1
XFILLER_52_231 VPWR VGND sg13g2_decap_8
X_22673_ net430 _03431_ _03067_ VPWR VGND sg13g2_and2_1
XFILLER_13_629 VPWR VGND sg13g2_decap_8
XFILLER_40_426 VPWR VGND sg13g2_decap_8
X_21624_ _02241_ u_LMS.w\[7\]\[22\] net62 VPWR VGND sg13g2_nand2_1
XFILLER_21_640 VPWR VGND sg13g2_decap_8
X_21555_ _02172_ _02108_ net2160 VPWR VGND sg13g2_xnor2_1
XFILLER_32_46 VPWR VGND sg13g2_decap_8
XFILLER_32_57 VPWR VGND sg13g2_fill_1
X_20506_ _01147_ _01028_ _01030_ VPWR VGND sg13g2_xnor2_1
X_21486_ VGND VPWR _02101_ _02102_ _02103_ _02079_ sg13g2_a21oi_1
XFILLER_5_817 VPWR VGND sg13g2_decap_8
XFILLER_5_828 VPWR VGND sg13g2_fill_1
X_20437_ net566 coeff_force_packed\[41\] _01094_ VPWR VGND sg13g2_and2_1
X_23225_ net1435 VGND VPWR _00287_ u_LMS.w\[0\]\[19\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
XFILLER_106_4 VPWR VGND sg13g2_fill_1
XFILLER_106_255 VPWR VGND sg13g2_fill_1
X_20368_ _00988_ VPWR _01031_ VGND _01029_ _01028_ sg13g2_o21ai_1
X_23156_ net1555 VGND VPWR _00218_ u_FIR.w\[0\]\[1\] clknet_leaf_49_clkA sg13g2_dfrbpq_1
X_22107_ _02652_ _02651_ _02701_ VPWR VGND sg13g2_xor2_1
Xclkbuf_leaf_8_clkA clknet_4_8_0_clkA clknet_leaf_8_clkA VPWR VGND sg13g2_buf_8
XFILLER_0_522 VPWR VGND sg13g2_decap_8
XFILLER_106_299 VPWR VGND sg13g2_fill_2
X_23087_ net1075 VGND VPWR _00149_ u_FIR.sum\[5\]\[11\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
X_20299_ _11008_ _00961_ _10990_ _00962_ VPWR VGND sg13g2_nand3_1
X_22038_ _02632_ _02587_ _02588_ VPWR VGND sg13g2_xnor2_1
XFILLER_87_172 VPWR VGND sg13g2_fill_2
XFILLER_76_835 VPWR VGND sg13g2_decap_8
XFILLER_57_54 VPWR VGND sg13g2_fill_1
X_14860_ _06144_ _06119_ _06146_ VPWR VGND sg13g2_xor2_1
X_13811_ _05136_ u_FIR.sum\[2\]\[11\] net403 VPWR VGND sg13g2_xnor2_1
XFILLER_57_98 VPWR VGND sg13g2_fill_1
XFILLER_17_913 VPWR VGND sg13g2_fill_2
X_14791_ _06079_ _06049_ _06078_ VPWR VGND sg13g2_xnor2_1
XFILLER_29_784 VPWR VGND sg13g2_fill_1
X_16530_ net975 VPWR _07740_ VGND net481 net788 sg13g2_o21ai_1
X_13742_ _05061_ _05068_ _05069_ VPWR VGND sg13g2_nor2b_1
XFILLER_17_957 VPWR VGND sg13g2_fill_1
XFILLER_113_82 VPWR VGND sg13g2_fill_1
XFILLER_71_540 VPWR VGND sg13g2_fill_1
XFILLER_43_242 VPWR VGND sg13g2_fill_2
X_16461_ net503 VPWR _07689_ VGND _07681_ _07688_ sg13g2_o21ai_1
XFILLER_32_927 VPWR VGND sg13g2_decap_8
X_13673_ VGND VPWR _04964_ _04992_ _05001_ _04994_ sg13g2_a21oi_1
XFILLER_44_798 VPWR VGND sg13g2_decap_4
X_18200_ _09301_ VPWR _09310_ VGND _09302_ _09309_ sg13g2_o21ai_1
X_15412_ _06677_ _06666_ _06676_ VPWR VGND sg13g2_xnor2_1
XFILLER_43_297 VPWR VGND sg13g2_fill_1
X_19180_ VGND VPWR _10267_ _10265_ _10262_ sg13g2_or2_1
X_12624_ _03991_ net731 net909 VPWR VGND sg13g2_nand2_1
X_16392_ _07622_ VPWR _07624_ VGND _07604_ _07606_ sg13g2_o21ai_1
X_18131_ _09236_ VPWR _09241_ VGND _09224_ _09234_ sg13g2_o21ai_1
XFILLER_8_600 VPWR VGND sg13g2_decap_8
X_15343_ _03370_ net821 _06610_ VPWR VGND sg13g2_nor2_1
X_12555_ _03928_ _03859_ _03927_ VPWR VGND sg13g2_xnor2_1
XFILLER_12_673 VPWR VGND sg13g2_fill_1
XFILLER_40_993 VPWR VGND sg13g2_fill_2
X_18062_ net359 VPWR _09173_ VGND u_LMS.w\[1\]\[11\] net375 sg13g2_o21ai_1
X_15274_ net835 _06542_ net775 _06543_ VPWR VGND sg13g2_nand3_1
X_12486_ _03716_ _03804_ _03831_ _03861_ VPWR VGND sg13g2_nor3_1
X_17013_ _08169_ net709 net231 VPWR VGND sg13g2_nand2_1
X_14225_ _05531_ _05532_ _05533_ VPWR VGND sg13g2_and2_1
X_14156_ _05466_ _05448_ _05464_ VPWR VGND sg13g2_xnor2_1
XFILLER_113_704 VPWR VGND sg13g2_fill_2
XFILLER_99_938 VPWR VGND sg13g2_fill_2
X_13107_ _04457_ _04456_ _04422_ VPWR VGND sg13g2_nand2b_1
X_18964_ net667 net184 net664 _10051_ VPWR VGND net166 sg13g2_nand4_1
X_14087_ _05399_ _05371_ _05398_ VPWR VGND sg13g2_xnor2_1
XFILLER_112_247 VPWR VGND sg13g2_fill_1
X_17915_ _09046_ _08982_ _09047_ _09048_ VPWR VGND sg13g2_a21o_1
X_13038_ net1025 VPWR _04391_ VGND net521 u_FIR.sum\[2\]\[2\] sg13g2_o21ai_1
X_18895_ _09982_ _09979_ _09981_ VPWR VGND sg13g2_xnor2_1
XFILLER_21_4 VPWR VGND sg13g2_fill_1
XFILLER_67_835 VPWR VGND sg13g2_fill_1
XFILLER_39_526 VPWR VGND sg13g2_fill_1
XFILLER_121_781 VPWR VGND sg13g2_decap_8
XFILLER_39_537 VPWR VGND sg13g2_decap_8
X_17846_ u_LMS.w\[1\]\[17\] _08978_ _08979_ VPWR VGND sg13g2_and2_1
XFILLER_82_816 VPWR VGND sg13g2_fill_1
XFILLER_94_687 VPWR VGND sg13g2_fill_2
X_17777_ _08910_ net697 net258 VPWR VGND sg13g2_nand2_1
X_14989_ _06267_ _06266_ _06260_ VPWR VGND sg13g2_nand2b_1
XFILLER_82_849 VPWR VGND sg13g2_decap_4
X_19516_ _10578_ _10579_ _10580_ VPWR VGND sg13g2_nor2_1
X_16728_ VGND VPWR net528 _07884_ _00278_ _07885_ sg13g2_a21oi_1
XFILLER_34_220 VPWR VGND sg13g2_decap_8
XFILLER_62_551 VPWR VGND sg13g2_decap_4
X_19447_ _10511_ _10477_ _10510_ VPWR VGND sg13g2_xnor2_1
X_16659_ VGND VPWR net527 _07834_ _00259_ _07835_ sg13g2_a21oi_1
XFILLER_50_735 VPWR VGND sg13g2_decap_8
XFILLER_97_0 VPWR VGND sg13g2_decap_8
XFILLER_72_1020 VPWR VGND sg13g2_decap_8
X_19378_ _10349_ _10347_ _10442_ VPWR VGND sg13g2_xor2_1
X_18329_ _09429_ VPWR _09439_ VGND _09395_ _09426_ sg13g2_o21ai_1
X_21340_ _01931_ VPWR _01957_ VGND _01928_ _01929_ sg13g2_o21ai_1
X_23193__1493 VPWR VGND net1492 sg13g2_tiehi
XFILLER_8_70 VPWR VGND sg13g2_decap_4
XFILLER_129_881 VPWR VGND sg13g2_fill_1
XFILLER_118_16 VPWR VGND sg13g2_fill_1
X_21271_ _01852_ _01851_ _01888_ VPWR VGND sg13g2_xor2_1
X_20222_ _00885_ _00884_ _00883_ VPWR VGND sg13g2_nand2b_1
X_23010_ net1191 VGND VPWR _00072_ u_FIR.sum\[1\]\[7\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
XFILLER_131_512 VPWR VGND sg13g2_decap_8
X_20153_ _11194_ _11190_ _11192_ VPWR VGND sg13g2_xnor2_1
Xrebuffer1643 _07971_ net1642 VPWR VGND sg13g2_buf_2
Xrebuffer1654 _09596_ net1653 VPWR VGND sg13g2_buf_2
Xrebuffer1665 _07959_ net1664 VPWR VGND sg13g2_buf_2
X_20084_ _11123_ _11101_ _11125_ VPWR VGND sg13g2_xor2_1
XFILLER_76_109 VPWR VGND sg13g2_fill_1
XFILLER_131_589 VPWR VGND sg13g2_decap_8
XFILLER_112_770 VPWR VGND sg13g2_fill_1
XFILLER_100_921 VPWR VGND sg13g2_fill_2
XFILLER_69_172 VPWR VGND sg13g2_decap_4
XFILLER_111_291 VPWR VGND sg13g2_fill_2
XFILLER_73_805 VPWR VGND sg13g2_decap_8
XFILLER_84_153 VPWR VGND sg13g2_fill_1
XFILLER_45_518 VPWR VGND sg13g2_decap_8
XFILLER_84_186 VPWR VGND sg13g2_decap_8
X_23774_ net996 VGND VPWR _00019_ u_spi_slave.tx_active net1640 sg13g2_dfrbpq_1
X_20986_ _01626_ _01625_ _01580_ VPWR VGND sg13g2_nand2b_1
XFILLER_129_1021 VPWR VGND sg13g2_decap_8
XFILLER_53_562 VPWR VGND sg13g2_decap_4
X_22725_ VGND VPWR _03353_ net336 _00702_ _03080_ sg13g2_a21oi_1
XFILLER_43_23 VPWR VGND sg13g2_fill_1
XFILLER_40_223 VPWR VGND sg13g2_decap_8
XFILLER_41_757 VPWR VGND sg13g2_fill_1
X_22656_ coeff_force_packed\[28\] net472 _03065_ _00648_ VPWR VGND sg13g2_mux2_1
XFILLER_43_78 VPWR VGND sg13g2_fill_2
XFILLER_22_971 VPWR VGND sg13g2_decap_8
X_21607_ VGND VPWR net2141 _02222_ _02224_ _02166_ sg13g2_a21oi_1
X_22587_ _03056_ net952 _03055_ VPWR VGND sg13g2_nand2_1
X_12340_ _03692_ _03717_ _03690_ _03719_ VPWR VGND sg13g2_nand3_1
X_21538_ net64 u_LMS.w\[7\]\[19\] _02155_ VPWR VGND sg13g2_xor2_1
X_12271_ _03652_ net720 net894 VPWR VGND sg13g2_nand2_1
X_21469_ _02086_ _02039_ _02084_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_391 VPWR VGND sg13g2_fill_1
XFILLER_88_1060 VPWR VGND sg13g2_fill_1
X_14010_ _05306_ _05323_ _05324_ VPWR VGND sg13g2_nor2_1
X_23208_ net1466 VGND VPWR _00270_ u_FIR.w\[7\]\[4\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
XFILLER_4_28 VPWR VGND sg13g2_decap_8
X_23139_ net1580 VGND VPWR _00201_ u_FIR.sum\[8\]\[11\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
X_23429__1062 VPWR VGND net1061 sg13g2_tiehi
XFILLER_0_330 VPWR VGND sg13g2_decap_8
X_15961_ _07204_ _07170_ _07203_ VPWR VGND sg13g2_nand2_1
XFILLER_95_418 VPWR VGND sg13g2_fill_1
X_17700_ _08832_ _08801_ _08833_ VPWR VGND sg13g2_xor2_1
X_14912_ _06194_ _06179_ _06196_ VPWR VGND sg13g2_xor2_1
XFILLER_49_846 VPWR VGND sg13g2_decap_8
XFILLER_48_323 VPWR VGND sg13g2_fill_2
X_18680_ _09766_ _09765_ _09767_ VPWR VGND sg13g2_xor2_1
X_15892_ _07139_ _07120_ _07137_ VPWR VGND sg13g2_xnor2_1
XFILLER_48_356 VPWR VGND sg13g2_decap_8
X_17631_ _08764_ net691 net186 VPWR VGND sg13g2_nand2_1
X_14843_ _06127_ _06091_ _06129_ VPWR VGND sg13g2_xor2_1
XFILLER_1_1024 VPWR VGND sg13g2_decap_8
XFILLER_17_732 VPWR VGND sg13g2_fill_2
X_17562_ _08693_ _08694_ _08695_ VPWR VGND sg13g2_nor2b_1
X_14774_ _06062_ _06061_ _06057_ VPWR VGND sg13g2_nand2b_1
XFILLER_95_1031 VPWR VGND sg13g2_fill_2
X_11986_ net474 _03401_ spi_addr\[0\] _03403_ VPWR VGND sg13g2_nand3_1
X_19301_ _10363_ _10364_ _10365_ VPWR VGND sg13g2_and2_1
X_16513_ VGND VPWR net478 _07725_ _00222_ _07726_ sg13g2_a21oi_1
X_13725_ _05052_ _05046_ _05050_ VPWR VGND sg13g2_xnor2_1
XFILLER_72_871 VPWR VGND sg13g2_fill_1
X_17493_ _08626_ _08625_ _08624_ VPWR VGND sg13g2_nand2b_1
XFILLER_56_1026 VPWR VGND sg13g2_decap_8
XFILLER_17_90 VPWR VGND sg13g2_fill_1
X_19232_ VGND VPWR u_LMS.w\[3\]\[22\] net305 _10309_ _10292_ sg13g2_a21oi_1
X_16444_ _07673_ _07667_ _07672_ VPWR VGND sg13g2_nand2_1
X_13656_ _04936_ VPWR _04985_ VGND _04933_ _04937_ sg13g2_o21ai_1
XFILLER_32_768 VPWR VGND sg13g2_fill_2
X_19163_ VGND VPWR _10170_ _10243_ _10250_ _10249_ sg13g2_a21oi_1
X_12607_ _03975_ net735 net883 VPWR VGND sg13g2_nand2_1
X_16375_ net1003 VPWR _07608_ VGND net496 u_FIR.sum\[8\]\[13\] sg13g2_o21ai_1
XFILLER_13_982 VPWR VGND sg13g2_decap_8
X_13587_ _04916_ _04887_ _04918_ VPWR VGND sg13g2_xor2_1
XFILLER_129_122 VPWR VGND sg13g2_fill_1
X_18114_ VGND VPWR _09200_ _09211_ _09224_ _09210_ sg13g2_a21oi_1
XFILLER_40_790 VPWR VGND sg13g2_fill_2
X_15326_ _06594_ _06585_ _06592_ VPWR VGND sg13g2_xnor2_1
X_19094_ _10181_ _10142_ _10141_ VPWR VGND sg13g2_xnor2_1
X_12538_ _03911_ VPWR _03912_ VGND net542 u_FIR.sum\[0\]\[12\] sg13g2_o21ai_1
XFILLER_8_452 VPWR VGND sg13g2_decap_8
XFILLER_129_166 VPWR VGND sg13g2_decap_4
X_18045_ VPWR VGND _09160_ _08554_ net37 _03345_ _00320_ net369 sg13g2_a221oi_1
XFILLER_8_485 VPWR VGND sg13g2_fill_2
X_15257_ _06527_ _06485_ _06488_ _06526_ VPWR VGND sg13g2_and3_1
X_12469_ _03845_ _03828_ _03843_ VPWR VGND sg13g2_xnor2_1
X_14208_ _05516_ _05485_ _05517_ VPWR VGND sg13g2_xor2_1
X_15188_ net861 net775 _06457_ _06459_ VPWR VGND sg13g2_a21o_1
XFILLER_4_680 VPWR VGND sg13g2_decap_8
X_14139_ _05449_ _05411_ _05413_ VPWR VGND sg13g2_nand2_1
Xfanout409 net410 net409 VPWR VGND sg13g2_buf_1
X_19996_ _10953_ _11036_ _11037_ VPWR VGND sg13g2_nor2_1
XFILLER_101_729 VPWR VGND sg13g2_decap_4
X_18947_ _10034_ _10028_ _10027_ VPWR VGND sg13g2_nand2b_1
XFILLER_113_589 VPWR VGND sg13g2_decap_4
XFILLER_95_941 VPWR VGND sg13g2_fill_1
X_18878_ _09964_ _09963_ _09965_ VPWR VGND sg13g2_xor2_1
XFILLER_39_345 VPWR VGND sg13g2_decap_8
XFILLER_12_0 VPWR VGND sg13g2_decap_8
XFILLER_39_367 VPWR VGND sg13g2_decap_8
X_17829_ _08962_ _08960_ _08961_ VPWR VGND sg13g2_nand2b_1
XFILLER_39_378 VPWR VGND sg13g2_fill_1
XFILLER_55_838 VPWR VGND sg13g2_decap_4
X_20840_ _01479_ VPWR _01480_ VGND _03234_ net179 sg13g2_o21ai_1
XFILLER_63_871 VPWR VGND sg13g2_fill_1
XFILLER_35_562 VPWR VGND sg13g2_decap_4
X_20771_ _01411_ _01408_ _01410_ VPWR VGND sg13g2_nand2_1
XFILLER_81_189 VPWR VGND sg13g2_decap_4
Xfanout16 _01661_ net16 VPWR VGND sg13g2_buf_1
X_22510_ net918 _03005_ _03006_ _00561_ VPWR VGND sg13g2_nor3_1
Xfanout27 _10318_ net27 VPWR VGND sg13g2_buf_2
Xfanout38 _09097_ net38 VPWR VGND sg13g2_buf_1
X_23490_ net1447 VGND VPWR _00552_ u_LMS.x_r\[8\]\[1\] clknet_leaf_7_clkA sg13g2_dfrbpq_1
Xfanout49 net50 net49 VPWR VGND sg13g2_buf_2
X_22441_ net959 VPWR _02970_ VGND net443 net631 sg13g2_o21ai_1
X_22372_ VGND VPWR net456 _03283_ _00494_ _02935_ sg13g2_a21oi_1
X_21323_ _01940_ net590 net252 VPWR VGND sg13g2_nand2_1
X_21254_ _01871_ net600 net84 VPWR VGND sg13g2_nand2_1
XFILLER_1_105 VPWR VGND sg13g2_decap_8
Xrebuffer2130 _01042_ net2129 VPWR VGND sg13g2_buf_1
XFILLER_104_534 VPWR VGND sg13g2_fill_2
X_20205_ net213 _00867_ net631 _00868_ VPWR VGND sg13g2_nand3_1
Xrebuffer2141 net2144 net2140 VPWR VGND sg13g2_buf_1
X_21185_ _01802_ _01767_ _01801_ VPWR VGND sg13g2_xnor2_1
Xrebuffer2152 _02106_ net2151 VPWR VGND sg13g2_buf_1
Xrebuffer2163 _01983_ net2162 VPWR VGND sg13g2_buf_1
Xrebuffer2174 net2174 net2173 VPWR VGND sg13g2_buf_1
Xfanout910 net911 net910 VPWR VGND sg13g2_buf_1
X_20136_ _11129_ _11176_ _11177_ VPWR VGND sg13g2_nor2_1
Xfanout921 net922 net921 VPWR VGND sg13g2_buf_1
Xfanout932 net933 net932 VPWR VGND sg13g2_buf_1
Xrebuffer2196 net2196 net2195 VPWR VGND sg13g2_buf_1
Xfanout943 net944 net943 VPWR VGND sg13g2_buf_1
Xfanout954 net955 net954 VPWR VGND sg13g2_buf_1
XFILLER_86_930 VPWR VGND sg13g2_fill_2
Xfanout965 net966 net965 VPWR VGND sg13g2_buf_1
X_20067_ _11108_ _11067_ _11074_ VPWR VGND sg13g2_xnor2_1
Xfanout976 net977 net976 VPWR VGND sg13g2_buf_1
XFILLER_86_952 VPWR VGND sg13g2_decap_4
XFILLER_38_45 VPWR VGND sg13g2_decap_8
Xfanout987 net990 net987 VPWR VGND sg13g2_buf_1
Xfanout998 net999 net998 VPWR VGND sg13g2_buf_1
XFILLER_57_142 VPWR VGND sg13g2_decap_8
XFILLER_46_816 VPWR VGND sg13g2_decap_4
XFILLER_18_507 VPWR VGND sg13g2_fill_2
X_11840_ VPWR _03261_ net672 VGND sg13g2_inv_1
XFILLER_60_307 VPWR VGND sg13g2_decap_8
XFILLER_54_44 VPWR VGND sg13g2_decap_4
X_23757_ net1624 VGND VPWR net525 u_LMS.i_enable clknet_leaf_25_clkA sg13g2_dfrbpq_1
X_20969_ _01608_ VPWR _01609_ VGND _03306_ _01590_ sg13g2_o21ai_1
X_13510_ _04843_ _04827_ _04842_ VPWR VGND sg13g2_xnor2_1
X_22708_ u_debug_unit.error_signal_sync\[5\] net2066 net332 _00693_ VPWR VGND sg13g2_mux2_1
X_14490_ net992 VPWR _05787_ VGND net490 u_FIR.sum\[5\]\[1\] sg13g2_o21ai_1
X_23688_ net1013 VGND VPWR _00750_ u_debug_unit.mon_w7_sync\[5\] clknet_leaf_37_clkA
+ sg13g2_dfrbpq_1
XFILLER_41_565 VPWR VGND sg13g2_decap_8
X_13441_ _04781_ VPWR _04782_ VGND net539 u_FIR.sum\[2\]\[14\] sg13g2_o21ai_1
XFILLER_16_1021 VPWR VGND sg13g2_fill_1
X_22639_ coeff_force_packed\[15\] net470 _03063_ _00633_ VPWR VGND sg13g2_mux2_1
X_16160_ _07399_ _07362_ _07398_ VPWR VGND sg13g2_xnor2_1
X_13372_ net410 _04713_ u_FIR.w\[6\]\[6\] _04715_ VPWR VGND sg13g2_nand3_1
Xclkload19 VPWR clkload19/Y clknet_leaf_2_clkA VGND sg13g2_inv_1
X_15111_ _06384_ net778 net847 VPWR VGND sg13g2_nand2_1
X_12323_ _03703_ _03697_ _03702_ VPWR VGND sg13g2_xnor2_1
X_16091_ _07331_ _07330_ _07293_ VPWR VGND sg13g2_nand2b_1
XFILLER_86_1019 VPWR VGND sg13g2_decap_4
XFILLER_5_433 VPWR VGND sg13g2_decap_8
X_15042_ _06317_ _06311_ _06315_ VPWR VGND sg13g2_xnor2_1
X_12254_ _03636_ _03633_ _03634_ VPWR VGND sg13g2_xnor2_1
XFILLER_79_74 VPWR VGND sg13g2_decap_8
X_19850_ _10849_ VPWR _10902_ VGND _10847_ _10848_ sg13g2_o21ai_1
X_12185_ _00037_ VPWR _03576_ VGND u_spi_slave.bit_cnt\[1\] u_spi_slave.bit_cnt\[0\]
+ sg13g2_o21ai_1
XFILLER_122_342 VPWR VGND sg13g2_fill_1
X_18801_ _09888_ net662 net80 VPWR VGND sg13g2_nand2_1
X_19781_ VPWR _10845_ _10844_ VGND sg13g2_inv_1
X_16993_ _08149_ _08111_ _08117_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_941 VPWR VGND sg13g2_decap_8
X_18732_ _09819_ _09785_ _09818_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_182 VPWR VGND sg13g2_decap_8
X_15944_ _07188_ u_FIR.sum\[6\]\[16\] net390 VPWR VGND sg13g2_xnor2_1
XFILLER_95_62 VPWR VGND sg13g2_fill_2
X_18663_ _09751_ _09752_ _00346_ VPWR VGND sg13g2_nor2_1
X_15875_ _07122_ _07093_ _07095_ _07058_ net785 VPWR VGND sg13g2_a22oi_1
XFILLER_49_698 VPWR VGND sg13g2_decap_8
XFILLER_76_484 VPWR VGND sg13g2_decap_8
XFILLER_36_337 VPWR VGND sg13g2_fill_2
X_17614_ _08739_ _08738_ _08747_ VPWR VGND sg13g2_xor2_1
X_14826_ _06086_ _06112_ _06113_ VPWR VGND sg13g2_nor2_1
XFILLER_36_348 VPWR VGND sg13g2_fill_1
X_18594_ _09699_ net301 u_LMS.w\[2\]\[17\] coeff_force_packed\[19\] net558 VPWR VGND
+ sg13g2_a22oi_1
X_17545_ _08586_ _08584_ _08678_ VPWR VGND sg13g2_xor2_1
X_14757_ _06045_ VPWR _06046_ VGND net505 u_FIR.sum\[5\]\[9\] sg13g2_o21ai_1
X_11969_ _03389_ u_spi_slave.tx_active _03388_ VPWR VGND sg13g2_nand2_1
XFILLER_60_830 VPWR VGND sg13g2_fill_2
XFILLER_72_690 VPWR VGND sg13g2_fill_1
X_13708_ _05036_ _05001_ _05034_ VPWR VGND sg13g2_xnor2_1
X_17476_ VPWR _08609_ _08608_ VGND sg13g2_inv_1
X_14688_ _05978_ _05972_ _05976_ VPWR VGND sg13g2_xnor2_1
X_19215_ _10295_ _10170_ _10294_ VPWR VGND sg13g2_xnor2_1
X_16427_ _07657_ _07637_ _07641_ VPWR VGND sg13g2_nand2_1
X_13639_ _03363_ net893 _04968_ VPWR VGND sg13g2_nor2_1
X_19146_ _10233_ u_LMS.w\[3\]\[13\] _10181_ VPWR VGND sg13g2_xnor2_1
X_16358_ VGND VPWR _07591_ _07589_ _07588_ sg13g2_or2_1
XFILLER_118_615 VPWR VGND sg13g2_fill_1
XFILLER_118_626 VPWR VGND sg13g2_decap_4
X_15309_ _06577_ net775 net821 VPWR VGND sg13g2_nand2_1
XFILLER_9_794 VPWR VGND sg13g2_fill_1
XFILLER_118_648 VPWR VGND sg13g2_decap_8
X_19077_ _10164_ _10162_ _10163_ VPWR VGND sg13g2_nand2_1
X_16289_ _07524_ net794 net819 VPWR VGND sg13g2_nand2_1
X_18028_ _09148_ _08936_ u_LMS.w\[1\]\[2\] VPWR VGND sg13g2_nand2b_1
XFILLER_114_843 VPWR VGND sg13g2_fill_1
XFILLER_113_320 VPWR VGND sg13g2_fill_2
XFILLER_125_191 VPWR VGND sg13g2_fill_2
Xfanout206 net207 net206 VPWR VGND sg13g2_buf_1
Xfanout217 net218 net217 VPWR VGND sg13g2_buf_2
Xfanout228 net233 net228 VPWR VGND sg13g2_buf_1
X_19979_ _11018_ _11004_ _11020_ VPWR VGND sg13g2_xor2_1
Xfanout239 net239 net243 VPWR VGND sg13g2_buf_4
X_22990_ net1221 VGND VPWR _00052_ u_FIR.sum\[0\]\[2\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
XFILLER_83_911 VPWR VGND sg13g2_fill_2
X_21941_ net577 net204 _02535_ VPWR VGND sg13g2_and2_1
XFILLER_94_270 VPWR VGND sg13g2_fill_1
XFILLER_27_315 VPWR VGND sg13g2_decap_8
XFILLER_27_326 VPWR VGND sg13g2_fill_1
XFILLER_39_197 VPWR VGND sg13g2_decap_8
Xclkbuf_3_2__f_spi_sclk clknet_3_2__leaf_spi_sclk clknet_0_spi_sclk VPWR VGND sg13g2_buf_16
XFILLER_55_657 VPWR VGND sg13g2_fill_1
XFILLER_27_348 VPWR VGND sg13g2_fill_1
X_21872_ _02466_ _02464_ _02465_ VPWR VGND sg13g2_xnor2_1
X_23611_ net965 VGND VPWR _00673_ coeff_force_packed\[50\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
X_20823_ _01462_ _01460_ _01463_ VPWR VGND sg13g2_xor2_1
XFILLER_42_329 VPWR VGND sg13g2_fill_2
X_23542_ net964 VGND VPWR _00604_ debug_load_bus\[4\] clknet_leaf_17_clkA sg13g2_dfrbpq_1
X_20754_ VGND VPWR _01382_ _01393_ _01394_ _01381_ sg13g2_a21oi_1
XFILLER_126_1035 VPWR VGND sg13g2_decap_8
XFILLER_11_705 VPWR VGND sg13g2_fill_2
XFILLER_51_896 VPWR VGND sg13g2_decap_8
X_23473_ net1507 VGND VPWR _00535_ u_LMS.x_r\[6\]\[0\] clknet_leaf_11_clkA sg13g2_dfrbpq_1
X_20685_ _03233_ net94 _01325_ VPWR VGND sg13g2_nor2_1
XFILLER_109_604 VPWR VGND sg13g2_fill_2
X_22424_ VGND VPWR net436 _03257_ _00520_ _02961_ sg13g2_a21oi_1
X_22355_ net358 VPWR _02927_ VGND u_LMS.w\[8\]\[11\] net373 sg13g2_o21ai_1
X_21306_ _01923_ _01920_ _01921_ VPWR VGND sg13g2_xnor2_1
XFILLER_40_79 VPWR VGND sg13g2_decap_8
X_22286_ net61 u_LMS.w\[8\]\[18\] _02826_ _02873_ VPWR VGND sg13g2_a21o_1
XFILLER_123_117 VPWR VGND sg13g2_decap_8
XFILLER_2_436 VPWR VGND sg13g2_fill_1
XFILLER_105_854 VPWR VGND sg13g2_fill_2
X_21237_ _01848_ _01853_ _01854_ VPWR VGND sg13g2_and2_1
X_23305__1297 VPWR VGND net1296 sg13g2_tiehi
XFILLER_116_180 VPWR VGND sg13g2_fill_1
XFILLER_132_651 VPWR VGND sg13g2_fill_2
XFILLER_49_44 VPWR VGND sg13g2_decap_8
XFILLER_49_55 VPWR VGND sg13g2_fill_1
X_21168_ VPWR _01785_ _01784_ VGND sg13g2_inv_1
XFILLER_77_215 VPWR VGND sg13g2_fill_2
XFILLER_132_695 VPWR VGND sg13g2_decap_8
Xfanout740 u_FIR.w\[6\]\[5\] net740 VPWR VGND sg13g2_buf_1
Xfanout751 u_FIR.w\[5\]\[3\] net751 VPWR VGND sg13g2_buf_1
XFILLER_120_857 VPWR VGND sg13g2_fill_2
X_20119_ _11160_ net628 net230 VPWR VGND sg13g2_nand2_1
Xfanout762 u_FIR.w\[4\]\[2\] net762 VPWR VGND sg13g2_buf_1
XFILLER_131_194 VPWR VGND sg13g2_decap_8
X_21099_ _01721_ _01722_ _00434_ VPWR VGND sg13g2_nor2_1
Xfanout773 u_FIR.w\[3\]\[0\] net773 VPWR VGND sg13g2_buf_1
X_13990_ _05305_ net762 net892 VPWR VGND sg13g2_nand2_1
XFILLER_93_708 VPWR VGND sg13g2_decap_8
Xfanout784 net785 net784 VPWR VGND sg13g2_buf_1
Xfanout795 u_FIR.w\[0\]\[4\] net795 VPWR VGND sg13g2_buf_1
XFILLER_86_771 VPWR VGND sg13g2_fill_2
XFILLER_59_985 VPWR VGND sg13g2_decap_8
XFILLER_58_462 VPWR VGND sg13g2_fill_1
X_12941_ _04299_ net284 _04300_ VPWR VGND sg13g2_xor2_1
XFILLER_85_281 VPWR VGND sg13g2_decap_4
X_15660_ net817 net790 _06911_ _06913_ VPWR VGND sg13g2_a21o_1
X_12872_ _04233_ u_FIR.sum\[0\]\[10\] net407 VPWR VGND sg13g2_xnor2_1
X_14611_ _05903_ _05861_ _05901_ VPWR VGND sg13g2_xnor2_1
XFILLER_45_167 VPWR VGND sg13g2_decap_8
X_11823_ VPWR _03244_ net641 VGND sg13g2_inv_1
X_15591_ _06846_ _06806_ _06844_ VPWR VGND sg13g2_xnor2_1
XFILLER_27_893 VPWR VGND sg13g2_decap_8
X_17330_ _08486_ _03354_ net71 VPWR VGND sg13g2_xnor2_1
X_14542_ _05813_ _05815_ _05836_ VPWR VGND sg13g2_and2_1
XFILLER_121_82 VPWR VGND sg13g2_decap_4
XFILLER_14_554 VPWR VGND sg13g2_decap_8
XFILLER_81_64 VPWR VGND sg13g2_decap_8
X_17261_ _08417_ _08350_ _08351_ VPWR VGND sg13g2_xnor2_1
X_14473_ _05772_ _05769_ _05771_ VPWR VGND sg13g2_xnor2_1
X_19000_ _10087_ _10082_ _10083_ VPWR VGND sg13g2_xnor2_1
X_16212_ net847 _07448_ net793 _07449_ VPWR VGND sg13g2_nand3_1
X_13424_ VGND VPWR _04739_ _04757_ _04765_ _04756_ sg13g2_a21oi_1
X_17192_ _08347_ VPWR _08348_ VGND _08346_ _08344_ sg13g2_o21ai_1
XFILLER_128_935 VPWR VGND sg13g2_fill_2
XFILLER_10_771 VPWR VGND sg13g2_fill_1
X_16143_ _07382_ _07375_ _07380_ VPWR VGND sg13g2_xnor2_1
X_13355_ _04677_ _04698_ _04699_ VPWR VGND sg13g2_nor2b_1
XFILLER_128_979 VPWR VGND sg13g2_fill_1
X_12306_ _03686_ _03653_ _03685_ VPWR VGND sg13g2_xnor2_1
X_16074_ _07315_ _07250_ _07313_ VPWR VGND sg13g2_xnor2_1
XFILLER_115_629 VPWR VGND sg13g2_fill_1
XFILLER_108_670 VPWR VGND sg13g2_fill_2
X_13286_ net538 VPWR _04632_ VGND _04630_ _04631_ sg13g2_o21ai_1
XFILLER_53_7 VPWR VGND sg13g2_fill_2
XFILLER_114_128 VPWR VGND sg13g2_fill_1
X_19902_ _10943_ net624 net134 VPWR VGND sg13g2_nand2_1
X_15025_ _06301_ _06293_ _06300_ VPWR VGND sg13g2_nand2_1
X_12237_ _03604_ _03619_ _03620_ VPWR VGND sg13g2_and2_1
XFILLER_69_716 VPWR VGND sg13g2_fill_2
XFILLER_123_662 VPWR VGND sg13g2_decap_8
X_19833_ VGND VPWR u_LMS.w\[4\]\[20\] net310 _10889_ _10879_ sg13g2_a21oi_1
X_12168_ net945 u_spi_slave.rx_shift\[14\] net323 _00020_ VPWR VGND sg13g2_nor3_1
XFILLER_68_215 VPWR VGND sg13g2_decap_8
XFILLER_2_992 VPWR VGND sg13g2_decap_8
XFILLER_68_248 VPWR VGND sg13g2_fill_2
X_19764_ _10828_ _10814_ _10827_ VPWR VGND sg13g2_xnor2_1
X_16976_ _08132_ _08124_ _08129_ VPWR VGND sg13g2_xnor2_1
X_12099_ _03508_ _03509_ _03507_ _03511_ VPWR VGND _03510_ sg13g2_nand4_1
XFILLER_7_1052 VPWR VGND sg13g2_decap_8
XFILLER_77_760 VPWR VGND sg13g2_decap_8
XFILLER_65_911 VPWR VGND sg13g2_decap_4
XFILLER_37_602 VPWR VGND sg13g2_fill_1
X_18715_ _09802_ _09801_ _09800_ VPWR VGND sg13g2_nand2b_1
X_15927_ _07172_ _07126_ _07170_ VPWR VGND sg13g2_xnor2_1
X_19695_ _10759_ _10717_ _10719_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_270 VPWR VGND sg13g2_fill_2
XFILLER_37_624 VPWR VGND sg13g2_fill_2
XFILLER_65_944 VPWR VGND sg13g2_fill_1
X_18646_ net354 VPWR _09740_ VGND u_LMS.w\[2\]\[5\] net370 sg13g2_o21ai_1
X_15858_ _07106_ _07070_ _07104_ VPWR VGND sg13g2_xnor2_1
X_14809_ _06096_ _06095_ _06094_ VPWR VGND sg13g2_nand2b_1
X_18577_ _09685_ net33 net35 _09686_ VPWR VGND sg13g2_a21o_1
X_15789_ _07039_ _07035_ _07038_ VPWR VGND sg13g2_xnor2_1
X_17528_ _08661_ _08653_ _08659_ VPWR VGND sg13g2_xnor2_1
XFILLER_33_863 VPWR VGND sg13g2_fill_2
XFILLER_32_340 VPWR VGND sg13g2_decap_8
X_17459_ _08592_ _08588_ _08591_ VPWR VGND sg13g2_nand2_1
XFILLER_20_557 VPWR VGND sg13g2_decap_8
X_20470_ _01120_ u_LMS.w\[5\]\[2\] _00919_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_568 VPWR VGND sg13g2_fill_1
X_19129_ _10215_ _10214_ _10216_ VPWR VGND sg13g2_nor2b_1
XFILLER_118_434 VPWR VGND sg13g2_fill_2
X_22140_ _02456_ _02457_ _02734_ VPWR VGND sg13g2_nor2b_1
X_22071_ net203 net582 _02637_ _02665_ VPWR VGND sg13g2_a21o_1
XFILLER_126_49 VPWR VGND sg13g2_decap_8
XFILLER_102_802 VPWR VGND sg13g2_decap_8
X_21022_ _01662_ net1651 _01626_ VPWR VGND sg13g2_xnor2_1
XFILLER_59_204 VPWR VGND sg13g2_decap_4
XFILLER_113_150 VPWR VGND sg13g2_fill_2
XFILLER_102_824 VPWR VGND sg13g2_fill_2
XFILLER_101_323 VPWR VGND sg13g2_fill_1
XFILLER_19_25 VPWR VGND sg13g2_fill_1
XFILLER_59_259 VPWR VGND sg13g2_fill_1
XFILLER_56_900 VPWR VGND sg13g2_decap_8
XFILLER_56_911 VPWR VGND sg13g2_fill_2
XFILLER_101_389 VPWR VGND sg13g2_decap_8
XFILLER_56_922 VPWR VGND sg13g2_decap_8
X_21924_ _02518_ _02515_ _02516_ VPWR VGND sg13g2_xnor2_1
XFILLER_28_668 VPWR VGND sg13g2_fill_2
XFILLER_35_13 VPWR VGND sg13g2_fill_2
XFILLER_43_616 VPWR VGND sg13g2_decap_4
XFILLER_55_487 VPWR VGND sg13g2_decap_8
X_21855_ _02449_ _02447_ _02448_ VPWR VGND sg13g2_nand2_1
XFILLER_82_284 VPWR VGND sg13g2_decap_4
XFILLER_35_46 VPWR VGND sg13g2_decap_8
XFILLER_42_126 VPWR VGND sg13g2_decap_8
XFILLER_71_969 VPWR VGND sg13g2_fill_1
X_20806_ VGND VPWR _01430_ _01437_ _01446_ _01445_ sg13g2_a21oi_1
XFILLER_42_148 VPWR VGND sg13g2_fill_2
XFILLER_35_79 VPWR VGND sg13g2_decap_8
X_21786_ _02373_ _02358_ _02380_ VPWR VGND sg13g2_xor2_1
XFILLER_23_351 VPWR VGND sg13g2_decap_8
X_23525_ net1317 VGND VPWR _00587_ u_LMS.count\[28\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
X_20737_ _01377_ _01371_ _01375_ VPWR VGND sg13g2_xnor2_1
XFILLER_52_1040 VPWR VGND sg13g2_fill_1
X_23456_ net1563 VGND VPWR _00518_ u_LMS.x_r\[3\]\[7\] clknet_leaf_65_clkA sg13g2_dfrbpq_1
X_20668_ _01308_ _01305_ _01307_ VPWR VGND sg13g2_nand2_1
XFILLER_13_1035 VPWR VGND sg13g2_decap_8
X_22407_ net947 VPWR _02953_ VGND net434 net664 sg13g2_o21ai_1
XFILLER_51_89 VPWR VGND sg13g2_fill_1
X_23387_ net1187 VGND VPWR _00449_ u_LMS.w\[7\]\[20\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
X_20599_ net426 _03228_ net179 net227 _01239_ VPWR VGND sg13g2_nor4_1
XFILLER_109_467 VPWR VGND sg13g2_decap_4
X_13140_ _04489_ net744 net855 VPWR VGND sg13g2_nand2_1
X_22338_ VGND VPWR net47 _02913_ _02914_ net6 sg13g2_a21oi_1
X_13071_ _04422_ _04421_ _04414_ VPWR VGND sg13g2_nand2b_1
XFILLER_105_640 VPWR VGND sg13g2_decap_8
X_22269_ _02860_ net312 u_LMS.w\[8\]\[15\] coeff_force_packed\[59\] net561 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_105_651 VPWR VGND sg13g2_fill_2
XFILLER_3_767 VPWR VGND sg13g2_fill_2
XFILLER_105_673 VPWR VGND sg13g2_decap_8
X_12022_ _03409_ _03423_ _03439_ VPWR VGND sg13g2_nor2_1
XFILLER_132_470 VPWR VGND sg13g2_decap_4
XFILLER_104_194 VPWR VGND sg13g2_fill_1
X_16830_ VGND VPWR _07986_ _07985_ _07966_ sg13g2_or2_1
XFILLER_116_82 VPWR VGND sg13g2_decap_8
Xfanout570 u_LMS.x_r\[8\]\[7\] net570 VPWR VGND sg13g2_buf_1
Xfanout581 u_LMS.x_r\[8\]\[3\] net581 VPWR VGND sg13g2_buf_1
XFILLER_19_602 VPWR VGND sg13g2_decap_8
Xfanout592 net593 net592 VPWR VGND sg13g2_buf_1
XFILLER_47_922 VPWR VGND sg13g2_decap_8
X_16761_ _07917_ net915 _07915_ VPWR VGND sg13g2_nand2_1
X_13973_ VGND VPWR _05282_ _05289_ _05291_ _05290_ sg13g2_a21oi_1
XFILLER_76_97 VPWR VGND sg13g2_decap_8
X_18500_ _09610_ _09531_ _09536_ VPWR VGND sg13g2_xnor2_1
X_15712_ _06964_ _06963_ _06922_ VPWR VGND sg13g2_nand2b_1
X_12924_ _04269_ VPWR _04283_ VGND net284 _04267_ sg13g2_o21ai_1
X_19480_ _10542_ _10543_ _10544_ VPWR VGND sg13g2_nor2_1
X_16692_ VGND VPWR net517 _07858_ _00268_ _07859_ sg13g2_a21oi_1
XFILLER_132_70 VPWR VGND sg13g2_decap_8
X_18431_ _09520_ _09540_ _09541_ VPWR VGND sg13g2_nor2b_1
XFILLER_34_627 VPWR VGND sg13g2_decap_4
X_15643_ _06890_ _06893_ _06896_ VPWR VGND sg13g2_nor2_1
X_12855_ net814 _04183_ u_FIR.w\[7\]\[1\] _04216_ VPWR VGND _04213_ sg13g2_nand4_1
XFILLER_92_63 VPWR VGND sg13g2_fill_2
X_11806_ VPWR _03227_ net606 VGND sg13g2_inv_1
XFILLER_15_852 VPWR VGND sg13g2_decap_8
X_18362_ _09470_ _09471_ _09472_ VPWR VGND sg13g2_nor2_1
X_15574_ _06829_ net789 net845 VPWR VGND sg13g2_nand2_1
X_12786_ _04143_ _04148_ _04149_ VPWR VGND sg13g2_nor2b_1
XFILLER_15_874 VPWR VGND sg13g2_fill_2
X_17313_ _08404_ _08407_ _08468_ _08469_ VPWR VGND sg13g2_or3_1
X_14525_ _05818_ _05819_ _05820_ VPWR VGND sg13g2_nor2b_1
X_18293_ _03266_ net126 net2198 net123 _09403_ VPWR VGND sg13g2_nor4_1
X_17244_ _08400_ _08397_ _08399_ VPWR VGND sg13g2_xnor2_1
X_14456_ _05755_ net278 _05756_ VPWR VGND sg13g2_xor2_1
X_13407_ _04749_ u_FIR.sum\[1\]\[13\] net406 VPWR VGND sg13g2_nand2_1
XFILLER_128_743 VPWR VGND sg13g2_decap_8
X_17175_ _08331_ _08322_ _08326_ VPWR VGND sg13g2_xnor2_1
X_14387_ _05665_ _05690_ _05691_ VPWR VGND sg13g2_nor2b_1
XFILLER_128_754 VPWR VGND sg13g2_fill_2
XFILLER_116_905 VPWR VGND sg13g2_fill_1
X_16126_ _07353_ VPWR _07365_ VGND _07305_ _07343_ sg13g2_o21ai_1
X_13338_ _04682_ net739 net829 VPWR VGND sg13g2_nand2_1
XFILLER_116_938 VPWR VGND sg13g2_decap_4
XFILLER_6_583 VPWR VGND sg13g2_fill_2
XFILLER_127_286 VPWR VGND sg13g2_fill_2
X_16057_ _07298_ net799 net845 VPWR VGND sg13g2_nand2_1
X_13269_ _04615_ _04598_ _04614_ VPWR VGND sg13g2_xnor2_1
XFILLER_131_919 VPWR VGND sg13g2_decap_8
XFILLER_124_960 VPWR VGND sg13g2_decap_4
X_23704__1489 VPWR VGND net1488 sg13g2_tiehi
X_23384__1197 VPWR VGND net1196 sg13g2_tiehi
X_15008_ _06283_ _06284_ _06285_ VPWR VGND sg13g2_nor2b_1
XFILLER_97_833 VPWR VGND sg13g2_decap_8
XFILLER_124_993 VPWR VGND sg13g2_decap_8
XFILLER_111_621 VPWR VGND sg13g2_fill_1
XFILLER_37_2 VPWR VGND sg13g2_fill_1
XFILLER_97_844 VPWR VGND sg13g2_fill_2
XFILLER_110_120 VPWR VGND sg13g2_decap_4
X_19816_ _10875_ net310 u_LMS.w\[4\]\[17\] coeff_force_packed\[33\] net562 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_116_1045 VPWR VGND sg13g2_decap_8
XFILLER_97_877 VPWR VGND sg13g2_fill_2
XFILLER_97_888 VPWR VGND sg13g2_fill_1
XFILLER_69_579 VPWR VGND sg13g2_fill_1
XFILLER_96_365 VPWR VGND sg13g2_fill_2
XFILLER_84_505 VPWR VGND sg13g2_decap_4
XFILLER_38_900 VPWR VGND sg13g2_fill_2
XFILLER_56_207 VPWR VGND sg13g2_decap_4
XFILLER_38_922 VPWR VGND sg13g2_fill_1
X_19747_ _10811_ _10432_ _10737_ VPWR VGND sg13g2_nand2b_1
X_16959_ _08114_ _08078_ _08115_ VPWR VGND sg13g2_xor2_1
X_19678_ _10738_ _10736_ _10742_ VPWR VGND sg13g2_xor2_1
XFILLER_37_454 VPWR VGND sg13g2_decap_8
XFILLER_37_465 VPWR VGND sg13g2_fill_1
XFILLER_37_476 VPWR VGND sg13g2_decap_8
XFILLER_37_487 VPWR VGND sg13g2_fill_2
X_18629_ _09726_ VPWR _09727_ VGND _09724_ _09725_ sg13g2_o21ai_1
XFILLER_24_148 VPWR VGND sg13g2_decap_8
X_21640_ net12 VPWR _02256_ VGND net11 _02255_ sg13g2_o21ai_1
XFILLER_75_1051 VPWR VGND sg13g2_decap_8
X_21571_ _02188_ u_LMS.w\[7\]\[3\] _02187_ VPWR VGND sg13g2_nand2_1
X_23310_ net1291 VGND VPWR _00372_ u_LMS.w\[4\]\[12\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_20522_ _01160_ _01154_ _01162_ VPWR VGND sg13g2_xor2_1
XFILLER_123_1038 VPWR VGND sg13g2_decap_8
X_23241_ net1407 VGND VPWR _00303_ u_LMS.w\[1\]\[12\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
X_20453_ net23 VPWR _01107_ VGND net21 _01106_ sg13g2_o21ai_1
X_23172_ net1529 VGND VPWR _00234_ u_FIR.w\[2\]\[3\] clknet_leaf_51_clkA sg13g2_dfrbpq_1
X_20384_ _00975_ VPWR _01047_ VGND _01046_ _01045_ sg13g2_o21ai_1
XFILLER_106_448 VPWR VGND sg13g2_decap_8
X_22123_ VPWR _02717_ _02716_ VGND sg13g2_inv_1
XFILLER_88_811 VPWR VGND sg13g2_decap_8
XFILLER_82_1022 VPWR VGND sg13g2_fill_1
XFILLER_0_726 VPWR VGND sg13g2_decap_8
X_22054_ _02646_ _02647_ _02648_ VPWR VGND sg13g2_nor2_1
XFILLER_0_737 VPWR VGND sg13g2_fill_2
XFILLER_99_170 VPWR VGND sg13g2_decap_4
XFILLER_101_120 VPWR VGND sg13g2_decap_4
XFILLER_102_643 VPWR VGND sg13g2_fill_2
X_21005_ _01643_ _01644_ _01640_ _01645_ VPWR VGND sg13g2_nand3_1
X_23168__1537 VPWR VGND net1536 sg13g2_tiehi
XFILLER_28_410 VPWR VGND sg13g2_fill_1
XFILLER_46_45 VPWR VGND sg13g2_fill_1
X_22956_ _07696_ VPWR _00813_ VGND _03288_ net525 sg13g2_o21ai_1
XFILLER_44_914 VPWR VGND sg13g2_decap_4
X_21907_ _02500_ _02468_ _02501_ VPWR VGND sg13g2_xor2_1
X_22887_ _03172_ net297 u_FIR.x\[0\] net298 net4 VPWR VGND sg13g2_a22oi_1
XFILLER_102_40 VPWR VGND sg13g2_fill_2
XFILLER_70_221 VPWR VGND sg13g2_fill_2
XFILLER_70_232 VPWR VGND sg13g2_fill_1
X_12640_ _04007_ _03969_ _04005_ VPWR VGND sg13g2_xnor2_1
X_21838_ _02432_ _02336_ _02338_ VPWR VGND sg13g2_xnor2_1
XFILLER_70_254 VPWR VGND sg13g2_fill_1
XFILLER_102_95 VPWR VGND sg13g2_fill_1
XFILLER_52_980 VPWR VGND sg13g2_fill_1
X_12571_ VGND VPWR _03940_ _03941_ _03942_ net413 sg13g2_a21oi_1
XFILLER_24_693 VPWR VGND sg13g2_fill_1
X_21769_ _02345_ VPWR _02363_ VGND _02342_ _02343_ sg13g2_o21ai_1
X_14310_ _05616_ _05604_ _05615_ VPWR VGND sg13g2_xnor2_1
X_23508_ net1384 VGND VPWR _00570_ u_LMS.count\[11\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
X_15290_ _06551_ _06558_ _06559_ VPWR VGND sg13g2_nor2b_1
XFILLER_129_529 VPWR VGND sg13g2_decap_8
XFILLER_8_837 VPWR VGND sg13g2_fill_2
XFILLER_7_28 VPWR VGND sg13g2_decap_8
X_14241_ _05549_ _05545_ _05548_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_0 VPWR VGND sg13g2_decap_8
XFILLER_11_387 VPWR VGND sg13g2_decap_8
X_23439_ net1614 VGND VPWR _00501_ u_LMS.x_r\[1\]\[6\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
XFILLER_7_369 VPWR VGND sg13g2_decap_4
X_14172_ _05480_ _05444_ _05482_ VPWR VGND sg13g2_xor2_1
XFILLER_124_201 VPWR VGND sg13g2_fill_1
XFILLER_109_286 VPWR VGND sg13g2_fill_2
X_13123_ _04438_ _04472_ _04436_ _04473_ VPWR VGND sg13g2_nand3_1
XFILLER_125_757 VPWR VGND sg13g2_fill_1
XFILLER_3_531 VPWR VGND sg13g2_decap_8
X_18980_ _10067_ net667 net219 VPWR VGND sg13g2_nand2_1
XFILLER_127_70 VPWR VGND sg13g2_decap_8
X_17931_ _09064_ _09058_ _09063_ VPWR VGND sg13g2_xnor2_1
X_13054_ _04406_ _04397_ _04404_ VPWR VGND sg13g2_xnor2_1
XFILLER_97_118 VPWR VGND sg13g2_fill_1
XFILLER_124_289 VPWR VGND sg13g2_fill_1
XFILLER_3_597 VPWR VGND sg13g2_decap_8
XFILLER_121_930 VPWR VGND sg13g2_decap_8
XFILLER_78_321 VPWR VGND sg13g2_decap_8
X_12005_ _03422_ _03419_ _03420_ _03421_ VPWR VGND sg13g2_and3_1
XFILLER_78_332 VPWR VGND sg13g2_fill_1
X_17862_ _08995_ _08954_ _08955_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_803 VPWR VGND sg13g2_fill_1
XFILLER_121_963 VPWR VGND sg13g2_decap_4
XFILLER_87_96 VPWR VGND sg13g2_decap_8
XFILLER_79_888 VPWR VGND sg13g2_decap_8
X_19601_ _10665_ _10635_ _10641_ VPWR VGND sg13g2_xnor2_1
X_16813_ _07969_ net2136 _07935_ VPWR VGND sg13g2_xnor2_1
XFILLER_4_1011 VPWR VGND sg13g2_decap_8
X_17793_ _08926_ net258 net694 net243 net697 VPWR VGND sg13g2_a22oi_1
XFILLER_47_730 VPWR VGND sg13g2_decap_8
XFILLER_93_346 VPWR VGND sg13g2_decap_8
X_19532_ _10590_ VPWR _10596_ VGND _10586_ _10591_ sg13g2_o21ai_1
X_16744_ _07895_ _07897_ _07899_ _07900_ VPWR VGND sg13g2_or3_1
X_13956_ _05275_ _05266_ _05274_ VPWR VGND sg13g2_xnor2_1
XFILLER_98_1051 VPWR VGND sg13g2_decap_8
XFILLER_93_379 VPWR VGND sg13g2_fill_2
X_19463_ _10527_ _10525_ _10526_ VPWR VGND sg13g2_nand2_1
X_12907_ _04267_ u_FIR.sum\[0\]\[11\] net408 VPWR VGND sg13g2_xnor2_1
X_23231__1426 VPWR VGND net1425 sg13g2_tiehi
X_16675_ net1039 VPWR _07846_ VGND net544 u_FIR.w\[6\]\[6\] sg13g2_o21ai_1
X_13887_ VGND VPWR net536 _05208_ _00113_ _05209_ sg13g2_a21oi_1
XFILLER_46_295 VPWR VGND sg13g2_fill_1
XFILLER_35_969 VPWR VGND sg13g2_fill_2
X_18414_ _09524_ net683 net239 VPWR VGND sg13g2_nand2_1
X_15626_ _06878_ _06879_ _06880_ VPWR VGND sg13g2_nor2_1
X_12838_ _04200_ _04171_ _04198_ VPWR VGND sg13g2_xnor2_1
X_19394_ _10458_ _10456_ _10457_ VPWR VGND sg13g2_nand2_1
XFILLER_61_276 VPWR VGND sg13g2_decap_8
X_18345_ _09455_ net678 net217 VPWR VGND sg13g2_nand2_1
X_15557_ _06813_ _06804_ _06811_ VPWR VGND sg13g2_xnor2_1
X_12769_ VGND VPWR _04113_ _04119_ _04132_ _04118_ sg13g2_a21oi_1
X_14508_ VGND VPWR net490 _05802_ _00140_ _05803_ sg13g2_a21oi_1
X_18276_ _09384_ _09385_ _09386_ VPWR VGND sg13g2_nor2b_1
X_15488_ net975 VPWR _06748_ VGND net481 u_FIR.sum\[7\]\[0\] sg13g2_o21ai_1
XFILLER_30_674 VPWR VGND sg13g2_fill_2
Xclkbuf_leaf_23_clkA clknet_4_11_0_clkA clknet_leaf_23_clkA VPWR VGND sg13g2_buf_8
X_17227_ VGND VPWR _08029_ _08059_ _08383_ _08382_ sg13g2_a21oi_1
X_14439_ VGND VPWR _05717_ _05719_ _05740_ _05739_ sg13g2_a21oi_1
XFILLER_7_870 VPWR VGND sg13g2_decap_8
XFILLER_128_573 VPWR VGND sg13g2_fill_1
X_17158_ net212 net710 _08285_ _08314_ VPWR VGND sg13g2_a21o_1
XFILLER_7_881 VPWR VGND sg13g2_fill_2
X_16109_ _07349_ u_FIR.w\[0\]\[6\] _07348_ VPWR VGND sg13g2_xnor2_1
X_17089_ _08245_ _08242_ _08243_ VPWR VGND sg13g2_xnor2_1
XFILLER_131_705 VPWR VGND sg13g2_fill_1
XFILLER_116_779 VPWR VGND sg13g2_fill_2
XFILLER_103_407 VPWR VGND sg13g2_fill_2
XFILLER_42_0 VPWR VGND sg13g2_decap_4
XFILLER_103_418 VPWR VGND sg13g2_decap_8
XFILLER_131_727 VPWR VGND sg13g2_fill_2
XFILLER_88_118 VPWR VGND sg13g2_decap_8
XFILLER_124_790 VPWR VGND sg13g2_fill_2
XFILLER_130_248 VPWR VGND sg13g2_decap_8
XFILLER_97_663 VPWR VGND sg13g2_decap_4
XFILLER_112_985 VPWR VGND sg13g2_decap_4
XFILLER_29_229 VPWR VGND sg13g2_decap_4
XFILLER_123_28 VPWR VGND sg13g2_decap_8
X_22810_ u_debug_unit.mon_w7_sync\[0\] net349 _03123_ VPWR VGND sg13g2_nor2_1
XFILLER_26_903 VPWR VGND sg13g2_fill_2
X_22741_ VGND VPWR _07755_ net333 _00710_ _03088_ sg13g2_a21oi_1
XFILLER_37_273 VPWR VGND sg13g2_fill_1
XFILLER_80_552 VPWR VGND sg13g2_decap_4
X_22672_ u_debug_unit.force_w5\[7\] net459 _03066_ _00663_ VPWR VGND sg13g2_mux2_1
XFILLER_53_799 VPWR VGND sg13g2_fill_2
X_21623_ _02240_ _02238_ _02239_ VPWR VGND sg13g2_nand2_1
XFILLER_12_129 VPWR VGND sg13g2_decap_4
XFILLER_32_14 VPWR VGND sg13g2_decap_4
X_21554_ _03302_ _02170_ _02171_ VPWR VGND sg13g2_nor2_1
X_20505_ _01145_ _01146_ _00416_ VPWR VGND sg13g2_nor2_1
XFILLER_120_7 VPWR VGND sg13g2_decap_8
X_21485_ _02078_ _02077_ _02102_ VPWR VGND sg13g2_xor2_1
XFILLER_10_1005 VPWR VGND sg13g2_fill_1
X_23224_ net1437 VGND VPWR _00286_ u_LMS.w\[0\]\[18\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
X_20436_ net22 VPWR _01093_ VGND net20 _01092_ sg13g2_o21ai_1
XFILLER_4_317 VPWR VGND sg13g2_fill_1
XFILLER_10_1049 VPWR VGND sg13g2_decap_8
X_23155_ net1556 VGND VPWR _00217_ u_FIR.w\[0\]\[0\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
XFILLER_107_779 VPWR VGND sg13g2_fill_1
X_20367_ _00987_ u_LMS.w\[5\]\[11\] _01030_ VPWR VGND sg13g2_xor2_1
XFILLER_106_278 VPWR VGND sg13g2_decap_4
X_22106_ _02651_ _02652_ _02700_ VPWR VGND sg13g2_and2_1
XFILLER_106_289 VPWR VGND sg13g2_fill_1
XFILLER_122_738 VPWR VGND sg13g2_fill_1
X_23086_ net1077 VGND VPWR _00148_ u_FIR.sum\[5\]\[10\] clknet_leaf_41_clkA sg13g2_dfrbpq_1
XFILLER_103_930 VPWR VGND sg13g2_decap_4
X_20298_ _00961_ net622 net158 VPWR VGND sg13g2_nand2_1
XFILLER_115_790 VPWR VGND sg13g2_fill_2
XFILLER_103_941 VPWR VGND sg13g2_fill_1
XFILLER_0_545 VPWR VGND sg13g2_fill_1
XFILLER_0_556 VPWR VGND sg13g2_decap_8
X_22037_ VGND VPWR _02629_ _02630_ _02631_ _02628_ sg13g2_a21oi_1
XFILLER_102_462 VPWR VGND sg13g2_fill_2
XFILLER_88_685 VPWR VGND sg13g2_decap_8
XFILLER_76_825 VPWR VGND sg13g2_fill_1
XFILLER_102_473 VPWR VGND sg13g2_decap_8
XFILLER_130_793 VPWR VGND sg13g2_fill_1
XFILLER_76_858 VPWR VGND sg13g2_decap_8
X_13810_ _05135_ u_FIR.sum\[2\]\[11\] net403 VPWR VGND sg13g2_nand2_1
X_14790_ _06078_ _06050_ _06076_ VPWR VGND sg13g2_xnor2_1
XFILLER_17_936 VPWR VGND sg13g2_decap_4
X_13741_ _05068_ _05026_ _05066_ VPWR VGND sg13g2_xnor2_1
X_22939_ VGND VPWR net324 _03200_ _00800_ _03199_ sg13g2_a21oi_1
XFILLER_56_593 VPWR VGND sg13g2_fill_1
XFILLER_28_284 VPWR VGND sg13g2_fill_2
XFILLER_16_446 VPWR VGND sg13g2_decap_8
X_16460_ _07688_ _07683_ _07687_ VPWR VGND sg13g2_xnor2_1
X_13672_ VGND VPWR net532 _04999_ _00107_ _05000_ sg13g2_a21oi_1
XFILLER_71_574 VPWR VGND sg13g2_decap_8
XFILLER_43_276 VPWR VGND sg13g2_fill_1
X_15411_ _06676_ _06667_ _06674_ VPWR VGND sg13g2_xnor2_1
X_12623_ VGND VPWR _03958_ _03973_ _03990_ _03972_ sg13g2_a21oi_1
Xclkbuf_leaf_46_clkA clknet_4_4_0_clkA clknet_leaf_46_clkA VPWR VGND sg13g2_buf_8
X_16391_ _07604_ _07606_ _07622_ _07623_ VPWR VGND sg13g2_nor3_1
X_18130_ VGND VPWR _09216_ _09239_ _09240_ _09238_ sg13g2_a21oi_1
X_15342_ _06609_ net775 net808 VPWR VGND sg13g2_nand2_1
XFILLER_129_304 VPWR VGND sg13g2_fill_2
X_12554_ _03927_ _03915_ _03925_ VPWR VGND sg13g2_xnor2_1
X_18061_ _09172_ net57 _09171_ VPWR VGND sg13g2_nand2_1
X_15273_ _03370_ net848 _06542_ VPWR VGND sg13g2_nor2_1
X_12485_ VPWR _03860_ _03859_ VGND sg13g2_inv_1
X_17012_ _08168_ net709 net212 VPWR VGND sg13g2_nand2_1
X_14224_ net851 net757 _05530_ _05532_ VPWR VGND sg13g2_a21o_1
X_14155_ _05465_ _05448_ _05464_ VPWR VGND sg13g2_nand2_1
X_13106_ _04454_ _04447_ _04456_ VPWR VGND sg13g2_xor2_1
XFILLER_3_361 VPWR VGND sg13g2_fill_1
XFILLER_125_598 VPWR VGND sg13g2_decap_4
X_18963_ _10050_ net664 net184 VPWR VGND sg13g2_nand2_1
X_14086_ _05396_ _05360_ _05398_ VPWR VGND sg13g2_xor2_1
X_23275__1344 VPWR VGND net1343 sg13g2_tiehi
X_17914_ _09047_ u_LMS.w\[1\]\[17\] _08978_ VPWR VGND sg13g2_xnor2_1
X_13037_ _04388_ _04387_ _04390_ VPWR VGND sg13g2_xor2_1
X_18894_ _03252_ _03253_ net235 net251 _09981_ VPWR VGND sg13g2_nor4_1
XFILLER_26_1056 VPWR VGND sg13g2_decap_4
XFILLER_113_1004 VPWR VGND sg13g2_fill_1
X_17845_ _08978_ _08670_ _08977_ VPWR VGND sg13g2_xnor2_1
XFILLER_66_324 VPWR VGND sg13g2_fill_1
XFILLER_93_132 VPWR VGND sg13g2_fill_2
XFILLER_82_806 VPWR VGND sg13g2_decap_4
X_23318__1284 VPWR VGND net1283 sg13g2_tiehi
X_17776_ _08909_ _08886_ _08908_ VPWR VGND sg13g2_nand2_1
X_14988_ _06264_ _06265_ _06266_ VPWR VGND sg13g2_nor2_1
X_19515_ _10579_ _10542_ _10543_ VPWR VGND sg13g2_xnor2_1
X_16727_ net1031 VPWR _07885_ VGND net528 net720 sg13g2_o21ai_1
X_13939_ _05250_ _05258_ _05259_ VPWR VGND sg13g2_nor2_1
XFILLER_62_530 VPWR VGND sg13g2_fill_2
X_19446_ _10510_ net645 net174 VPWR VGND sg13g2_nand2_1
XFILLER_50_703 VPWR VGND sg13g2_decap_4
X_16658_ net1030 VPWR _07835_ VGND net527 net746 sg13g2_o21ai_1
XFILLER_23_928 VPWR VGND sg13g2_fill_1
XFILLER_34_265 VPWR VGND sg13g2_decap_8
XFILLER_16_980 VPWR VGND sg13g2_fill_1
X_15609_ _06863_ _06862_ _06824_ VPWR VGND sg13g2_nand2b_1
XFILLER_34_298 VPWR VGND sg13g2_fill_1
X_19377_ _10437_ VPWR _10441_ VGND _10438_ _10439_ sg13g2_o21ai_1
X_16589_ VGND VPWR u_LMS.w\[3\]\[16\] _07773_ _07783_ _07774_ sg13g2_a21oi_1
X_18328_ net682 net164 net127 _09438_ VPWR VGND net680 sg13g2_nand4_1
XFILLER_33_1027 VPWR VGND sg13g2_fill_1
XFILLER_30_460 VPWR VGND sg13g2_fill_1
XFILLER_120_1008 VPWR VGND sg13g2_fill_1
X_18259_ _09369_ net672 net200 VPWR VGND sg13g2_nand2_1
XFILLER_120_1019 VPWR VGND sg13g2_decap_8
X_21270_ _01881_ VPWR _01887_ VGND net2214 _01886_ sg13g2_o21ai_1
XFILLER_116_532 VPWR VGND sg13g2_fill_2
X_20221_ _00862_ _00861_ _00884_ VPWR VGND sg13g2_xor2_1
X_20152_ _11193_ _11190_ _11192_ VPWR VGND sg13g2_nand2_1
Xrebuffer1644 net1644 net1643 VPWR VGND sg13g2_buf_1
Xrebuffer1655 _07928_ net1654 VPWR VGND sg13g2_buf_8
XFILLER_98_972 VPWR VGND sg13g2_decap_4
XFILLER_131_568 VPWR VGND sg13g2_decap_8
XFILLER_100_900 VPWR VGND sg13g2_decap_8
X_20083_ _03240_ net142 _11124_ VPWR VGND sg13g2_nor2_1
Xrebuffer1666 _07926_ net1665 VPWR VGND sg13g2_buf_1
XFILLER_58_847 VPWR VGND sg13g2_decap_8
XFILLER_84_110 VPWR VGND sg13g2_fill_1
XFILLER_69_184 VPWR VGND sg13g2_fill_1
XFILLER_58_858 VPWR VGND sg13g2_fill_2
X_23079__1088 VPWR VGND net1087 sg13g2_tiehi
XFILLER_73_839 VPWR VGND sg13g2_fill_2
XFILLER_72_327 VPWR VGND sg13g2_decap_4
XFILLER_27_69 VPWR VGND sg13g2_decap_8
X_23773_ net995 VGND VPWR _00020_ spi_wr_en clknet_3_6__leaf_spi_sclk sg13g2_dfrbpq_1
XFILLER_84_198 VPWR VGND sg13g2_fill_2
X_20985_ _01625_ _03310_ _01579_ VPWR VGND sg13g2_nand2_1
XFILLER_129_1000 VPWR VGND sg13g2_decap_8
XFILLER_53_541 VPWR VGND sg13g2_decap_8
X_22724_ u_debug_unit.mon_w0_sync\[6\] net336 _03080_ VPWR VGND sg13g2_nor2_1
XFILLER_81_883 VPWR VGND sg13g2_decap_4
XFILLER_41_714 VPWR VGND sg13g2_fill_2
XFILLER_26_788 VPWR VGND sg13g2_decap_8
XFILLER_25_265 VPWR VGND sg13g2_fill_1
XFILLER_26_799 VPWR VGND sg13g2_fill_2
XFILLER_53_596 VPWR VGND sg13g2_decap_8
X_22655_ net430 net287 _03065_ VPWR VGND sg13g2_and2_1
XFILLER_43_57 VPWR VGND sg13g2_fill_1
X_21606_ _02223_ _02222_ _02166_ VPWR VGND sg13g2_nand2b_1
X_22586_ VGND VPWR _03055_ _03053_ _03213_ sg13g2_or2_1
XFILLER_40_279 VPWR VGND sg13g2_decap_8
X_21537_ _02154_ _02153_ _02140_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_819 VPWR VGND sg13g2_decap_4
X_12270_ _03651_ _03647_ _03648_ VPWR VGND sg13g2_xnor2_1
X_21468_ _02085_ net602 net244 VPWR VGND sg13g2_nand2_1
X_23207_ net1468 VGND VPWR _00269_ u_FIR.w\[7\]\[3\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
X_20419_ _01080_ _01036_ _01038_ VPWR VGND sg13g2_xnor2_1
X_21399_ _02016_ net211 net599 net244 net597 VPWR VGND sg13g2_a22oi_1
XFILLER_122_513 VPWR VGND sg13g2_decap_8
XFILLER_107_598 VPWR VGND sg13g2_decap_4
X_23138_ net1582 VGND VPWR _00200_ u_FIR.sum\[8\]\[10\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
XFILLER_122_524 VPWR VGND sg13g2_fill_2
XFILLER_108_83 VPWR VGND sg13g2_fill_1
XFILLER_68_32 VPWR VGND sg13g2_decap_8
XFILLER_89_950 VPWR VGND sg13g2_decap_8
XFILLER_122_546 VPWR VGND sg13g2_fill_2
XFILLER_68_54 VPWR VGND sg13g2_fill_1
X_23453__1573 VPWR VGND net1572 sg13g2_tiehi
XFILLER_89_961 VPWR VGND sg13g2_fill_2
X_23069_ net1102 VGND VPWR _00131_ u_FIR.sum\[4\]\[12\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
X_15960_ _07126_ _07191_ _07203_ VPWR VGND sg13g2_nor2_1
XFILLER_103_760 VPWR VGND sg13g2_decap_8
XFILLER_49_825 VPWR VGND sg13g2_fill_2
XFILLER_0_375 VPWR VGND sg13g2_decap_8
X_14911_ _06179_ _06194_ _06195_ VPWR VGND sg13g2_nor2b_1
XFILLER_88_482 VPWR VGND sg13g2_decap_8
X_15891_ _07120_ _07137_ _07138_ VPWR VGND sg13g2_nor2b_1
XFILLER_130_590 VPWR VGND sg13g2_decap_8
XFILLER_76_666 VPWR VGND sg13g2_decap_8
X_23486__1463 VPWR VGND net1462 sg13g2_tiehi
X_17630_ _08732_ _08762_ _08763_ VPWR VGND sg13g2_nor2b_1
X_14842_ _06128_ _06091_ _06127_ VPWR VGND sg13g2_nand2_1
XFILLER_63_305 VPWR VGND sg13g2_fill_1
XFILLER_36_519 VPWR VGND sg13g2_decap_8
XFILLER_76_699 VPWR VGND sg13g2_decap_8
XFILLER_1_1003 VPWR VGND sg13g2_decap_8
X_17561_ _08694_ _08626_ _08628_ VPWR VGND sg13g2_xnor2_1
X_14773_ _06059_ _06060_ _06061_ VPWR VGND sg13g2_and2_1
X_11985_ _03402_ spi_addr\[0\] _03401_ VPWR VGND sg13g2_nand2_1
X_19300_ _10361_ VPWR _10364_ VGND _03246_ net96 sg13g2_o21ai_1
X_16512_ net971 VPWR _07726_ VGND net478 net794 sg13g2_o21ai_1
XFILLER_95_1054 VPWR VGND sg13g2_decap_8
X_13724_ _05051_ _05050_ _05046_ VPWR VGND sg13g2_nand2b_1
X_17492_ _08603_ net121 _08600_ _08625_ VPWR VGND sg13g2_nand3_1
XFILLER_71_360 VPWR VGND sg13g2_decap_8
XFILLER_71_371 VPWR VGND sg13g2_decap_8
X_19231_ net30 VPWR _10308_ VGND net28 _10307_ sg13g2_o21ai_1
X_16443_ _07672_ _07648_ _07670_ VPWR VGND sg13g2_xnor2_1
X_13655_ _04945_ u_FIR.w\[5\]\[6\] _04943_ _04984_ VPWR VGND sg13g2_a21o_1
XFILLER_31_246 VPWR VGND sg13g2_decap_8
XFILLER_31_257 VPWR VGND sg13g2_fill_2
X_19162_ _10247_ _10248_ _10244_ _10249_ VPWR VGND sg13g2_nand3_1
X_12606_ _03974_ _03957_ _03973_ VPWR VGND sg13g2_xnor2_1
XFILLER_13_972 VPWR VGND sg13g2_decap_4
X_16374_ _07607_ _07580_ _07605_ VPWR VGND sg13g2_xnor2_1
X_13586_ _04917_ _04887_ _04916_ VPWR VGND sg13g2_nand2b_1
XFILLER_13_994 VPWR VGND sg13g2_fill_2
X_18113_ _09223_ _09222_ _09221_ VPWR VGND sg13g2_nand2b_1
X_15325_ _06585_ _06592_ _06593_ VPWR VGND sg13g2_nor2b_1
X_12537_ net542 VPWR _03911_ VGND _03909_ _03910_ sg13g2_o21ai_1
X_19093_ _03334_ _10179_ _10180_ VPWR VGND sg13g2_nor2_1
XFILLER_118_819 VPWR VGND sg13g2_decap_8
X_18044_ net57 _09159_ _09020_ _09160_ VPWR VGND sg13g2_nand3_1
X_15256_ _06524_ _06491_ _06526_ VPWR VGND sg13g2_xor2_1
X_12468_ _03844_ _03828_ _03843_ VPWR VGND sg13g2_nand2_1
X_14207_ _05514_ _05486_ _05516_ VPWR VGND sg13g2_xor2_1
X_15187_ net861 _06457_ net775 _06458_ VPWR VGND sg13g2_nand3_1
XFILLER_125_340 VPWR VGND sg13g2_decap_8
X_12399_ _03777_ _03756_ _03776_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_351 VPWR VGND sg13g2_fill_1
XFILLER_113_513 VPWR VGND sg13g2_fill_2
X_14138_ _05422_ VPWR _05448_ VGND _05374_ _05414_ sg13g2_o21ai_1
X_19995_ _11036_ net629 net113 VPWR VGND sg13g2_nand2_1
XFILLER_98_235 VPWR VGND sg13g2_decap_8
XFILLER_113_535 VPWR VGND sg13g2_fill_1
X_23178__1520 VPWR VGND net1519 sg13g2_tiehi
X_23206__1471 VPWR VGND net1470 sg13g2_tiehi
X_18946_ _10031_ _10032_ _10033_ VPWR VGND sg13g2_nor2_1
X_14069_ _05379_ _05345_ _05381_ VPWR VGND sg13g2_xor2_1
XFILLER_86_419 VPWR VGND sg13g2_decap_8
XFILLER_79_482 VPWR VGND sg13g2_fill_1
X_18877_ _09964_ _09798_ _09933_ VPWR VGND sg13g2_xnor2_1
X_17828_ _08761_ _08756_ _08961_ VPWR VGND sg13g2_xor2_1
XFILLER_82_614 VPWR VGND sg13g2_fill_1
XFILLER_27_519 VPWR VGND sg13g2_decap_4
Xclkbuf_3_1__f_spi_sclk clknet_3_1__leaf_spi_sclk clknet_0_spi_sclk VPWR VGND sg13g2_buf_16
XFILLER_81_113 VPWR VGND sg13g2_fill_2
X_17759_ _08869_ _08891_ _08892_ VPWR VGND sg13g2_and2_1
XFILLER_82_658 VPWR VGND sg13g2_fill_1
XFILLER_47_390 VPWR VGND sg13g2_decap_8
X_23075__1094 VPWR VGND net1093 sg13g2_tiehi
XFILLER_81_157 VPWR VGND sg13g2_decap_8
X_20770_ _01368_ _01409_ _01410_ VPWR VGND sg13g2_nor2_1
XFILLER_62_360 VPWR VGND sg13g2_decap_4
Xfanout17 _01658_ net17 VPWR VGND sg13g2_buf_1
X_19429_ _10457_ _10456_ _10493_ VPWR VGND sg13g2_xor2_1
Xfanout28 _10267_ net28 VPWR VGND sg13g2_buf_2
Xfanout39 _09097_ net39 VPWR VGND sg13g2_buf_1
XFILLER_22_235 VPWR VGND sg13g2_decap_4
X_22440_ VGND VPWR net444 _03249_ _00528_ _02969_ sg13g2_a21oi_1
XFILLER_22_279 VPWR VGND sg13g2_decap_8
XFILLER_50_599 VPWR VGND sg13g2_decap_4
XFILLER_13_38 VPWR VGND sg13g2_decap_8
X_22371_ net969 VPWR _02935_ VGND net456 u_LMS.x_r\[0\]\[7\] sg13g2_o21ai_1
XFILLER_129_49 VPWR VGND sg13g2_decap_8
X_21322_ _01939_ net595 net208 VPWR VGND sg13g2_nand2_1
X_21253_ _01870_ _01868_ _01869_ VPWR VGND sg13g2_xnor2_1
XFILLER_117_874 VPWR VGND sg13g2_fill_2
XFILLER_117_885 VPWR VGND sg13g2_fill_1
XFILLER_116_362 VPWR VGND sg13g2_fill_2
Xrebuffer2120 _10026_ net2119 VPWR VGND sg13g2_buf_1
XFILLER_89_202 VPWR VGND sg13g2_fill_2
X_20204_ _00866_ _00841_ _00867_ VPWR VGND sg13g2_xor2_1
Xrebuffer2131 _00983_ net2130 VPWR VGND sg13g2_buf_2
Xrebuffer2142 _02221_ net2141 VPWR VGND sg13g2_buf_1
X_21184_ _01801_ _01793_ _01799_ VPWR VGND sg13g2_xnor2_1
Xrebuffer2153 _02055_ net2152 VPWR VGND sg13g2_buf_1
XFILLER_89_235 VPWR VGND sg13g2_decap_8
Xfanout900 net901 net900 VPWR VGND sg13g2_buf_1
Xrebuffer2164 _02127_ net2163 VPWR VGND sg13g2_buf_1
Xfanout911 u_FIR.x_reg\[0\] net911 VPWR VGND sg13g2_buf_1
Xrebuffer2175 net2175 net2174 VPWR VGND sg13g2_buf_1
X_20135_ _11176_ net89 net637 net113 net634 VPWR VGND sg13g2_a22oi_1
Xfanout922 net928 net922 VPWR VGND sg13g2_buf_1
Xrebuffer2197 net2197 net2196 VPWR VGND sg13g2_buf_1
XFILLER_77_419 VPWR VGND sg13g2_decap_4
Xfanout933 net935 net933 VPWR VGND sg13g2_buf_1
XFILLER_58_600 VPWR VGND sg13g2_decap_4
Xfanout944 net945 net944 VPWR VGND sg13g2_buf_1
Xfanout955 net956 net955 VPWR VGND sg13g2_buf_1
Xfanout966 net967 net966 VPWR VGND sg13g2_buf_1
X_20066_ _11099_ VPWR _11107_ VGND _11105_ _11106_ sg13g2_o21ai_1
Xfanout977 net978 net977 VPWR VGND sg13g2_buf_1
XFILLER_57_121 VPWR VGND sg13g2_decap_8
Xfanout988 net989 net988 VPWR VGND sg13g2_buf_1
XFILLER_58_655 VPWR VGND sg13g2_fill_1
Xfanout999 net1000 net999 VPWR VGND sg13g2_buf_1
XFILLER_86_975 VPWR VGND sg13g2_decap_8
XFILLER_79_1005 VPWR VGND sg13g2_decap_4
XFILLER_100_774 VPWR VGND sg13g2_decap_4
XFILLER_46_828 VPWR VGND sg13g2_fill_1
XFILLER_85_474 VPWR VGND sg13g2_decap_4
XFILLER_45_327 VPWR VGND sg13g2_decap_8
XFILLER_57_198 VPWR VGND sg13g2_fill_1
XFILLER_54_23 VPWR VGND sg13g2_fill_2
XFILLER_26_541 VPWR VGND sg13g2_decap_4
X_23756_ net1623 VGND VPWR _00818_ u_LMS.x\[7\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
X_20968_ _01608_ _01607_ _01606_ VPWR VGND sg13g2_nand2b_1
XFILLER_14_725 VPWR VGND sg13g2_fill_2
X_22707_ VGND VPWR _07933_ net332 _00692_ _03072_ sg13g2_a21oi_1
XFILLER_54_89 VPWR VGND sg13g2_fill_2
X_23687_ net1020 VGND VPWR _00749_ u_debug_unit.mon_w7_sync\[4\] clknet_leaf_35_clkA
+ sg13g2_dfrbpq_1
XFILLER_13_235 VPWR VGND sg13g2_fill_2
X_20899_ _01536_ _01538_ _01539_ VPWR VGND sg13g2_and2_1
XFILLER_14_769 VPWR VGND sg13g2_decap_4
XFILLER_13_257 VPWR VGND sg13g2_fill_2
X_13440_ net547 VPWR _04781_ VGND _04779_ _04780_ sg13g2_o21ai_1
XFILLER_55_1060 VPWR VGND sg13g2_fill_1
X_22638_ coeff_force_packed\[14\] net472 _03063_ _00632_ VPWR VGND sg13g2_mux2_1
XFILLER_110_84 VPWR VGND sg13g2_decap_8
XFILLER_10_931 VPWR VGND sg13g2_decap_4
X_13371_ _04714_ u_FIR.w\[6\]\[6\] net410 VPWR VGND sg13g2_nand2_1
X_22569_ u_LMS.count\[24\] _03042_ _03044_ VPWR VGND sg13g2_and2_1
XFILLER_127_616 VPWR VGND sg13g2_fill_2
XFILLER_70_88 VPWR VGND sg13g2_fill_1
X_15110_ _06383_ net781 net833 VPWR VGND sg13g2_nand2_1
X_12322_ _03702_ net718 _03701_ VPWR VGND sg13g2_xnor2_1
X_16090_ _03375_ net900 _07330_ VPWR VGND sg13g2_nor2_1
XFILLER_127_638 VPWR VGND sg13g2_fill_2
X_15041_ _06316_ _06315_ _06311_ VPWR VGND sg13g2_nand2b_1
X_12253_ _03635_ _03633_ _03634_ VPWR VGND sg13g2_nand2b_1
XFILLER_119_71 VPWR VGND sg13g2_decap_8
XFILLER_79_31 VPWR VGND sg13g2_decap_4
XFILLER_5_489 VPWR VGND sg13g2_fill_2
X_12184_ net945 u_spi_slave.bit_cnt\[0\] _00015_ VPWR VGND sg13g2_nor2_1
XFILLER_123_844 VPWR VGND sg13g2_decap_4
X_18800_ _09887_ _09884_ _09885_ VPWR VGND sg13g2_xnor2_1
XFILLER_123_866 VPWR VGND sg13g2_fill_2
X_19780_ net66 u_LMS.w\[4\]\[22\] _10844_ VPWR VGND sg13g2_xor2_1
X_16992_ _08140_ VPWR _08148_ VGND _08146_ _08147_ sg13g2_o21ai_1
XFILLER_95_205 VPWR VGND sg13g2_decap_4
XFILLER_123_899 VPWR VGND sg13g2_decap_4
XFILLER_0_161 VPWR VGND sg13g2_decap_8
X_18731_ _09818_ _09810_ _09816_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_931 VPWR VGND sg13g2_fill_2
X_15943_ _07187_ _07186_ net273 VPWR VGND sg13g2_nand2b_1
XFILLER_23_1026 VPWR VGND sg13g2_decap_4
X_18662_ net356 VPWR _09752_ VGND u_LMS.w\[2\]\[9\] net372 sg13g2_o21ai_1
XFILLER_48_154 VPWR VGND sg13g2_fill_1
X_15874_ _07097_ VPWR _07121_ VGND net275 _07099_ sg13g2_o21ai_1
XFILLER_23_1059 VPWR VGND sg13g2_fill_2
X_17613_ _08746_ _08741_ _08744_ VPWR VGND sg13g2_xnor2_1
X_14825_ _06112_ _06087_ _06111_ VPWR VGND sg13g2_xnor2_1
X_18593_ _09697_ net33 net36 _09698_ VPWR VGND sg13g2_a21o_1
X_17544_ _08673_ VPWR _08677_ VGND _08674_ _08675_ sg13g2_o21ai_1
X_14756_ net505 VPWR _06045_ VGND _06043_ _06044_ sg13g2_o21ai_1
XFILLER_32_500 VPWR VGND sg13g2_decap_8
X_11968_ u_spi_slave.tx_cnt\[1\] u_spi_slave.tx_cnt\[0\] u_spi_slave.tx_cnt\[2\] _03388_
+ VPWR VGND sg13g2_nand3_1
XFILLER_91_499 VPWR VGND sg13g2_fill_2
X_13707_ _05035_ _05034_ _05001_ VPWR VGND sg13g2_nand2b_1
XFILLER_32_533 VPWR VGND sg13g2_decap_8
X_17475_ _08607_ _08597_ _08608_ VPWR VGND sg13g2_xor2_1
XFILLER_60_853 VPWR VGND sg13g2_fill_1
X_14687_ _05977_ _05976_ _05972_ VPWR VGND sg13g2_nand2b_1
X_11899_ VPWR _03320_ u_LMS.w\[5\]\[18\] VGND sg13g2_inv_1
X_19214_ VGND VPWR u_LMS.w\[3\]\[18\] net1649 _10294_ _10243_ sg13g2_a21oi_1
XFILLER_60_875 VPWR VGND sg13g2_decap_8
X_16426_ _07654_ _07655_ _07656_ VPWR VGND sg13g2_nor2b_1
XFILLER_60_886 VPWR VGND sg13g2_fill_1
X_13638_ _04967_ net750 net864 VPWR VGND sg13g2_nand2_1
XFILLER_13_780 VPWR VGND sg13g2_fill_2
X_19145_ VGND VPWR _10229_ _10230_ _10232_ _10184_ sg13g2_a21oi_1
X_16357_ _07585_ _07587_ _07590_ VPWR VGND sg13g2_nor2_1
X_13569_ _04900_ _04894_ _04898_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_1019 VPWR VGND sg13g2_decap_8
XFILLER_117_104 VPWR VGND sg13g2_fill_1
X_15308_ _06576_ u_FIR.w\[2\]\[6\] net835 VPWR VGND sg13g2_nand2b_1
XFILLER_8_261 VPWR VGND sg13g2_fill_1
X_19076_ _09808_ _09828_ _09837_ _10163_ VPWR VGND sg13g2_or3_1
X_16288_ _07523_ u_FIR.w\[0\]\[6\] net834 VPWR VGND sg13g2_nand2b_1
XFILLER_117_137 VPWR VGND sg13g2_decap_8
X_18027_ net368 _09096_ _09147_ VPWR VGND sg13g2_nor2_1
X_15239_ _06508_ _06464_ _06509_ VPWR VGND sg13g2_xor2_1
XFILLER_114_800 VPWR VGND sg13g2_fill_2
XFILLER_99_511 VPWR VGND sg13g2_decap_8
XFILLER_126_693 VPWR VGND sg13g2_fill_1
Xfanout207 net216 net207 VPWR VGND sg13g2_buf_1
XFILLER_99_566 VPWR VGND sg13g2_decap_8
XFILLER_119_1054 VPWR VGND sg13g2_decap_8
Xfanout218 net220 net218 VPWR VGND sg13g2_buf_1
XFILLER_101_505 VPWR VGND sg13g2_decap_8
X_19978_ _11004_ _11018_ _11019_ VPWR VGND sg13g2_and2_1
Xfanout229 net233 net229 VPWR VGND sg13g2_buf_1
XFILLER_101_549 VPWR VGND sg13g2_decap_4
X_18929_ _10015_ _09984_ _10016_ VPWR VGND sg13g2_xor2_1
X_21940_ _02532_ _02528_ _02534_ VPWR VGND _02531_ sg13g2_nand3b_1
XFILLER_68_986 VPWR VGND sg13g2_fill_2
XFILLER_67_496 VPWR VGND sg13g2_fill_1
X_21871_ _02465_ _02428_ _02430_ VPWR VGND sg13g2_xnor2_1
X_23723__1359 VPWR VGND net1358 sg13g2_tiehi
XFILLER_83_978 VPWR VGND sg13g2_decap_4
XFILLER_131_39 VPWR VGND sg13g2_decap_8
X_23610_ net965 VGND VPWR _00672_ coeff_force_packed\[49\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
X_20822_ _01439_ _01461_ _01462_ VPWR VGND sg13g2_nor2_1
XFILLER_42_308 VPWR VGND sg13g2_decap_4
XFILLER_39_1011 VPWR VGND sg13g2_decap_8
XFILLER_78_1060 VPWR VGND sg13g2_fill_1
XFILLER_23_500 VPWR VGND sg13g2_decap_8
XFILLER_36_894 VPWR VGND sg13g2_fill_1
X_23541_ net1013 VGND VPWR _00603_ debug_load_bus\[3\] clknet_leaf_37_clkA sg13g2_dfrbpq_1
X_20753_ _01392_ _01387_ _01393_ VPWR VGND sg13g2_xor2_1
XFILLER_24_37 VPWR VGND sg13g2_decap_8
XFILLER_126_1014 VPWR VGND sg13g2_decap_8
X_23472_ net1511 VGND VPWR _00534_ u_LMS.x_r\[5\]\[7\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
XFILLER_11_728 VPWR VGND sg13g2_fill_2
X_20684_ _03233_ _03234_ _01324_ VPWR VGND sg13g2_nor2_1
X_22423_ net949 VPWR _02961_ VGND net436 net649 sg13g2_o21ai_1
XFILLER_10_249 VPWR VGND sg13g2_fill_2
XFILLER_108_115 VPWR VGND sg13g2_fill_2
XFILLER_109_649 VPWR VGND sg13g2_decap_8
X_22354_ VGND VPWR net48 _02925_ _02926_ _02897_ sg13g2_a21oi_1
XFILLER_108_137 VPWR VGND sg13g2_fill_1
X_21305_ _01922_ _01920_ _01921_ VPWR VGND sg13g2_nand2_1
X_22285_ net925 _02872_ _00470_ VPWR VGND sg13g2_nor2_1
XFILLER_117_671 VPWR VGND sg13g2_fill_1
X_21236_ _01853_ _01851_ _01852_ VPWR VGND sg13g2_nand2_1
XFILLER_132_630 VPWR VGND sg13g2_decap_8
XFILLER_46_1037 VPWR VGND sg13g2_fill_1
X_21167_ _01784_ _01783_ _01782_ VPWR VGND sg13g2_nand2b_1
XFILLER_46_1059 VPWR VGND sg13g2_fill_2
Xfanout730 u_FIR.w\[7\]\[5\] net730 VPWR VGND sg13g2_buf_1
Xfanout741 u_FIR.w\[6\]\[4\] net741 VPWR VGND sg13g2_buf_1
XFILLER_131_173 VPWR VGND sg13g2_fill_1
X_20118_ _11159_ net630 net230 VPWR VGND sg13g2_nand2_1
Xfanout752 u_FIR.w\[5\]\[2\] net752 VPWR VGND sg13g2_buf_1
X_21098_ net361 VPWR _01722_ VGND u_LMS.w\[6\]\[5\] net378 sg13g2_o21ai_1
Xfanout763 u_FIR.w\[4\]\[1\] net763 VPWR VGND sg13g2_buf_1
Xfanout774 u_FIR.w\[3\]\[0\] net774 VPWR VGND sg13g2_buf_1
XFILLER_86_750 VPWR VGND sg13g2_decap_8
XFILLER_58_441 VPWR VGND sg13g2_decap_8
Xfanout785 u_FIR.w\[1\]\[5\] net785 VPWR VGND sg13g2_buf_1
Xfanout796 u_FIR.w\[0\]\[3\] net796 VPWR VGND sg13g2_buf_1
X_20049_ _11087_ _11085_ _11088_ _11090_ VPWR VGND sg13g2_a21o_1
X_12940_ _04299_ u_FIR.sum\[0\]\[12\] net408 VPWR VGND sg13g2_xnor2_1
XFILLER_46_614 VPWR VGND sg13g2_decap_4
XFILLER_18_316 VPWR VGND sg13g2_fill_2
XFILLER_46_647 VPWR VGND sg13g2_decap_4
XFILLER_65_55 VPWR VGND sg13g2_fill_1
X_12871_ _04232_ u_FIR.sum\[0\]\[10\] net407 VPWR VGND sg13g2_nand2_1
XFILLER_65_66 VPWR VGND sg13g2_fill_1
XFILLER_65_77 VPWR VGND sg13g2_fill_2
X_14610_ VGND VPWR _05902_ _05900_ _05862_ sg13g2_or2_1
X_11822_ VPWR _03243_ net639 VGND sg13g2_inv_1
X_15590_ _06845_ _06844_ _06806_ VPWR VGND sg13g2_nand2b_1
XFILLER_121_50 VPWR VGND sg13g2_fill_1
XFILLER_26_371 VPWR VGND sg13g2_fill_2
X_14541_ _05835_ _05826_ _05833_ VPWR VGND sg13g2_xnor2_1
XFILLER_81_21 VPWR VGND sg13g2_decap_4
XFILLER_42_842 VPWR VGND sg13g2_fill_1
X_23739_ net988 VGND VPWR _00801_ spi_addr\[5\] clknet_3_1__leaf_spi_sclk sg13g2_dfrbpq_1
XFILLER_81_32 VPWR VGND sg13g2_fill_1
X_17260_ _08416_ u_LMS.w\[0\]\[11\] _08415_ VPWR VGND sg13g2_nand2_1
X_14472_ _05771_ net278 _05770_ VPWR VGND sg13g2_xnor2_1
X_23033__1157 VPWR VGND net1156 sg13g2_tiehi
X_16211_ _03375_ net860 _07448_ VPWR VGND sg13g2_nor2_1
X_13423_ VGND VPWR net547 _04763_ _00094_ _04764_ sg13g2_a21oi_1
X_17191_ VGND VPWR _08347_ _08345_ _08302_ sg13g2_or2_1
XFILLER_127_402 VPWR VGND sg13g2_decap_8
X_16142_ _07375_ _07380_ _07381_ VPWR VGND sg13g2_nor2b_1
X_13354_ _04698_ _04690_ _04696_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_446 VPWR VGND sg13g2_decap_8
X_12305_ _03683_ _03680_ _03685_ VPWR VGND sg13g2_xor2_1
X_23048__1135 VPWR VGND net1134 sg13g2_tiehi
XFILLER_6_765 VPWR VGND sg13g2_decap_8
X_16073_ _07314_ _07313_ _07250_ VPWR VGND sg13g2_nand2b_1
X_13285_ VGND VPWR _04589_ _04592_ _04631_ _04629_ sg13g2_a21oi_1
X_19901_ _10942_ net622 net161 VPWR VGND sg13g2_nand2_1
X_15024_ _06300_ _06294_ _06298_ VPWR VGND sg13g2_xnor2_1
X_12236_ _03619_ _03602_ _03617_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_297 VPWR VGND sg13g2_decap_8
X_19832_ net26 VPWR _10888_ VGND net25 _10887_ sg13g2_o21ai_1
X_12167_ net943 net323 _03575_ VPWR VGND sg13g2_nor2_1
XFILLER_69_728 VPWR VGND sg13g2_fill_1
XFILLER_111_825 VPWR VGND sg13g2_fill_1
XFILLER_96_514 VPWR VGND sg13g2_decap_8
XFILLER_2_971 VPWR VGND sg13g2_decap_8
XFILLER_110_302 VPWR VGND sg13g2_fill_1
XFILLER_110_324 VPWR VGND sg13g2_decap_8
X_19763_ _10827_ _10395_ _10826_ VPWR VGND sg13g2_xnor2_1
X_16975_ VGND VPWR _08128_ _08130_ _08131_ _08100_ sg13g2_a21oi_1
X_12098_ _03510_ _03418_ u_debug_unit.mon_w2_sync\[3\] _03405_ u_debug_unit.mon_w5_sync\[3\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_7_1031 VPWR VGND sg13g2_decap_8
XFILLER_122_195 VPWR VGND sg13g2_fill_1
X_18714_ _09779_ net119 _09776_ _09801_ VPWR VGND sg13g2_nand3_1
X_15926_ _07126_ _07170_ _07171_ VPWR VGND sg13g2_nor2_1
XFILLER_49_463 VPWR VGND sg13g2_decap_4
X_19694_ _03322_ _10757_ _10758_ VPWR VGND sg13g2_nor2_1
XFILLER_65_923 VPWR VGND sg13g2_fill_1
XFILLER_37_614 VPWR VGND sg13g2_fill_1
XFILLER_37_636 VPWR VGND sg13g2_decap_8
XFILLER_64_422 VPWR VGND sg13g2_decap_8
X_18645_ VGND VPWR _09681_ _09738_ _09739_ _09728_ sg13g2_a21oi_1
X_15857_ _07105_ _07104_ _07070_ VPWR VGND sg13g2_nand2b_1
XFILLER_65_989 VPWR VGND sg13g2_fill_1
X_14808_ _06095_ _06092_ _06093_ VPWR VGND sg13g2_nand2_1
XFILLER_91_263 VPWR VGND sg13g2_decap_8
XFILLER_36_168 VPWR VGND sg13g2_fill_2
X_18576_ _09685_ _09646_ _09647_ VPWR VGND sg13g2_xnor2_1
XFILLER_52_628 VPWR VGND sg13g2_fill_1
X_15788_ _07038_ u_FIR.sum\[6\]\[10\] net392 VPWR VGND sg13g2_xnor2_1
XFILLER_80_948 VPWR VGND sg13g2_fill_1
XFILLER_64_499 VPWR VGND sg13g2_decap_8
X_17527_ _08660_ _08608_ _08659_ VPWR VGND sg13g2_nand2_1
XFILLER_33_842 VPWR VGND sg13g2_decap_8
X_14739_ _06028_ _06010_ _06027_ VPWR VGND sg13g2_xnor2_1
X_23355__1247 VPWR VGND net1246 sg13g2_tiehi
XFILLER_33_886 VPWR VGND sg13g2_decap_8
X_17458_ _08590_ _08589_ _08591_ VPWR VGND sg13g2_xor2_1
X_16409_ _07615_ VPWR _07640_ VGND net270 _07613_ sg13g2_o21ai_1
X_17389_ _08536_ _08476_ _08531_ VPWR VGND sg13g2_nand2_1
XFILLER_72_0 VPWR VGND sg13g2_decap_4
X_19128_ _10215_ u_LMS.w\[3\]\[7\] _10193_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_947 VPWR VGND sg13g2_fill_1
XFILLER_119_969 VPWR VGND sg13g2_fill_1
X_23396__1161 VPWR VGND net1160 sg13g2_tiehi
XFILLER_118_457 VPWR VGND sg13g2_fill_1
X_19059_ _09909_ _09910_ _10146_ VPWR VGND sg13g2_nor2b_1
XFILLER_118_479 VPWR VGND sg13g2_decap_4
XFILLER_10_28 VPWR VGND sg13g2_decap_4
X_22070_ _02663_ _02657_ _02664_ VPWR VGND sg13g2_xor2_1
XFILLER_126_28 VPWR VGND sg13g2_decap_8
X_21021_ VGND VPWR _01661_ _01659_ _01656_ sg13g2_or2_1
XFILLER_87_525 VPWR VGND sg13g2_fill_2
XFILLER_114_696 VPWR VGND sg13g2_fill_1
XFILLER_102_858 VPWR VGND sg13g2_fill_1
XFILLER_59_238 VPWR VGND sg13g2_fill_1
XFILLER_101_346 VPWR VGND sg13g2_fill_1
XFILLER_102_869 VPWR VGND sg13g2_decap_8
XFILLER_68_772 VPWR VGND sg13g2_decap_4
XFILLER_74_219 VPWR VGND sg13g2_decap_4
XFILLER_55_422 VPWR VGND sg13g2_fill_2
XFILLER_27_113 VPWR VGND sg13g2_fill_1
XFILLER_56_956 VPWR VGND sg13g2_fill_1
X_21923_ _02517_ _02515_ _02516_ VPWR VGND sg13g2_nand2_1
XFILLER_27_146 VPWR VGND sg13g2_fill_1
XFILLER_56_989 VPWR VGND sg13g2_decap_4
XFILLER_43_606 VPWR VGND sg13g2_fill_2
XFILLER_83_786 VPWR VGND sg13g2_decap_8
X_21854_ _02448_ _02442_ _02443_ VPWR VGND sg13g2_xnor2_1
X_20805_ _01438_ _01444_ _01445_ VPWR VGND sg13g2_nor2_1
X_21785_ _02379_ _02378_ _02377_ VPWR VGND sg13g2_nand2b_1
XFILLER_24_886 VPWR VGND sg13g2_decap_8
X_20736_ _01376_ _01375_ _01371_ VPWR VGND sg13g2_nand2b_1
X_23524_ net1321 VGND VPWR _00586_ u_LMS.count\[27\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
X_23455_ net1566 VGND VPWR _00517_ u_LMS.x_r\[3\]\[6\] clknet_leaf_65_clkA sg13g2_dfrbpq_1
X_20667_ _01304_ VPWR _01307_ VGND _03228_ net197 sg13g2_o21ai_1
X_22406_ VGND VPWR net434 _03266_ _00511_ _02952_ sg13g2_a21oi_1
X_23386_ net1190 VGND VPWR _00448_ u_LMS.w\[7\]\[19\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
X_20598_ net426 net227 _01238_ VPWR VGND sg13g2_nor2_1
X_22337_ _02913_ _02797_ _02798_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_416 VPWR VGND sg13g2_fill_1
XFILLER_118_991 VPWR VGND sg13g2_decap_8
X_13070_ _04421_ _04415_ _04419_ VPWR VGND sg13g2_xnor2_1
X_22268_ net8 VPWR _02859_ VGND net7 _02858_ sg13g2_o21ai_1
X_12021_ spi_addr\[5\] spi_addr\[4\] spi_addr\[6\] _03406_ _03438_ VPWR VGND sg13g2_nor4_1
X_21219_ _01832_ VPWR _01836_ VGND _01833_ _01834_ sg13g2_o21ai_1
X_23044__1141 VPWR VGND net1140 sg13g2_tiehi
X_22199_ _02791_ _02792_ _02793_ VPWR VGND sg13g2_nor2_1
XFILLER_104_162 VPWR VGND sg13g2_fill_1
XFILLER_2_289 VPWR VGND sg13g2_decap_8
XFILLER_120_622 VPWR VGND sg13g2_fill_2
Xfanout560 net569 net560 VPWR VGND sg13g2_buf_1
Xfanout571 u_LMS.x_r\[8\]\[7\] net571 VPWR VGND sg13g2_buf_1
XFILLER_65_208 VPWR VGND sg13g2_fill_1
Xfanout582 net583 net582 VPWR VGND sg13g2_buf_1
X_16760_ _07915_ net915 _07916_ VPWR VGND sg13g2_and2_2
XFILLER_59_772 VPWR VGND sg13g2_fill_1
Xfanout593 u_LMS.x_r\[7\]\[6\] net593 VPWR VGND sg13g2_buf_1
X_13972_ net539 VPWR _05290_ VGND _05282_ _05289_ sg13g2_o21ai_1
XFILLER_76_76 VPWR VGND sg13g2_fill_1
XFILLER_101_880 VPWR VGND sg13g2_fill_1
XFILLER_58_271 VPWR VGND sg13g2_fill_2
X_15711_ _06963_ _06959_ _06962_ VPWR VGND sg13g2_xnor2_1
X_12923_ VGND VPWR _04250_ _04274_ _04282_ _04273_ sg13g2_a21oi_1
X_16691_ net1020 VPWR _07859_ VGND net517 net734 sg13g2_o21ai_1
XFILLER_19_669 VPWR VGND sg13g2_fill_2
X_18430_ _09530_ VPWR _09540_ VGND _09538_ _09539_ sg13g2_o21ai_1
XFILLER_34_617 VPWR VGND sg13g2_fill_1
X_15642_ _06895_ _06894_ _00182_ VPWR VGND sg13g2_nor2b_1
X_12854_ _04215_ _04144_ _04214_ VPWR VGND sg13g2_nand2_1
XFILLER_61_414 VPWR VGND sg13g2_fill_1
XFILLER_62_948 VPWR VGND sg13g2_fill_2
X_18361_ _09471_ _09436_ _09444_ VPWR VGND sg13g2_xnor2_1
X_11805_ VPWR _03226_ net605 VGND sg13g2_inv_1
X_15573_ _06825_ _06827_ _06828_ VPWR VGND sg13g2_nor2_1
X_12785_ _04148_ _04144_ _04146_ VPWR VGND sg13g2_xnor2_1
XFILLER_61_469 VPWR VGND sg13g2_fill_1
X_17312_ VPWR VGND _08465_ _08409_ _08464_ u_LMS.w\[0\]\[15\] _08468_ _08406_ sg13g2_a221oi_1
X_14524_ _05798_ _05793_ _05791_ _05819_ VPWR VGND sg13g2_a21o_1
X_18292_ _09401_ _09400_ _09402_ VPWR VGND sg13g2_xor2_1
XFILLER_42_683 VPWR VGND sg13g2_fill_2
XFILLER_41_182 VPWR VGND sg13g2_fill_2
X_17243_ VGND VPWR _08098_ _08377_ _08399_ _08099_ sg13g2_a21oi_1
X_14455_ _05755_ u_FIR.sum\[3\]\[17\] net400 VPWR VGND sg13g2_xnor2_1
X_13406_ _04748_ _04741_ _04747_ VPWR VGND sg13g2_xnor2_1
X_17174_ _08328_ _08320_ _08330_ VPWR VGND sg13g2_xor2_1
X_14386_ _05688_ _05666_ _05690_ VPWR VGND sg13g2_xor2_1
XFILLER_127_243 VPWR VGND sg13g2_decap_8
X_16125_ _07351_ VPWR _07364_ VGND _07345_ _07349_ sg13g2_o21ai_1
X_13337_ _04681_ u_FIR.w\[6\]\[6\] net843 VPWR VGND sg13g2_nand2b_1
XFILLER_128_788 VPWR VGND sg13g2_decap_4
X_16056_ _07294_ _07296_ _07297_ VPWR VGND sg13g2_nor2_1
X_13268_ _04614_ _04607_ _04612_ VPWR VGND sg13g2_xnor2_1
X_15007_ _06267_ VPWR _06284_ VGND _06268_ _06269_ sg13g2_o21ai_1
XFILLER_124_972 VPWR VGND sg13g2_decap_4
X_12219_ VGND VPWR net727 net882 _03603_ _03601_ sg13g2_a21oi_1
XFILLER_111_600 VPWR VGND sg13g2_fill_2
X_13199_ _04546_ _04518_ _04547_ VPWR VGND sg13g2_xor2_1
XFILLER_111_611 VPWR VGND sg13g2_fill_2
XFILLER_96_311 VPWR VGND sg13g2_fill_2
XFILLER_97_856 VPWR VGND sg13g2_decap_8
X_19815_ _10851_ VPWR _10874_ VGND _10855_ _10873_ sg13g2_o21ai_1
XFILLER_99_1008 VPWR VGND sg13g2_decap_8
X_19746_ VGND VPWR _10809_ _10810_ _10808_ _10744_ sg13g2_a21oi_2
X_16958_ _08114_ net706 net134 VPWR VGND sg13g2_nand2_1
XFILLER_65_720 VPWR VGND sg13g2_decap_4
X_23504__1399 VPWR VGND net1398 sg13g2_tiehi
XFILLER_2_84 VPWR VGND sg13g2_decap_8
X_15909_ _07128_ _07154_ _07155_ VPWR VGND sg13g2_nor2b_1
X_19677_ u_LMS.w\[4\]\[17\] _10740_ _10741_ VPWR VGND sg13g2_and2_1
X_16889_ _08045_ _08025_ _08043_ VPWR VGND sg13g2_xnor2_1
XFILLER_38_978 VPWR VGND sg13g2_fill_2
X_23458__1558 VPWR VGND net1557 sg13g2_tiehi
XFILLER_92_561 VPWR VGND sg13g2_fill_2
X_18628_ VGND VPWR u_LMS.w\[2\]\[24\] net301 _09726_ _09702_ sg13g2_a21oi_1
XFILLER_65_797 VPWR VGND sg13g2_decap_8
XFILLER_64_285 VPWR VGND sg13g2_decap_8
X_18559_ VGND VPWR u_LMS.w\[2\]\[21\] u_LMS.w\[2\]\[20\] _09669_ net69 sg13g2_a21oi_1
XFILLER_40_609 VPWR VGND sg13g2_fill_1
XFILLER_36_1003 VPWR VGND sg13g2_fill_2
XFILLER_33_650 VPWR VGND sg13g2_decap_8
X_21570_ _02093_ _02186_ _02187_ VPWR VGND sg13g2_nor2_1
Xclkbuf_4_5_0_clkA clknet_0_clkA clknet_4_5_0_clkA VPWR VGND sg13g2_buf_8
XFILLER_32_160 VPWR VGND sg13g2_decap_4
X_20521_ _01160_ _01154_ _01161_ VPWR VGND sg13g2_nor2b_1
XFILLER_21_867 VPWR VGND sg13g2_fill_1
XFILLER_119_700 VPWR VGND sg13g2_fill_1
XFILLER_21_878 VPWR VGND sg13g2_decap_8
XFILLER_119_711 VPWR VGND sg13g2_fill_1
XFILLER_20_366 VPWR VGND sg13g2_decap_8
X_23240_ net1409 VGND VPWR _00302_ u_LMS.w\[0\]\[11\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
X_20452_ _01106_ _01104_ _01105_ VPWR VGND sg13g2_xnor2_1
X_23171_ net1531 VGND VPWR _00233_ u_FIR.w\[2\]\[2\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
X_20383_ _01046_ u_LMS.w\[5\]\[17\] _00974_ VPWR VGND sg13g2_xnor2_1
X_22122_ _02716_ _02713_ _02714_ VPWR VGND sg13g2_xnor2_1
X_22053_ _02647_ _02616_ _02624_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_419 VPWR VGND sg13g2_fill_1
X_21004_ _01644_ u_LMS.w\[6\]\[21\] net73 VPWR VGND sg13g2_nand2_1
XFILLER_101_165 VPWR VGND sg13g2_fill_1
XFILLER_47_219 VPWR VGND sg13g2_fill_1
XFILLER_130_997 VPWR VGND sg13g2_decap_8
XFILLER_28_422 VPWR VGND sg13g2_fill_2
X_22955_ _07694_ VPWR _00812_ VGND _03289_ net525 sg13g2_o21ai_1
XFILLER_71_701 VPWR VGND sg13g2_decap_8
X_21906_ _02500_ net579 net167 VPWR VGND sg13g2_nand2_1
XFILLER_44_948 VPWR VGND sg13g2_decap_8
X_22886_ VGND VPWR u_s2p_input.reg_cnt\[2\] _03170_ _03171_ net939 sg13g2_a21oi_1
XFILLER_43_425 VPWR VGND sg13g2_decap_4
XFILLER_15_127 VPWR VGND sg13g2_decap_8
XFILLER_43_447 VPWR VGND sg13g2_decap_4
X_21837_ _02427_ VPWR _02431_ VGND _02428_ _02429_ sg13g2_o21ai_1
XFILLER_102_74 VPWR VGND sg13g2_decap_8
XFILLER_62_34 VPWR VGND sg13g2_fill_2
XFILLER_12_812 VPWR VGND sg13g2_decap_8
X_12570_ net906 net738 u_FIR.sum\[0\]\[0\] _03941_ VPWR VGND sg13g2_a21o_1
XFILLER_24_672 VPWR VGND sg13g2_decap_8
X_21768_ VPWR _02362_ _02361_ VGND sg13g2_inv_1
XFILLER_24_683 VPWR VGND sg13g2_fill_2
XFILLER_11_300 VPWR VGND sg13g2_decap_8
XFILLER_129_508 VPWR VGND sg13g2_decap_8
X_20719_ _01359_ _01340_ _01341_ VPWR VGND sg13g2_xnor2_1
X_23507_ net1387 VGND VPWR _00569_ u_LMS.count\[10\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
X_21699_ VGND VPWR _02302_ _02303_ _00453_ net932 sg13g2_a21oi_1
X_14240_ _05548_ u_FIR.sum\[3\]\[9\] net401 VPWR VGND sg13g2_xnor2_1
X_23438_ net1617 VGND VPWR _00500_ u_LMS.x_r\[1\]\[5\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
XFILLER_109_232 VPWR VGND sg13g2_fill_1
X_14171_ _05444_ _05480_ _05481_ VPWR VGND sg13g2_nor2b_1
X_23369_ net1232 VGND VPWR _00431_ u_LMS.w\[6\]\[2\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
X_13122_ _04470_ _04441_ _04472_ VPWR VGND sg13g2_xor2_1
XFILLER_124_224 VPWR VGND sg13g2_decap_8
XFILLER_2_0 VPWR VGND sg13g2_decap_8
XFILLER_11_93 VPWR VGND sg13g2_fill_1
XFILLER_106_972 VPWR VGND sg13g2_fill_1
X_17930_ _09063_ _08632_ _09062_ VPWR VGND sg13g2_xnor2_1
X_13053_ _04405_ _04397_ _04404_ VPWR VGND sg13g2_nand2_1
XFILLER_87_31 VPWR VGND sg13g2_fill_1
X_12004_ _03421_ _03404_ u_debug_unit.mon_w7_sync\[6\] _03400_ u_debug_unit.mon_w3_sync\[6\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_79_845 VPWR VGND sg13g2_fill_2
X_17861_ _08994_ u_LMS.w\[1\]\[11\] _08993_ VPWR VGND sg13g2_nand2_1
XFILLER_132_290 VPWR VGND sg13g2_decap_8
XFILLER_78_355 VPWR VGND sg13g2_decap_4
X_19600_ _10664_ _10662_ _10663_ VPWR VGND sg13g2_nand2_1
X_16812_ _07936_ net2077 _07968_ VPWR VGND sg13g2_nor2_1
XFILLER_78_388 VPWR VGND sg13g2_decap_8
XFILLER_66_528 VPWR VGND sg13g2_decap_8
XFILLER_120_474 VPWR VGND sg13g2_fill_2
X_17792_ _08925_ _08916_ _08918_ VPWR VGND sg13g2_xnor2_1
XFILLER_120_485 VPWR VGND sg13g2_fill_2
Xfanout390 net391 net390 VPWR VGND sg13g2_buf_1
XFILLER_120_496 VPWR VGND sg13g2_fill_1
X_19531_ _10593_ _10594_ _10595_ VPWR VGND sg13g2_nor2_1
X_16743_ u_FIR.sum\[8\]\[7\] _03378_ net1643 _07899_ VPWR VGND sg13g2_mux2_1
X_13955_ _05272_ _05268_ _05274_ VPWR VGND sg13g2_xor2_1
XFILLER_19_466 VPWR VGND sg13g2_decap_8
XFILLER_59_1014 VPWR VGND sg13g2_decap_8
XFILLER_19_477 VPWR VGND sg13g2_fill_2
X_19462_ _10491_ _10487_ _10526_ VPWR VGND sg13g2_xor2_1
X_12906_ _04266_ u_FIR.sum\[0\]\[11\] net408 VPWR VGND sg13g2_nand2_1
X_16674_ VGND VPWR net538 _07844_ _00264_ _07845_ sg13g2_a21oi_1
X_13886_ net1035 VPWR _05209_ VGND net536 u_FIR.sum\[3\]\[13\] sg13g2_o21ai_1
XFILLER_34_436 VPWR VGND sg13g2_decap_4
X_18413_ _09505_ _09522_ _09523_ VPWR VGND sg13g2_nor2_1
X_15625_ VGND VPWR net792 net818 _06879_ u_FIR.sum\[6\]\[6\] sg13g2_a21oi_1
XFILLER_61_233 VPWR VGND sg13g2_decap_8
X_19393_ _10457_ _10451_ _10452_ VPWR VGND sg13g2_xnor2_1
X_12837_ _04171_ _04198_ _04199_ VPWR VGND sg13g2_nor2b_1
XFILLER_36_90 VPWR VGND sg13g2_fill_1
XFILLER_43_970 VPWR VGND sg13g2_decap_4
XFILLER_21_108 VPWR VGND sg13g2_decap_8
X_18344_ _09454_ _09430_ _09432_ VPWR VGND sg13g2_xnor2_1
X_15556_ _06812_ _06804_ _06811_ VPWR VGND sg13g2_nand2_1
X_12768_ VGND VPWR _04091_ _04121_ _04131_ _04123_ sg13g2_a21oi_1
X_14507_ net992 VPWR _05803_ VGND net490 u_FIR.sum\[5\]\[2\] sg13g2_o21ai_1
X_18275_ _09350_ _09344_ _09385_ VPWR VGND sg13g2_xor2_1
X_15487_ VGND VPWR _06745_ _06746_ _06747_ net411 sg13g2_a21oi_1
X_12699_ _04064_ net733 net856 VPWR VGND sg13g2_nand2_1
X_17226_ _08029_ _08048_ _08058_ _08382_ VPWR VGND sg13g2_nor3_1
X_14438_ _05739_ _05721_ _05738_ VPWR VGND sg13g2_xnor2_1
XFILLER_122_1050 VPWR VGND sg13g2_decap_8
X_17157_ _08312_ _08310_ _08313_ VPWR VGND sg13g2_xor2_1
X_14369_ net279 _05670_ _05673_ VPWR VGND sg13g2_and2_1
XFILLER_116_725 VPWR VGND sg13g2_fill_1
X_16108_ _07346_ _07347_ _07348_ VPWR VGND sg13g2_nor2_1
XFILLER_6_381 VPWR VGND sg13g2_fill_1
X_17088_ _08244_ _08242_ _08243_ VPWR VGND sg13g2_nand2_1
Xclkbuf_4_13_0_clkA clknet_0_clkA clknet_4_13_0_clkA VPWR VGND sg13g2_buf_8
X_16039_ _07276_ _07278_ _07280_ VPWR VGND sg13g2_nor2_1
XFILLER_69_322 VPWR VGND sg13g2_fill_1
XFILLER_130_227 VPWR VGND sg13g2_decap_8
XFILLER_35_0 VPWR VGND sg13g2_decap_4
XFILLER_112_953 VPWR VGND sg13g2_fill_2
XFILLER_85_804 VPWR VGND sg13g2_fill_2
XFILLER_85_826 VPWR VGND sg13g2_decap_4
XFILLER_69_399 VPWR VGND sg13g2_decap_4
XFILLER_57_539 VPWR VGND sg13g2_decap_4
XFILLER_96_196 VPWR VGND sg13g2_decap_8
X_19729_ _10793_ _03322_ _10757_ VPWR VGND sg13g2_nand2_1
X_23002__1204 VPWR VGND net1203 sg13g2_tiehi
X_23164__1544 VPWR VGND net1543 sg13g2_tiehi
XFILLER_37_252 VPWR VGND sg13g2_decap_8
XFILLER_26_926 VPWR VGND sg13g2_decap_8
XFILLER_38_786 VPWR VGND sg13g2_decap_8
X_22740_ u_debug_unit.mon_w2_sync\[0\] net333 _03088_ VPWR VGND sg13g2_nor2_1
XFILLER_16_27 VPWR VGND sg13g2_decap_8
XFILLER_52_222 VPWR VGND sg13g2_fill_1
X_22671_ coeff_force_packed\[41\] net461 _03066_ _00662_ VPWR VGND sg13g2_mux2_1
XFILLER_53_789 VPWR VGND sg13g2_fill_2
XFILLER_41_929 VPWR VGND sg13g2_fill_2
X_21622_ u_LMS.w\[7\]\[20\] u_LMS.w\[7\]\[21\] net62 _02239_ VPWR VGND sg13g2_a21o_1
X_21553_ _02170_ _02111_ _02121_ VPWR VGND sg13g2_xnor2_1
X_20504_ net363 VPWR _01146_ VGND u_LMS.w\[5\]\[10\] net381 sg13g2_o21ai_1
X_21484_ _02100_ _02099_ _02101_ VPWR VGND sg13g2_nor2b_1
XFILLER_20_174 VPWR VGND sg13g2_decap_4
XFILLER_107_703 VPWR VGND sg13g2_fill_2
X_23223_ net1439 VGND VPWR _00285_ u_LMS.w\[0\]\[17\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
X_20435_ net2124 net2126 _01092_ VPWR VGND sg13g2_xor2_1
XFILLER_106_202 VPWR VGND sg13g2_decap_8
XFILLER_10_1028 VPWR VGND sg13g2_decap_8
XFILLER_106_213 VPWR VGND sg13g2_fill_2
X_23154_ net1558 VGND VPWR _00216_ u_FIR.x_reg\[7\] clknet_leaf_23_clkA sg13g2_dfrbpq_1
X_20366_ u_LMS.w\[5\]\[11\] _00987_ _01029_ VPWR VGND sg13g2_nor2_1
X_22105_ VGND VPWR _02697_ _02698_ _02699_ _02673_ sg13g2_a21oi_1
XFILLER_122_717 VPWR VGND sg13g2_decap_4
X_23085_ net1078 VGND VPWR _00147_ u_FIR.sum\[5\]\[9\] clknet_leaf_42_clkA sg13g2_dfrbpq_1
X_20297_ _11016_ VPWR _00960_ VGND _10986_ _11017_ sg13g2_o21ai_1
X_22036_ _02627_ _02626_ _02630_ VPWR VGND sg13g2_xor2_1
XFILLER_103_953 VPWR VGND sg13g2_decap_4
XFILLER_87_174 VPWR VGND sg13g2_fill_1
XFILLER_75_314 VPWR VGND sg13g2_fill_1
XFILLER_75_325 VPWR VGND sg13g2_decap_8
X_23350__1252 VPWR VGND net1251 sg13g2_tiehi
XFILLER_28_230 VPWR VGND sg13g2_decap_8
XFILLER_56_550 VPWR VGND sg13g2_fill_2
XFILLER_44_701 VPWR VGND sg13g2_decap_8
X_13740_ _05067_ _05066_ _05026_ VPWR VGND sg13g2_nand2b_1
X_22938_ _03200_ net323 u_spi_slave.rx_shift\[3\] u_spi_slave.rx_shift\[11\] net428
+ VPWR VGND sg13g2_a22oi_1
XFILLER_17_948 VPWR VGND sg13g2_decap_8
XFILLER_113_73 VPWR VGND sg13g2_decap_8
XFILLER_83_391 VPWR VGND sg13g2_fill_1
X_13671_ net1033 VPWR _05000_ VGND net532 u_FIR.sum\[3\]\[7\] sg13g2_o21ai_1
X_22869_ VGND VPWR u_p2s_output.reg_sh\[5\] net551 _03160_ _03159_ sg13g2_a21oi_1
X_15410_ _06667_ _06674_ _06675_ VPWR VGND sg13g2_nor2b_1
XFILLER_25_981 VPWR VGND sg13g2_fill_2
XFILLER_19_1020 VPWR VGND sg13g2_fill_2
X_12622_ VGND VPWR net531 _03988_ _00068_ _03989_ sg13g2_a21oi_1
X_16390_ _07621_ _07609_ _07622_ VPWR VGND sg13g2_xor2_1
XFILLER_19_1042 VPWR VGND sg13g2_decap_8
X_15341_ VGND VPWR _06575_ _06579_ _06608_ _06578_ sg13g2_a21oi_1
XFILLER_12_642 VPWR VGND sg13g2_fill_2
X_12553_ _03925_ _03915_ _03926_ VPWR VGND sg13g2_nor2b_1
X_23426__1071 VPWR VGND net1070 sg13g2_tiehi
X_18060_ _09171_ _09033_ _09035_ VPWR VGND sg13g2_xnor2_1
X_15272_ _06541_ net777 net821 VPWR VGND sg13g2_nand2_1
XFILLER_8_646 VPWR VGND sg13g2_fill_2
X_12484_ _03716_ VPWR _03859_ VGND _03804_ _03831_ sg13g2_o21ai_1
XFILLER_11_185 VPWR VGND sg13g2_fill_2
X_17011_ _08167_ net706 net231 VPWR VGND sg13g2_nand2_1
X_14223_ net851 _05530_ net757 _05531_ VPWR VGND sg13g2_nand3_1
XFILLER_7_178 VPWR VGND sg13g2_decap_4
X_14154_ _05464_ _05457_ _05462_ VPWR VGND sg13g2_xnor2_1
X_13105_ _04455_ _04447_ _04454_ VPWR VGND sg13g2_nand2_1
XFILLER_106_780 VPWR VGND sg13g2_decap_8
X_18962_ _10049_ _10040_ _10048_ VPWR VGND sg13g2_xnor2_1
X_14085_ _05360_ _05396_ _05397_ VPWR VGND sg13g2_nor2_1
XFILLER_98_439 VPWR VGND sg13g2_decap_8
XFILLER_112_238 VPWR VGND sg13g2_fill_2
X_17913_ _08983_ _08985_ _09045_ _09046_ VPWR VGND sg13g2_or3_1
X_13036_ _04387_ _04388_ _04389_ VPWR VGND sg13g2_nor2b_1
X_18893_ _09980_ net657 net254 VPWR VGND sg13g2_nand2_1
XFILLER_26_1035 VPWR VGND sg13g2_fill_2
X_17844_ _08699_ VPWR _08977_ VGND _08974_ _08976_ sg13g2_o21ai_1
XFILLER_120_260 VPWR VGND sg13g2_fill_1
XFILLER_94_645 VPWR VGND sg13g2_decap_4
XFILLER_78_196 VPWR VGND sg13g2_fill_1
Xclkbuf_3_0__f_spi_sclk clknet_3_0__leaf_spi_sclk clknet_0_spi_sclk VPWR VGND sg13g2_buf_16
XFILLER_66_358 VPWR VGND sg13g2_decap_8
X_17775_ _08907_ VPWR _08908_ VGND _03274_ net178 sg13g2_o21ai_1
XFILLER_19_230 VPWR VGND sg13g2_fill_2
X_14987_ VGND VPWR net782 net890 _06265_ u_FIR.sum\[5\]\[1\] sg13g2_a21oi_1
XFILLER_94_689 VPWR VGND sg13g2_fill_1
X_19514_ VGND VPWR _10566_ _10568_ _10578_ _10577_ sg13g2_a21oi_1
X_16726_ VGND VPWR u_LMS.w\[8\]\[17\] _07872_ _07884_ _07873_ sg13g2_a21oi_1
XFILLER_47_572 VPWR VGND sg13g2_decap_4
X_13938_ _05258_ _05237_ _05257_ VPWR VGND sg13g2_xnor2_1
XFILLER_81_339 VPWR VGND sg13g2_decap_8
XFILLER_35_734 VPWR VGND sg13g2_fill_2
X_19445_ _10509_ u_LMS.x_r\[4\]\[3\] net169 VPWR VGND sg13g2_nand2_1
X_23160__1550 VPWR VGND net1549 sg13g2_tiehi
X_16657_ VGND VPWR u_LMS.w\[6\]\[12\] _07832_ _07834_ _07833_ sg13g2_a21oi_1
XFILLER_90_862 VPWR VGND sg13g2_fill_2
X_13869_ _05187_ net282 _05190_ _05192_ VPWR VGND sg13g2_a21o_1
XFILLER_16_970 VPWR VGND sg13g2_fill_1
X_15608_ _03373_ net901 _06862_ VPWR VGND sg13g2_nor2_1
XFILLER_72_1000 VPWR VGND sg13g2_decap_4
XFILLER_62_586 VPWR VGND sg13g2_decap_8
X_19376_ _10436_ _10439_ _10440_ VPWR VGND sg13g2_nor2_1
X_16588_ VGND VPWR net489 _07781_ _00241_ _07782_ sg13g2_a21oi_1
XFILLER_50_759 VPWR VGND sg13g2_decap_8
XFILLER_31_940 VPWR VGND sg13g2_fill_1
X_18327_ _09437_ net680 net164 VPWR VGND sg13g2_nand2_1
X_15539_ _06795_ net786 net899 VPWR VGND sg13g2_nand2_1
XFILLER_31_984 VPWR VGND sg13g2_decap_8
XFILLER_30_450 VPWR VGND sg13g2_decap_4
X_18258_ _09368_ net670 net238 VPWR VGND sg13g2_nand2_1
X_17209_ VGND VPWR _08355_ _08359_ _08365_ _08358_ sg13g2_a21oi_1
X_18189_ _09299_ _09298_ _09294_ VPWR VGND sg13g2_nand2b_1
X_20220_ VGND VPWR _00878_ _00879_ _00883_ _00882_ sg13g2_a21oi_1
XFILLER_7_690 VPWR VGND sg13g2_decap_8
XFILLER_103_205 VPWR VGND sg13g2_decap_8
X_20151_ _11191_ _11159_ _11192_ VPWR VGND sg13g2_xor2_1
XFILLER_131_547 VPWR VGND sg13g2_decap_8
Xrebuffer1645 net1644 _07892_ VPWR VGND sg13g2_buf_4
X_20082_ _11123_ net627 net192 VPWR VGND sg13g2_nand2_1
Xrebuffer1656 net2125 net1655 VPWR VGND sg13g2_buf_1
XFILLER_98_962 VPWR VGND sg13g2_decap_4
XFILLER_112_761 VPWR VGND sg13g2_decap_8
Xrebuffer1667 net1667 net1666 VPWR VGND sg13g2_buf_1
XFILLER_58_826 VPWR VGND sg13g2_decap_8
XFILLER_100_923 VPWR VGND sg13g2_fill_1
XFILLER_57_325 VPWR VGND sg13g2_decap_8
XFILLER_100_967 VPWR VGND sg13g2_decap_4
XFILLER_111_293 VPWR VGND sg13g2_fill_1
XFILLER_100_978 VPWR VGND sg13g2_decap_8
XFILLER_57_369 VPWR VGND sg13g2_decap_4
XFILLER_66_870 VPWR VGND sg13g2_fill_1
XFILLER_38_561 VPWR VGND sg13g2_decap_4
X_20984_ _01582_ VPWR _01624_ VGND _01622_ _01621_ sg13g2_o21ai_1
X_23772_ net994 VGND VPWR _00005_ u_spi_slave.rx_shift\[14\] clknet_3_4__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_25_211 VPWR VGND sg13g2_decap_8
X_22723_ VGND VPWR _07725_ net349 _00701_ _03079_ sg13g2_a21oi_1
XFILLER_26_767 VPWR VGND sg13g2_decap_8
XFILLER_14_918 VPWR VGND sg13g2_decap_4
XFILLER_43_14 VPWR VGND sg13g2_fill_2
XFILLER_129_1056 VPWR VGND sg13g2_decap_4
XFILLER_25_288 VPWR VGND sg13g2_decap_8
X_22654_ net458 u_debug_unit.force_w3\[7\] _03064_ _00647_ VPWR VGND sg13g2_mux2_1
XFILLER_41_748 VPWR VGND sg13g2_decap_8
XFILLER_40_247 VPWR VGND sg13g2_decap_8
X_21605_ VGND VPWR _02222_ _02165_ u_LMS.w\[7\]\[14\] sg13g2_or2_1
XFILLER_40_258 VPWR VGND sg13g2_fill_2
X_22585_ _03052_ _03054_ _00588_ VPWR VGND sg13g2_nor2_1
X_21536_ _02153_ _02141_ _02152_ VPWR VGND sg13g2_xnor2_1
XFILLER_107_500 VPWR VGND sg13g2_decap_4
X_21467_ VGND VPWR net604 net244 _02084_ _02083_ sg13g2_a21oi_1
X_23368__1234 VPWR VGND net1233 sg13g2_tiehi
XFILLER_4_126 VPWR VGND sg13g2_fill_2
X_20418_ VGND VPWR _01078_ _01079_ _00396_ net934 sg13g2_a21oi_1
X_23206_ net1470 VGND VPWR _00268_ u_FIR.w\[7\]\[2\] clknet_leaf_35_clkA sg13g2_dfrbpq_1
X_21398_ _01929_ _02014_ _02015_ VPWR VGND sg13g2_nor2_1
XFILLER_108_40 VPWR VGND sg13g2_fill_2
XFILLER_107_588 VPWR VGND sg13g2_decap_4
X_20349_ _01011_ _01010_ _01012_ VPWR VGND sg13g2_nor2b_1
X_23137_ net1583 VGND VPWR _00199_ u_FIR.sum\[8\]\[9\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
X_23068_ net1104 VGND VPWR _00130_ u_FIR.sum\[4\]\[11\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
XFILLER_1_866 VPWR VGND sg13g2_fill_2
X_22019_ _02613_ _02612_ _02609_ VPWR VGND sg13g2_nand2b_1
X_14910_ _06192_ _06180_ _06194_ VPWR VGND sg13g2_xor2_1
XFILLER_89_995 VPWR VGND sg13g2_decap_4
XFILLER_76_623 VPWR VGND sg13g2_decap_8
X_15890_ _07137_ _07130_ _07135_ VPWR VGND sg13g2_xnor2_1
XFILLER_48_325 VPWR VGND sg13g2_fill_1
XFILLER_76_645 VPWR VGND sg13g2_decap_8
XFILLER_124_50 VPWR VGND sg13g2_fill_2
X_14841_ _06127_ _06124_ _06125_ VPWR VGND sg13g2_xnor2_1
XFILLER_64_829 VPWR VGND sg13g2_fill_2
Xclkbuf_leaf_13_clkA clknet_4_11_0_clkA clknet_leaf_13_clkA VPWR VGND sg13g2_buf_8
XFILLER_91_615 VPWR VGND sg13g2_decap_8
XFILLER_84_43 VPWR VGND sg13g2_fill_2
X_17560_ VGND VPWR _08691_ _08692_ _08693_ _08688_ sg13g2_a21oi_1
XFILLER_63_328 VPWR VGND sg13g2_fill_2
X_14772_ net837 net767 _06058_ _06060_ VPWR VGND sg13g2_a21o_1
X_11984_ spi_addr\[3\] spi_addr\[2\] _03401_ VPWR VGND sg13g2_nor2b_1
XFILLER_17_734 VPWR VGND sg13g2_fill_1
X_16511_ VGND VPWR u_LMS.w\[0\]\[17\] _07713_ _07725_ _07714_ sg13g2_a21oi_1
XFILLER_17_756 VPWR VGND sg13g2_fill_2
X_23278__1338 VPWR VGND net1337 sg13g2_tiehi
X_13723_ _05048_ _05049_ _05050_ VPWR VGND sg13g2_and2_1
XFILLER_1_1059 VPWR VGND sg13g2_fill_2
X_17491_ VGND VPWR _08600_ _08603_ _08624_ net121 sg13g2_a21oi_1
XFILLER_72_862 VPWR VGND sg13g2_decap_8
XFILLER_32_715 VPWR VGND sg13g2_fill_2
X_19230_ _10254_ _10252_ _10307_ VPWR VGND sg13g2_xor2_1
X_16442_ _07671_ _07670_ _07648_ VPWR VGND sg13g2_nand2b_1
XFILLER_32_737 VPWR VGND sg13g2_fill_2
X_23122__1607 VPWR VGND net1606 sg13g2_tiehi
X_13654_ _04983_ _04965_ _04981_ VPWR VGND sg13g2_xnor2_1
XFILLER_31_225 VPWR VGND sg13g2_decap_4
XFILLER_13_951 VPWR VGND sg13g2_decap_8
X_19161_ _10248_ u_LMS.w\[3\]\[21\] net68 VPWR VGND sg13g2_nand2_1
X_12605_ _03971_ _03953_ _03973_ VPWR VGND sg13g2_xor2_1
X_16373_ _07580_ _07605_ _07606_ VPWR VGND sg13g2_and2_1
X_13585_ _04916_ _04888_ _04915_ VPWR VGND sg13g2_xnor2_1
X_18112_ _09199_ net120 _09190_ _09222_ VPWR VGND sg13g2_nand3_1
XFILLER_9_944 VPWR VGND sg13g2_fill_2
X_15324_ _06592_ _06554_ _06590_ VPWR VGND sg13g2_xnor2_1
X_19092_ _10179_ _10143_ _10144_ VPWR VGND sg13g2_xnor2_1
X_12536_ VGND VPWR _03883_ _03886_ _03910_ _03908_ sg13g2_a21oi_1
XFILLER_9_988 VPWR VGND sg13g2_fill_1
X_18043_ _09159_ _09018_ _09019_ VPWR VGND sg13g2_nand2b_1
X_15255_ _06524_ _06491_ _06525_ VPWR VGND sg13g2_nor2b_1
X_12467_ _03842_ _03832_ _03843_ VPWR VGND sg13g2_xor2_1
XFILLER_8_487 VPWR VGND sg13g2_fill_1
X_14206_ _05515_ _05486_ _05514_ VPWR VGND sg13g2_nand2b_1
X_15186_ _03370_ net875 _06457_ VPWR VGND sg13g2_nor2_1
XFILLER_99_704 VPWR VGND sg13g2_fill_1
X_12398_ _03776_ _03757_ _03774_ VPWR VGND sg13g2_xnor2_1
XFILLER_113_503 VPWR VGND sg13g2_fill_2
X_14137_ _05433_ VPWR _05447_ VGND _05384_ _05423_ sg13g2_o21ai_1
XFILLER_99_737 VPWR VGND sg13g2_fill_1
X_19994_ _11035_ _11033_ _11034_ VPWR VGND sg13g2_xnor2_1
X_18945_ _10032_ _09994_ _10005_ VPWR VGND sg13g2_xnor2_1
X_14068_ VGND VPWR _05380_ _05378_ _05346_ sg13g2_or2_1
X_23196__1488 VPWR VGND net1487 sg13g2_tiehi
X_13019_ _04371_ _04364_ _04373_ VPWR VGND sg13g2_xor2_1
X_18876_ _09953_ VPWR _09963_ VGND _09921_ _09951_ sg13g2_o21ai_1
XFILLER_67_656 VPWR VGND sg13g2_decap_4
X_17827_ VGND VPWR _08772_ _08793_ _08960_ _08792_ sg13g2_a21oi_1
XFILLER_94_475 VPWR VGND sg13g2_decap_4
X_17758_ _08868_ VPWR _08891_ VGND _03274_ net163 sg13g2_o21ai_1
XFILLER_66_199 VPWR VGND sg13g2_decap_4
XFILLER_63_840 VPWR VGND sg13g2_decap_8
XFILLER_81_147 VPWR VGND sg13g2_decap_4
XFILLER_63_851 VPWR VGND sg13g2_fill_2
X_16709_ _07871_ VPWR _07872_ VGND _07867_ _07868_ sg13g2_o21ai_1
X_17689_ _08822_ _08816_ _08820_ VPWR VGND sg13g2_xnor2_1
XFILLER_63_895 VPWR VGND sg13g2_fill_2
Xfanout18 _01658_ net18 VPWR VGND sg13g2_buf_1
X_19428_ _10486_ VPWR _10492_ VGND _10487_ _10491_ sg13g2_o21ai_1
Xfanout29 _10267_ net29 VPWR VGND sg13g2_buf_1
XFILLER_10_409 VPWR VGND sg13g2_decap_8
X_19359_ _10423_ _10400_ _10421_ VPWR VGND sg13g2_xnor2_1
XFILLER_22_269 VPWR VGND sg13g2_fill_2
X_22370_ VGND VPWR net455 _03284_ _00493_ _02934_ sg13g2_a21oi_1
XFILLER_129_28 VPWR VGND sg13g2_decap_8
X_21321_ _01936_ _01932_ _01938_ VPWR VGND _01935_ sg13g2_nand3b_1
X_21252_ _01869_ _01833_ _01835_ VPWR VGND sg13g2_xnor2_1
X_20203_ _00866_ net628 net264 VPWR VGND sg13g2_nand2_1
XFILLER_132_812 VPWR VGND sg13g2_fill_2
Xrebuffer2121 _00939_ net2120 VPWR VGND sg13g2_buf_1
X_21183_ _01800_ _01793_ _01799_ VPWR VGND sg13g2_nand2_1
Xrebuffer2132 _00856_ net2131 VPWR VGND sg13g2_buf_1
Xrebuffer2143 _02225_ net2142 VPWR VGND sg13g2_buf_1
XFILLER_104_536 VPWR VGND sg13g2_fill_1
Xrebuffer2154 net2157 net2153 VPWR VGND sg13g2_buf_1
XFILLER_132_845 VPWR VGND sg13g2_decap_8
Xrebuffer2165 _02228_ net2164 VPWR VGND sg13g2_buf_1
X_20134_ _11161_ VPWR _11175_ VGND _11158_ _11163_ sg13g2_o21ai_1
Xfanout901 net911 net901 VPWR VGND sg13g2_buf_1
XFILLER_132_867 VPWR VGND sg13g2_decap_8
XFILLER_104_569 VPWR VGND sg13g2_decap_8
Xfanout912 u_LMS.mu\[4\] net912 VPWR VGND sg13g2_buf_1
Xrebuffer2176 net2176 net2175 VPWR VGND sg13g2_buf_1
Xfanout923 net926 net923 VPWR VGND sg13g2_buf_1
Xfanout934 net935 net934 VPWR VGND sg13g2_buf_1
Xrebuffer2198 _08229_ net2197 VPWR VGND sg13g2_buf_1
Xfanout945 net946 net945 VPWR VGND sg13g2_buf_1
Xclkbuf_leaf_36_clkA clknet_4_12_0_clkA clknet_leaf_36_clkA VPWR VGND sg13g2_buf_8
XFILLER_131_388 VPWR VGND sg13g2_decap_8
X_20065_ _11106_ _11097_ _11098_ VPWR VGND sg13g2_xnor2_1
Xfanout956 net957 net956 VPWR VGND sg13g2_buf_1
Xfanout967 net968 net967 VPWR VGND sg13g2_buf_1
Xfanout978 net1000 net978 VPWR VGND sg13g2_buf_1
XFILLER_97_280 VPWR VGND sg13g2_fill_2
Xfanout989 net990 net989 VPWR VGND sg13g2_buf_1
XFILLER_97_291 VPWR VGND sg13g2_fill_1
XFILLER_85_453 VPWR VGND sg13g2_decap_8
XFILLER_39_892 VPWR VGND sg13g2_decap_8
XFILLER_54_851 VPWR VGND sg13g2_decap_8
XFILLER_72_158 VPWR VGND sg13g2_decap_8
XFILLER_26_553 VPWR VGND sg13g2_fill_2
X_23755_ net1330 VGND VPWR _00817_ u_LMS.x\[6\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
XFILLER_72_169 VPWR VGND sg13g2_fill_1
X_20967_ _01607_ u_LMS.w\[6\]\[6\] _01590_ VPWR VGND sg13g2_xnor2_1
XFILLER_54_884 VPWR VGND sg13g2_decap_8
X_22706_ u_debug_unit.error_signal_sync\[4\] net332 _03072_ VPWR VGND sg13g2_nor2_1
XFILLER_14_748 VPWR VGND sg13g2_fill_2
XFILLER_110_30 VPWR VGND sg13g2_decap_8
X_23686_ net1018 VGND VPWR _00748_ u_debug_unit.mon_w7_sync\[3\] clknet_leaf_20_clkA
+ sg13g2_dfrbpq_1
X_20898_ _01301_ _01302_ _01538_ VPWR VGND sg13g2_nor2_1
X_22637_ net429 _03430_ _03063_ VPWR VGND sg13g2_and2_1
XFILLER_9_229 VPWR VGND sg13g2_decap_8
X_13370_ net739 net813 _04713_ VPWR VGND sg13g2_and2_1
XFILLER_16_1056 VPWR VGND sg13g2_decap_4
XFILLER_10_943 VPWR VGND sg13g2_fill_2
X_22568_ u_LMS.count\[24\] _03042_ _03043_ VPWR VGND sg13g2_nor2_1
XFILLER_21_280 VPWR VGND sg13g2_decap_4
X_12321_ _03701_ _03698_ _03699_ VPWR VGND sg13g2_xnor2_1
X_21519_ _01893_ VPWR _02136_ VGND _01892_ _01925_ sg13g2_o21ai_1
XFILLER_108_831 VPWR VGND sg13g2_fill_2
X_22499_ net958 VPWR _02999_ VGND net441 net571 sg13g2_o21ai_1
XFILLER_126_127 VPWR VGND sg13g2_fill_2
XFILLER_6_958 VPWR VGND sg13g2_fill_2
X_15040_ _06313_ _06295_ _06315_ VPWR VGND sg13g2_xor2_1
XFILLER_6_969 VPWR VGND sg13g2_decap_8
XFILLER_126_149 VPWR VGND sg13g2_fill_2
X_12252_ _03634_ net727 net854 VPWR VGND sg13g2_nand2_1
XFILLER_119_190 VPWR VGND sg13g2_fill_2
XFILLER_107_352 VPWR VGND sg13g2_decap_4
XFILLER_102_0 VPWR VGND sg13g2_fill_1
XFILLER_108_897 VPWR VGND sg13g2_fill_1
X_12183_ net944 u_spi_slave.rx_shift\[13\] _00005_ VPWR VGND sg13g2_nor2b_1
XFILLER_122_300 VPWR VGND sg13g2_fill_1
X_16991_ _08139_ _08138_ _08147_ VPWR VGND sg13g2_xor2_1
XFILLER_0_140 VPWR VGND sg13g2_decap_8
X_18730_ _09817_ _09810_ _09816_ VPWR VGND sg13g2_nand2_1
X_15942_ _07186_ u_FIR.sum\[6\]\[16\] net390 VPWR VGND sg13g2_nand2_1
XFILLER_49_623 VPWR VGND sg13g2_fill_2
XFILLER_95_31 VPWR VGND sg13g2_fill_1
XFILLER_95_42 VPWR VGND sg13g2_fill_2
XFILLER_48_111 VPWR VGND sg13g2_fill_2
X_18661_ VGND VPWR net56 _09750_ _09751_ net32 sg13g2_a21oi_1
X_15873_ VGND VPWR _07089_ _07100_ _07120_ _07107_ sg13g2_a21oi_1
XFILLER_64_604 VPWR VGND sg13g2_fill_2
XFILLER_37_829 VPWR VGND sg13g2_decap_8
XFILLER_95_97 VPWR VGND sg13g2_fill_2
XFILLER_64_615 VPWR VGND sg13g2_fill_1
X_17612_ _08745_ _08741_ _08744_ VPWR VGND sg13g2_nand2_1
X_14824_ _06111_ _06088_ _06109_ VPWR VGND sg13g2_xnor2_1
X_18592_ _09697_ _09656_ _09657_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_957 VPWR VGND sg13g2_decap_8
XFILLER_36_339 VPWR VGND sg13g2_fill_1
X_23209__1465 VPWR VGND net1464 sg13g2_tiehi
X_17543_ _08672_ _08675_ _08676_ VPWR VGND sg13g2_nor2_1
X_14755_ VGND VPWR _06001_ _06004_ _06044_ _06042_ sg13g2_a21oi_1
X_11967_ net946 net328 _03387_ VPWR VGND sg13g2_nor2_1
XFILLER_17_575 VPWR VGND sg13g2_fill_2
X_13706_ _05033_ _05002_ _05034_ VPWR VGND sg13g2_xor2_1
X_17474_ _08607_ _08598_ _08606_ VPWR VGND sg13g2_nand2b_1
XFILLER_60_832 VPWR VGND sg13g2_fill_1
XFILLER_44_383 VPWR VGND sg13g2_fill_2
X_14686_ _05974_ _05975_ _05976_ VPWR VGND sg13g2_and2_1
X_11898_ VPWR _03319_ u_LMS.w\[5\]\[19\] VGND sg13g2_inv_1
X_19213_ VGND VPWR _10291_ _10293_ _00355_ net927 sg13g2_a21oi_1
X_16425_ _07633_ _07653_ _07631_ _07655_ VPWR VGND sg13g2_nand3_1
X_13637_ _04966_ _04928_ _04930_ VPWR VGND sg13g2_nand2_1
X_19144_ _10231_ _10230_ _10184_ VPWR VGND sg13g2_nand2b_1
X_16356_ net272 _07587_ _07589_ VPWR VGND sg13g2_and2_1
X_13568_ _04899_ _04898_ _04894_ VPWR VGND sg13g2_nand2b_1
X_15307_ u_FIR.w\[2\]\[4\] net804 _06575_ VPWR VGND sg13g2_and2_1
X_19075_ _09828_ _09837_ _09808_ _10162_ VPWR VGND sg13g2_nand3_1
X_12519_ net828 u_FIR.w\[8\]\[6\] _03893_ VPWR VGND sg13g2_nor2b_1
X_16287_ u_FIR.w\[0\]\[4\] net803 _07522_ VPWR VGND sg13g2_and2_1
X_13499_ _04833_ _04826_ _04832_ VPWR VGND sg13g2_xnor2_1
X_18026_ VGND VPWR _09145_ _09146_ _00315_ net926 sg13g2_a21oi_1
X_15238_ _06508_ _06507_ _06505_ VPWR VGND sg13g2_nand2b_1
XFILLER_99_501 VPWR VGND sg13g2_fill_1
Xclkbuf_leaf_59_clkA clknet_4_1_0_clkA clknet_leaf_59_clkA VPWR VGND sg13g2_buf_8
XFILLER_132_119 VPWR VGND sg13g2_fill_1
XFILLER_126_683 VPWR VGND sg13g2_fill_1
X_15169_ _06441_ _06434_ _06440_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_171 VPWR VGND sg13g2_decap_8
XFILLER_99_545 VPWR VGND sg13g2_fill_2
XFILLER_119_1033 VPWR VGND sg13g2_decap_8
XFILLER_5_84 VPWR VGND sg13g2_decap_8
Xfanout208 net216 net208 VPWR VGND sg13g2_buf_1
Xfanout219 net220 net219 VPWR VGND sg13g2_buf_1
X_19977_ _11017_ _10986_ _11018_ VPWR VGND sg13g2_xor2_1
XFILLER_101_528 VPWR VGND sg13g2_fill_2
X_18928_ _10015_ net658 net201 VPWR VGND sg13g2_nand2_1
XFILLER_79_291 VPWR VGND sg13g2_fill_1
X_18859_ _09946_ net657 net201 VPWR VGND sg13g2_nand2_1
XFILLER_94_250 VPWR VGND sg13g2_fill_1
XFILLER_68_998 VPWR VGND sg13g2_fill_2
XFILLER_94_261 VPWR VGND sg13g2_fill_1
XFILLER_82_412 VPWR VGND sg13g2_decap_4
XFILLER_131_18 VPWR VGND sg13g2_decap_8
X_21870_ _02464_ _02463_ _02459_ VPWR VGND sg13g2_nand2b_1
XFILLER_27_339 VPWR VGND sg13g2_decap_8
XFILLER_70_607 VPWR VGND sg13g2_decap_4
X_20821_ _01461_ net174 net620 net191 net618 VPWR VGND sg13g2_a22oi_1
XFILLER_54_158 VPWR VGND sg13g2_decap_8
XFILLER_35_361 VPWR VGND sg13g2_decap_8
X_23540_ net1012 VGND VPWR _00602_ debug_load_bus\[2\] clknet_leaf_37_clkA sg13g2_dfrbpq_1
X_20752_ _01392_ _01388_ _01390_ VPWR VGND sg13g2_xnor2_1
XFILLER_39_1056 VPWR VGND sg13g2_decap_4
XFILLER_62_180 VPWR VGND sg13g2_decap_8
XFILLER_51_876 VPWR VGND sg13g2_fill_1
X_20683_ _01316_ VPWR _01323_ VGND _01283_ _01314_ sg13g2_o21ai_1
X_23471_ net1514 VGND VPWR _00533_ u_LMS.x_r\[5\]\[6\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
X_22422_ VGND VPWR net437 _03258_ _00519_ _02960_ sg13g2_a21oi_1
XFILLER_10_239 VPWR VGND sg13g2_fill_2
X_23244__1403 VPWR VGND net1402 sg13g2_tiehi
X_22353_ _02925_ _02808_ _02810_ VPWR VGND sg13g2_xnor2_1
X_21304_ _01882_ _01886_ _01921_ VPWR VGND sg13g2_xor2_1
X_22284_ VPWR VGND _02870_ _02871_ net9 u_LMS.w\[8\]\[18\] _02872_ net308 sg13g2_a221oi_1
XFILLER_124_609 VPWR VGND sg13g2_fill_2
X_21235_ _01852_ _01846_ _01847_ VPWR VGND sg13g2_xnor2_1
XFILLER_116_160 VPWR VGND sg13g2_decap_8
XFILLER_6_7 VPWR VGND sg13g2_decap_8
XFILLER_105_856 VPWR VGND sg13g2_fill_1
XFILLER_116_193 VPWR VGND sg13g2_fill_2
XFILLER_104_344 VPWR VGND sg13g2_fill_2
XFILLER_78_707 VPWR VGND sg13g2_decap_8
XFILLER_105_878 VPWR VGND sg13g2_decap_8
X_21166_ _01761_ net116 _01758_ _01783_ VPWR VGND sg13g2_nand3_1
XFILLER_49_35 VPWR VGND sg13g2_fill_2
XFILLER_120_804 VPWR VGND sg13g2_decap_8
XFILLER_132_675 VPWR VGND sg13g2_decap_8
Xfanout720 u_FIR.w\[8\]\[5\] net720 VPWR VGND sg13g2_buf_1
X_20117_ _11158_ net631 net172 VPWR VGND sg13g2_nand2_1
Xfanout731 u_FIR.w\[7\]\[4\] net731 VPWR VGND sg13g2_buf_1
Xfanout742 net743 net742 VPWR VGND sg13g2_buf_1
X_21097_ VGND VPWR _01660_ _01720_ _01721_ net14 sg13g2_a21oi_1
Xfanout753 u_FIR.w\[5\]\[1\] net753 VPWR VGND sg13g2_buf_1
XFILLER_120_859 VPWR VGND sg13g2_fill_1
Xfanout764 u_FIR.w\[4\]\[1\] net764 VPWR VGND sg13g2_buf_1
XFILLER_86_740 VPWR VGND sg13g2_fill_1
XFILLER_59_965 VPWR VGND sg13g2_fill_2
Xfanout775 net776 net775 VPWR VGND sg13g2_buf_1
X_20048_ _11089_ _11085_ _11087_ _11088_ VPWR VGND sg13g2_and3_1
Xfanout786 u_FIR.w\[1\]\[4\] net786 VPWR VGND sg13g2_buf_1
XFILLER_58_453 VPWR VGND sg13g2_decap_8
XFILLER_100_550 VPWR VGND sg13g2_decap_8
Xfanout797 u_FIR.w\[0\]\[2\] net797 VPWR VGND sg13g2_buf_1
XFILLER_86_773 VPWR VGND sg13g2_fill_1
XFILLER_46_604 VPWR VGND sg13g2_fill_2
XFILLER_85_272 VPWR VGND sg13g2_fill_1
XFILLER_100_583 VPWR VGND sg13g2_decap_8
X_12870_ VPWR _04231_ _04230_ VGND sg13g2_inv_1
XFILLER_73_456 VPWR VGND sg13g2_decap_4
XFILLER_45_147 VPWR VGND sg13g2_decap_4
X_11821_ VPWR _03242_ net636 VGND sg13g2_inv_1
XFILLER_27_862 VPWR VGND sg13g2_decap_8
X_21999_ VGND VPWR _02569_ _02570_ _02593_ _02572_ sg13g2_a21oi_1
XFILLER_60_117 VPWR VGND sg13g2_decap_4
X_14540_ _05834_ _05833_ _05826_ VPWR VGND sg13g2_nand2b_1
XFILLER_81_11 VPWR VGND sg13g2_fill_2
X_23738_ net988 VGND VPWR _00800_ spi_addr\[4\] clknet_3_0__leaf_spi_sclk sg13g2_dfrbpq_1
XFILLER_92_1058 VPWR VGND sg13g2_fill_2
X_14471_ _05770_ u_FIR.sum\[3\]\[18\] _05754_ VPWR VGND sg13g2_xnor2_1
X_23669_ net1023 VGND VPWR _00731_ u_debug_unit.mon_w5_sync\[0\] clknet_leaf_20_clkA
+ sg13g2_dfrbpq_1
X_16210_ _07447_ net795 net833 VPWR VGND sg13g2_nand2_1
X_13422_ net1039 VPWR _04764_ VGND net544 u_FIR.sum\[2\]\[13\] sg13g2_o21ai_1
X_17190_ _08346_ _08302_ _08345_ VPWR VGND sg13g2_xnor2_1
X_16141_ _07378_ _07379_ _07380_ VPWR VGND sg13g2_and2_1
XFILLER_127_414 VPWR VGND sg13g2_fill_2
X_13353_ _04690_ _04696_ _04697_ VPWR VGND sg13g2_nor2b_1
X_12304_ _03684_ _03683_ _03680_ VPWR VGND sg13g2_nand2b_1
XFILLER_5_221 VPWR VGND sg13g2_fill_1
X_16072_ _07312_ _07309_ _07313_ VPWR VGND sg13g2_xor2_1
X_13284_ _04630_ _04589_ _04592_ _04629_ VPWR VGND sg13g2_and3_1
XFILLER_53_9 VPWR VGND sg13g2_fill_1
X_19900_ _03237_ net103 _10941_ VPWR VGND sg13g2_nor2_1
X_15023_ _06299_ _06298_ _06294_ VPWR VGND sg13g2_nand2b_1
X_12235_ VPWR _03618_ _03617_ VGND sg13g2_inv_1
XFILLER_123_631 VPWR VGND sg13g2_fill_1
X_19831_ _10885_ _10835_ _10887_ VPWR VGND sg13g2_xor2_1
XFILLER_2_950 VPWR VGND sg13g2_decap_8
X_12166_ _03574_ net428 _03572_ VPWR VGND sg13g2_nand2_1
XFILLER_39_7 VPWR VGND sg13g2_fill_2
X_19762_ _10825_ _10823_ _10826_ VPWR VGND sg13g2_xor2_1
X_16974_ _08130_ _08124_ _08129_ VPWR VGND sg13g2_nand2_1
X_12097_ _03509_ _03434_ u_debug_unit.mon_w0_sync\[3\] net296 coeff_force_packed\[10\]
+ VPWR VGND sg13g2_a22oi_1
X_18713_ VGND VPWR _09776_ _09779_ _09800_ net119 sg13g2_a21oi_1
X_15925_ _07170_ _07150_ _07168_ VPWR VGND sg13g2_xnor2_1
X_19693_ _10757_ _10720_ _10721_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_710 VPWR VGND sg13g2_fill_1
XFILLER_65_935 VPWR VGND sg13g2_decap_8
XFILLER_37_626 VPWR VGND sg13g2_fill_1
XFILLER_36_103 VPWR VGND sg13g2_fill_1
X_22975__1639 VPWR net1638 clknet_3_6__leaf_spi_sclk VGND sg13g2_inv_1
X_18644_ _09623_ _09622_ _09738_ VPWR VGND sg13g2_xor2_1
X_15856_ _07103_ net274 _07104_ VPWR VGND sg13g2_xor2_1
XFILLER_65_957 VPWR VGND sg13g2_fill_2
XFILLER_76_294 VPWR VGND sg13g2_decap_4
XFILLER_64_445 VPWR VGND sg13g2_decap_8
XFILLER_18_851 VPWR VGND sg13g2_fill_1
X_14807_ _06092_ _06093_ _06094_ VPWR VGND sg13g2_nor2_1
XFILLER_64_478 VPWR VGND sg13g2_decap_8
X_18575_ VGND VPWR _09683_ _09684_ _00326_ net921 sg13g2_a21oi_1
X_15787_ _07037_ u_FIR.sum\[6\]\[10\] net392 VPWR VGND sg13g2_nand2_1
X_12999_ VGND VPWR net545 _04354_ _00079_ _04355_ sg13g2_a21oi_1
XFILLER_73_990 VPWR VGND sg13g2_fill_2
XFILLER_51_117 VPWR VGND sg13g2_decap_4
XFILLER_33_832 VPWR VGND sg13g2_decap_4
X_17526_ _08659_ _08636_ _08657_ VPWR VGND sg13g2_xnor2_1
X_14738_ _06027_ _06019_ _06025_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_320 VPWR VGND sg13g2_fill_1
XFILLER_33_865 VPWR VGND sg13g2_fill_1
X_17457_ _08590_ net687 net129 VPWR VGND sg13g2_nand2_1
X_14669_ _05929_ _05959_ _05960_ VPWR VGND sg13g2_and2_1
X_16408_ _07637_ _07638_ _07639_ VPWR VGND sg13g2_and2_1
X_17388_ _08535_ u_LMS.w\[0\]\[21\] net72 VPWR VGND sg13g2_xnor2_1
XFILLER_119_915 VPWR VGND sg13g2_fill_1
X_23009__1193 VPWR VGND net1192 sg13g2_tiehi
X_19127_ _10213_ VPWR _10214_ VGND _03331_ _10194_ sg13g2_o21ai_1
X_16339_ _07573_ _07551_ _07571_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_0 VPWR VGND sg13g2_decap_8
X_19058_ VGND VPWR _10143_ _10144_ _10145_ _09942_ sg13g2_a21oi_1
X_18009_ _09074_ VPWR _09133_ VGND _09073_ _09079_ sg13g2_o21ai_1
X_23437__1621 VPWR VGND net1620 sg13g2_tiehi
X_21020_ _01656_ _01659_ _01660_ VPWR VGND sg13g2_nor2_1
X_23481__1480 VPWR VGND net1479 sg13g2_tiehi
XFILLER_114_653 VPWR VGND sg13g2_decap_8
XFILLER_102_826 VPWR VGND sg13g2_fill_1
XFILLER_113_152 VPWR VGND sg13g2_fill_1
XFILLER_101_314 VPWR VGND sg13g2_decap_8
XFILLER_102_837 VPWR VGND sg13g2_decap_8
X_23488__1456 VPWR VGND net1455 sg13g2_tiehi
XFILLER_132_1052 VPWR VGND sg13g2_decap_8
X_21922_ _02477_ _02481_ _02516_ VPWR VGND sg13g2_xor2_1
XFILLER_83_743 VPWR VGND sg13g2_fill_1
XFILLER_82_231 VPWR VGND sg13g2_decap_8
XFILLER_27_136 VPWR VGND sg13g2_fill_2
XFILLER_82_242 VPWR VGND sg13g2_fill_2
X_21853_ _02447_ net115 _02445_ VPWR VGND sg13g2_xnor2_1
X_20804_ _01444_ _01439_ _01443_ VPWR VGND sg13g2_xnor2_1
X_21784_ _02355_ net115 _02353_ _02378_ VPWR VGND sg13g2_nand3_1
XFILLER_24_854 VPWR VGND sg13g2_decap_8
X_23523_ net1324 VGND VPWR _00585_ u_LMS.count\[26\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
X_20735_ _01373_ _01374_ _01375_ VPWR VGND sg13g2_nor2_1
XFILLER_11_526 VPWR VGND sg13g2_fill_2
X_23454_ net1569 VGND VPWR _00516_ u_LMS.x_r\[3\]\[5\] clknet_leaf_65_clkA sg13g2_dfrbpq_1
X_20666_ _01306_ net610 net227 VPWR VGND sg13g2_nand2_1
XFILLER_13_1004 VPWR VGND sg13g2_fill_2
XFILLER_109_414 VPWR VGND sg13g2_fill_1
X_22405_ net947 VPWR _02952_ VGND net434 net667 sg13g2_o21ai_1
XFILLER_109_425 VPWR VGND sg13g2_fill_2
XFILLER_109_436 VPWR VGND sg13g2_fill_2
X_20597_ _01237_ _01215_ _01217_ _01234_ VPWR VGND sg13g2_and3_1
X_23385_ net1193 VGND VPWR _00447_ u_LMS.w\[7\]\[18\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
XFILLER_109_447 VPWR VGND sg13g2_fill_2
XFILLER_100_1007 VPWR VGND sg13g2_decap_8
X_22336_ _02911_ _02912_ _00481_ VPWR VGND sg13g2_nor2_1
XFILLER_3_703 VPWR VGND sg13g2_fill_2
XFILLER_124_428 VPWR VGND sg13g2_decap_4
XFILLER_3_736 VPWR VGND sg13g2_decap_4
X_22267_ _02858_ _02819_ _02857_ VPWR VGND sg13g2_xnor2_1
X_12020_ _03415_ net326 _03437_ VPWR VGND sg13g2_nor2_1
XFILLER_3_769 VPWR VGND sg13g2_fill_1
X_21218_ _01831_ _01834_ _01835_ VPWR VGND sg13g2_nor2_1
X_22198_ _02792_ _03295_ _02779_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_450 VPWR VGND sg13g2_fill_2
XFILLER_2_268 VPWR VGND sg13g2_decap_8
X_21149_ _01765_ _01755_ _01766_ VPWR VGND sg13g2_xor2_1
XFILLER_132_494 VPWR VGND sg13g2_decap_8
Xfanout550 u_FIR.i_enable net550 VPWR VGND sg13g2_buf_1
XFILLER_120_656 VPWR VGND sg13g2_fill_2
Xfanout561 net569 net561 VPWR VGND sg13g2_buf_1
Xfanout572 net574 net572 VPWR VGND sg13g2_buf_1
Xfanout583 u_LMS.x_r\[8\]\[2\] net583 VPWR VGND sg13g2_buf_1
X_13971_ _05288_ _05284_ _05289_ VPWR VGND sg13g2_xor2_1
XFILLER_19_615 VPWR VGND sg13g2_decap_8
Xfanout594 u_LMS.x_r\[7\]\[5\] net594 VPWR VGND sg13g2_buf_1
X_15710_ _06962_ u_FIR.sum\[6\]\[8\] net392 VPWR VGND sg13g2_xnor2_1
XFILLER_18_103 VPWR VGND sg13g2_decap_8
X_12922_ _04278_ VPWR _04281_ VGND _04249_ _04275_ sg13g2_o21ai_1
XFILLER_20_1008 VPWR VGND sg13g2_fill_2
X_16690_ VGND VPWR u_LMS.w\[7\]\[14\] _07852_ _07858_ _07853_ sg13g2_a21oi_1
XFILLER_46_434 VPWR VGND sg13g2_fill_2
XFILLER_47_979 VPWR VGND sg13g2_fill_1
XFILLER_73_242 VPWR VGND sg13g2_decap_4
X_15641_ net979 VPWR _06895_ VGND net483 u_FIR.sum\[7\]\[6\] sg13g2_o21ai_1
XFILLER_62_916 VPWR VGND sg13g2_decap_4
X_12853_ _04183_ _04213_ net814 _04214_ VPWR VGND sg13g2_nand3_1
XFILLER_15_821 VPWR VGND sg13g2_fill_2
X_18360_ VGND VPWR _09454_ _09461_ _09470_ _09469_ sg13g2_a21oi_1
X_11804_ VPWR _03225_ net586 VGND sg13g2_inv_1
XFILLER_15_832 VPWR VGND sg13g2_fill_2
X_15572_ _06827_ net899 u_FIR.w\[1\]\[5\] net887 net786 VPWR VGND sg13g2_a22oi_1
XFILLER_33_139 VPWR VGND sg13g2_decap_8
X_12784_ _04147_ _04146_ _04144_ VPWR VGND sg13g2_nand2b_1
XFILLER_42_640 VPWR VGND sg13g2_fill_2
X_17311_ VGND VPWR _08464_ _08465_ _08467_ _08409_ sg13g2_a21oi_1
XFILLER_70_960 VPWR VGND sg13g2_decap_8
X_14523_ _05818_ _05809_ _05816_ VPWR VGND sg13g2_xnor2_1
X_18291_ _09401_ _09375_ _09376_ VPWR VGND sg13g2_xnor2_1
X_17242_ _08398_ _08096_ _08097_ VPWR VGND sg13g2_xnor2_1
X_14454_ _05754_ net400 u_FIR.sum\[3\]\[17\] VPWR VGND sg13g2_nand2b_1
XFILLER_30_868 VPWR VGND sg13g2_fill_1
X_13405_ _04747_ _04643_ _04745_ VPWR VGND sg13g2_xnor2_1
X_17173_ _08329_ _08328_ _08320_ VPWR VGND sg13g2_nand2b_1
X_14385_ _05666_ _05688_ _05689_ VPWR VGND sg13g2_nor2_1
XFILLER_127_222 VPWR VGND sg13g2_decap_8
X_16124_ VGND VPWR _07327_ _07356_ _07363_ _07355_ sg13g2_a21oi_1
X_13336_ u_FIR.w\[6\]\[4\] net813 _04680_ VPWR VGND sg13g2_and2_1
XFILLER_41_80 VPWR VGND sg13g2_decap_8
XFILLER_41_91 VPWR VGND sg13g2_fill_2
XFILLER_109_992 VPWR VGND sg13g2_decap_8
XFILLER_127_288 VPWR VGND sg13g2_fill_1
X_16055_ _07296_ net900 net794 net887 net795 VPWR VGND sg13g2_a22oi_1
X_13267_ _04607_ _04612_ _04613_ VPWR VGND sg13g2_nor2b_1
XFILLER_29_1000 VPWR VGND sg13g2_decap_4
XFILLER_68_1060 VPWR VGND sg13g2_fill_1
X_15006_ _06283_ _06277_ _06282_ VPWR VGND sg13g2_xnor2_1
X_12218_ _03602_ net727 net882 _03601_ VPWR VGND sg13g2_and3_1
XFILLER_69_504 VPWR VGND sg13g2_decap_8
X_13198_ _04545_ _04537_ _04546_ VPWR VGND sg13g2_xor2_1
X_19814_ _10810_ _10872_ _10873_ VPWR VGND sg13g2_nor2b_1
XFILLER_111_634 VPWR VGND sg13g2_fill_1
X_12149_ _03558_ net287 coeff_force_packed\[28\] net288 coeff_force_packed\[56\] VPWR
+ VGND sg13g2_a22oi_1
XFILLER_97_879 VPWR VGND sg13g2_fill_1
XFILLER_110_133 VPWR VGND sg13g2_decap_4
XFILLER_96_367 VPWR VGND sg13g2_fill_1
X_19745_ _10809_ u_LMS.w\[4\]\[17\] _10740_ VPWR VGND sg13g2_xnor2_1
X_16957_ _08113_ net708 net134 VPWR VGND sg13g2_nand2_1
XFILLER_96_389 VPWR VGND sg13g2_fill_1
XFILLER_49_250 VPWR VGND sg13g2_fill_1
XFILLER_2_63 VPWR VGND sg13g2_decap_8
X_15908_ _07154_ _07131_ _07152_ VPWR VGND sg13g2_xnor2_1
X_19676_ _10740_ _10434_ _10739_ VPWR VGND sg13g2_xnor2_1
X_16888_ _08044_ _08043_ _08025_ VPWR VGND sg13g2_nand2b_1
XFILLER_65_754 VPWR VGND sg13g2_decap_8
XFILLER_80_702 VPWR VGND sg13g2_fill_1
X_18627_ net321 VPWR _09725_ VGND u_LMS.w\[2\]\[24\] net69 sg13g2_o21ai_1
X_15839_ _07073_ VPWR _07087_ VGND net274 _07071_ sg13g2_o21ai_1
XFILLER_53_938 VPWR VGND sg13g2_fill_2
XFILLER_64_275 VPWR VGND sg13g2_fill_2
XFILLER_80_757 VPWR VGND sg13g2_decap_8
X_18558_ VGND VPWR _09658_ _09661_ _09668_ _09667_ sg13g2_a21oi_1
XFILLER_17_191 VPWR VGND sg13g2_fill_1
X_23304__1298 VPWR VGND net1297 sg13g2_tiehi
X_17509_ _08642_ _08635_ _08641_ VPWR VGND sg13g2_nand2_1
XFILLER_61_971 VPWR VGND sg13g2_fill_1
XFILLER_33_673 VPWR VGND sg13g2_decap_4
XFILLER_21_813 VPWR VGND sg13g2_decap_4
X_18489_ _03342_ _09598_ _09599_ VPWR VGND sg13g2_nor2_1
XFILLER_61_993 VPWR VGND sg13g2_decap_8
XFILLER_60_470 VPWR VGND sg13g2_fill_1
XFILLER_20_312 VPWR VGND sg13g2_decap_8
X_20520_ _01160_ _01155_ _01158_ VPWR VGND sg13g2_xnor2_1
X_20451_ VGND VPWR _01053_ _01059_ _01105_ _01054_ sg13g2_a21oi_1
X_20382_ VGND VPWR _01042_ _01044_ _01045_ _00977_ sg13g2_a21oi_1
X_23170_ net1533 VGND VPWR _00232_ u_FIR.w\[2\]\[1\] clknet_leaf_51_clkA sg13g2_dfrbpq_1
XFILLER_119_778 VPWR VGND sg13g2_decap_8
X_22121_ _02713_ _02714_ _02715_ VPWR VGND sg13g2_nor2_1
X_22052_ _02646_ _02644_ _02645_ VPWR VGND sg13g2_nand2_1
XFILLER_115_973 VPWR VGND sg13g2_decap_4
XFILLER_0_717 VPWR VGND sg13g2_decap_4
XFILLER_99_150 VPWR VGND sg13g2_decap_8
XFILLER_88_835 VPWR VGND sg13g2_decap_8
X_21003_ _01643_ u_LMS.w\[6\]\[20\] net73 VPWR VGND sg13g2_nand2_1
XFILLER_99_183 VPWR VGND sg13g2_decap_4
XFILLER_102_645 VPWR VGND sg13g2_fill_1
XFILLER_88_868 VPWR VGND sg13g2_decap_4
XFILLER_56_732 VPWR VGND sg13g2_fill_1
X_22954_ _07692_ VPWR _00811_ VGND _03290_ net525 sg13g2_o21ai_1
XFILLER_46_36 VPWR VGND sg13g2_decap_8
XFILLER_28_434 VPWR VGND sg13g2_decap_8
XFILLER_56_765 VPWR VGND sg13g2_decap_4
XFILLER_83_551 VPWR VGND sg13g2_fill_1
XFILLER_55_242 VPWR VGND sg13g2_decap_4
X_21905_ _02499_ net580 net167 VPWR VGND sg13g2_nand2_1
X_22885_ _00772_ u_s2p_input.reg_cnt\[2\] net1028 _03170_ VPWR VGND sg13g2_and3_1
XFILLER_83_595 VPWR VGND sg13g2_decap_8
XFILLER_70_223 VPWR VGND sg13g2_fill_1
XFILLER_102_53 VPWR VGND sg13g2_decap_8
X_21836_ _02426_ _02429_ _02430_ VPWR VGND sg13g2_nor2_1
XFILLER_102_64 VPWR VGND sg13g2_fill_1
XFILLER_71_779 VPWR VGND sg13g2_decap_8
XFILLER_24_651 VPWR VGND sg13g2_decap_8
XFILLER_62_46 VPWR VGND sg13g2_decap_8
X_21767_ _02360_ _02349_ _02361_ VPWR VGND sg13g2_xor2_1
X_23506_ net1391 VGND VPWR _00568_ u_LMS.count\[9\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
X_20718_ _01356_ _01355_ _01358_ VPWR VGND sg13g2_xor2_1
X_21698_ VGND VPWR u_LMS.w\[7\]\[24\] net314 _02303_ _02276_ sg13g2_a21oi_1
X_23437_ net1620 VGND VPWR _00499_ u_LMS.x_r\[1\]\[4\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
X_20649_ _01279_ VPWR _01289_ VGND _01280_ _01288_ sg13g2_o21ai_1
XFILLER_109_222 VPWR VGND sg13g2_decap_4
X_14170_ _05478_ _05445_ _05480_ VPWR VGND sg13g2_xor2_1
XFILLER_109_266 VPWR VGND sg13g2_fill_2
X_23368_ net1233 VGND VPWR _00430_ u_LMS.w\[6\]\[24\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
X_22974__1638 VPWR net1637 clknet_3_7__leaf_spi_sclk VGND sg13g2_inv_1
X_13121_ _04471_ _04441_ _04470_ VPWR VGND sg13g2_nand2b_1
XFILLER_125_737 VPWR VGND sg13g2_fill_1
X_22319_ net357 VPWR _02900_ VGND u_LMS.w\[8\]\[2\] net374 sg13g2_o21ai_1
X_23299_ net1302 VGND VPWR _00361_ u_LMS.w\[3\]\[24\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
X_23129__1596 VPWR VGND net1595 sg13g2_tiehi
XFILLER_124_258 VPWR VGND sg13g2_decap_8
X_13052_ _04404_ _04398_ _04402_ VPWR VGND sg13g2_xnor2_1
XFILLER_79_813 VPWR VGND sg13g2_fill_2
XFILLER_105_461 VPWR VGND sg13g2_decap_8
XFILLER_3_577 VPWR VGND sg13g2_fill_2
X_12003_ _03420_ _03418_ u_debug_unit.mon_w2_sync\[6\] _03405_ u_debug_unit.mon_w5_sync\[6\]
+ VPWR VGND sg13g2_a22oi_1
X_17860_ _08993_ _08956_ _08957_ VPWR VGND sg13g2_xnor2_1
XFILLER_120_453 VPWR VGND sg13g2_decap_8
X_16811_ u_LMS.mu\[2\] VPWR _07967_ VGND _07965_ _07945_ sg13g2_o21ai_1
X_17791_ _08924_ _08921_ _08923_ VPWR VGND sg13g2_xnor2_1
Xfanout380 net385 net380 VPWR VGND sg13g2_buf_1
Xfanout391 _06921_ net391 VPWR VGND sg13g2_buf_1
X_19530_ _10594_ _10548_ _10555_ VPWR VGND sg13g2_xnor2_1
X_16742_ _07895_ _07897_ _07898_ VPWR VGND sg13g2_nor2_1
X_13954_ _05268_ _05272_ _05273_ VPWR VGND sg13g2_nor2_1
XFILLER_4_1046 VPWR VGND sg13g2_decap_8
XFILLER_47_754 VPWR VGND sg13g2_fill_1
X_12905_ _04183_ _04216_ _04265_ VPWR VGND sg13g2_and2_1
X_19461_ _10517_ VPWR _10525_ VGND _10518_ _10524_ sg13g2_o21ai_1
X_16673_ net1036 VPWR _07845_ VGND net538 net740 sg13g2_o21ai_1
X_13885_ _05206_ _05182_ _05208_ VPWR VGND sg13g2_xor2_1
XFILLER_34_415 VPWR VGND sg13g2_decap_8
X_18412_ _09522_ net254 net677 net238 net679 VPWR VGND sg13g2_a22oi_1
X_15624_ _06878_ net792 net818 u_FIR.sum\[6\]\[6\] VPWR VGND sg13g2_and3_1
X_12836_ _04198_ _04189_ _04196_ VPWR VGND sg13g2_xnor2_1
XFILLER_36_80 VPWR VGND sg13g2_fill_1
X_19392_ _10456_ net118 _10454_ VPWR VGND sg13g2_xnor2_1
X_18343_ VGND VPWR _09453_ _09452_ _09451_ sg13g2_or2_1
X_15555_ _06811_ _06773_ _06809_ VPWR VGND sg13g2_xnor2_1
X_12767_ _04127_ VPWR _04130_ VGND _04089_ _04124_ sg13g2_o21ai_1
XFILLER_42_470 VPWR VGND sg13g2_fill_1
XFILLER_70_790 VPWR VGND sg13g2_decap_4
X_14506_ _05800_ _05799_ _05802_ VPWR VGND sg13g2_xor2_1
X_18274_ VGND VPWR net2093 _09383_ _09384_ _09380_ sg13g2_a21oi_1
X_15486_ net900 net791 u_FIR.sum\[6\]\[0\] _06746_ VPWR VGND sg13g2_a21o_1
X_12698_ _04063_ net735 net843 VPWR VGND sg13g2_nand2_1
X_17225_ _08062_ VPWR _08381_ VGND _08027_ _08063_ sg13g2_o21ai_1
X_14437_ _05738_ _05715_ _05736_ VPWR VGND sg13g2_xnor2_1
X_17156_ net715 net231 net713 _08312_ VPWR VGND net212 sg13g2_nand4_1
X_14368_ _05606_ _05671_ _05672_ VPWR VGND sg13g2_nor2_1
X_16107_ VGND VPWR net802 net817 _07347_ u_FIR.sum\[7\]\[6\] sg13g2_a21oi_1
X_13319_ _04656_ _04663_ _04664_ VPWR VGND sg13g2_nor2b_1
X_17087_ _08243_ _08018_ _08154_ VPWR VGND sg13g2_xnor2_1
X_14299_ _05605_ _05574_ _05577_ VPWR VGND sg13g2_nand2_1
XFILLER_103_409 VPWR VGND sg13g2_fill_1
X_16038_ _07279_ _07276_ _07278_ VPWR VGND sg13g2_nand2_1
XFILLER_131_729 VPWR VGND sg13g2_fill_1
XFILLER_112_921 VPWR VGND sg13g2_fill_1
XFILLER_97_632 VPWR VGND sg13g2_fill_2
XFILLER_124_792 VPWR VGND sg13g2_fill_1
XFILLER_111_431 VPWR VGND sg13g2_fill_1
XFILLER_96_120 VPWR VGND sg13g2_decap_8
XFILLER_96_153 VPWR VGND sg13g2_decap_4
XFILLER_28_0 VPWR VGND sg13g2_decap_8
XFILLER_97_687 VPWR VGND sg13g2_decap_8
XFILLER_111_475 VPWR VGND sg13g2_fill_2
X_17989_ net40 VPWR _09117_ VGND net38 _09116_ sg13g2_o21ai_1
XFILLER_96_186 VPWR VGND sg13g2_decap_4
XFILLER_78_890 VPWR VGND sg13g2_decap_8
X_19728_ _10760_ VPWR _10792_ VGND _10789_ _10790_ sg13g2_o21ai_1
XFILLER_93_860 VPWR VGND sg13g2_decap_8
XFILLER_26_905 VPWR VGND sg13g2_fill_1
X_19659_ _10625_ _10624_ _10723_ VPWR VGND sg13g2_xor2_1
XFILLER_25_415 VPWR VGND sg13g2_decap_8
XFILLER_37_297 VPWR VGND sg13g2_decap_8
X_22670_ coeff_force_packed\[40\] net463 _03066_ _00661_ VPWR VGND sg13g2_mux2_1
XFILLER_52_245 VPWR VGND sg13g2_decap_8
X_21621_ _02237_ VPWR _02238_ VGND _02232_ _02156_ sg13g2_o21ai_1
X_21552_ _02169_ u_LMS.w\[7\]\[13\] _02168_ VPWR VGND sg13g2_nand2_1
XFILLER_20_131 VPWR VGND sg13g2_fill_1
X_20503_ VGND VPWR net51 _01144_ _01145_ net19 sg13g2_a21oi_1
X_21483_ _02100_ _02074_ _02076_ VPWR VGND sg13g2_xnor2_1
X_23222_ net1441 VGND VPWR _00284_ u_LMS.w\[0\]\[16\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
X_20434_ VGND VPWR _01090_ _01091_ _00400_ net941 sg13g2_a21oi_1
X_23153_ net1559 VGND VPWR _00215_ u_FIR.x_reg\[6\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
XFILLER_106_236 VPWR VGND sg13g2_fill_2
XFILLER_107_759 VPWR VGND sg13g2_decap_4
X_20365_ VGND VPWR _00990_ _01028_ _01026_ _01025_ sg13g2_a21oi_2
XFILLER_122_707 VPWR VGND sg13g2_fill_2
X_22104_ _02672_ _02671_ _02698_ VPWR VGND sg13g2_xor2_1
X_20296_ VGND VPWR _10984_ _11020_ _00959_ _11019_ sg13g2_a21oi_1
X_23084_ net1080 VGND VPWR _00146_ u_FIR.sum\[5\]\[8\] clknet_leaf_42_clkA sg13g2_dfrbpq_1
XFILLER_122_729 VPWR VGND sg13g2_decap_4
XFILLER_103_921 VPWR VGND sg13g2_fill_1
XFILLER_0_536 VPWR VGND sg13g2_decap_8
X_22035_ _02622_ VPWR _02629_ VGND net2204 _02623_ sg13g2_o21ai_1
XFILLER_121_239 VPWR VGND sg13g2_decap_8
XFILLER_87_131 VPWR VGND sg13g2_fill_2
XFILLER_88_665 VPWR VGND sg13g2_fill_2
XFILLER_87_142 VPWR VGND sg13g2_fill_2
XFILLER_76_805 VPWR VGND sg13g2_fill_1
XFILLER_57_24 VPWR VGND sg13g2_decap_8
XFILLER_102_464 VPWR VGND sg13g2_fill_1
XFILLER_130_773 VPWR VGND sg13g2_fill_2
XFILLER_69_890 VPWR VGND sg13g2_fill_1
XFILLER_87_197 VPWR VGND sg13g2_fill_2
XFILLER_75_359 VPWR VGND sg13g2_fill_2
X_22937_ spi_addr\[4\] net324 _03199_ VPWR VGND sg13g2_nor2_1
XFILLER_84_882 VPWR VGND sg13g2_fill_2
XFILLER_113_63 VPWR VGND sg13g2_fill_1
XFILLER_28_286 VPWR VGND sg13g2_fill_1
XFILLER_73_34 VPWR VGND sg13g2_decap_8
XFILLER_16_437 VPWR VGND sg13g2_fill_2
X_13670_ _04997_ _04961_ _04999_ VPWR VGND sg13g2_xor2_1
XFILLER_44_757 VPWR VGND sg13g2_fill_2
X_22868_ _07947_ _03138_ _03159_ VPWR VGND sg13g2_nor2_1
XFILLER_71_554 VPWR VGND sg13g2_decap_8
XFILLER_32_908 VPWR VGND sg13g2_fill_1
X_12621_ net1037 VPWR _03989_ VGND net540 u_FIR.sum\[1\]\[3\] sg13g2_o21ai_1
X_21819_ _02413_ _02406_ _02412_ VPWR VGND sg13g2_nand2_1
XFILLER_71_598 VPWR VGND sg13g2_decap_4
XFILLER_31_429 VPWR VGND sg13g2_decap_4
X_22799_ VGND VPWR _07836_ net350 _00739_ _03117_ sg13g2_a21oi_1
X_15340_ _06582_ VPWR _06607_ VGND net250 _06583_ sg13g2_o21ai_1
XFILLER_24_492 VPWR VGND sg13g2_fill_2
X_12552_ _03925_ _03862_ _03924_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_306 VPWR VGND sg13g2_fill_1
XFILLER_11_120 VPWR VGND sg13g2_fill_1
XFILLER_8_614 VPWR VGND sg13g2_decap_4
XFILLER_132_0 VPWR VGND sg13g2_decap_8
X_15271_ _06540_ _06498_ _06501_ VPWR VGND sg13g2_nand2_1
X_23450__1582 VPWR VGND net1581 sg13g2_tiehi
X_12483_ _03844_ VPWR _03858_ VGND _03827_ _03845_ sg13g2_o21ai_1
XFILLER_89_1008 VPWR VGND sg13g2_fill_1
X_17010_ _08166_ net710 net192 VPWR VGND sg13g2_nand2_1
X_14222_ _03365_ net863 _05530_ VPWR VGND sg13g2_nor2_1
XFILLER_22_60 VPWR VGND sg13g2_decap_4
X_14153_ _05457_ _05462_ _05463_ VPWR VGND sg13g2_nor2b_1
XFILLER_125_545 VPWR VGND sg13g2_decap_8
XFILLER_4_842 VPWR VGND sg13g2_fill_2
XFILLER_98_53 VPWR VGND sg13g2_decap_4
X_13104_ _04454_ _04448_ _04452_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_567 VPWR VGND sg13g2_decap_8
X_18961_ _09980_ _10047_ _10048_ VPWR VGND sg13g2_nor2b_1
X_14084_ _05396_ _05387_ _05394_ VPWR VGND sg13g2_xnor2_1
X_17912_ VPWR VGND _09042_ _08987_ _09041_ u_LMS.w\[1\]\[15\] _09045_ _08984_ sg13g2_a221oi_1
X_13035_ _04372_ VPWR _04388_ VGND _04368_ _04373_ sg13g2_o21ai_1
XFILLER_79_632 VPWR VGND sg13g2_fill_2
X_18892_ _09979_ _09946_ _09947_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_751 VPWR VGND sg13g2_fill_1
X_17843_ _08976_ _08699_ _08975_ VPWR VGND sg13g2_nand2_1
XFILLER_66_315 VPWR VGND sg13g2_decap_8
XFILLER_121_795 VPWR VGND sg13g2_decap_8
XFILLER_120_272 VPWR VGND sg13g2_decap_8
XFILLER_93_112 VPWR VGND sg13g2_fill_2
X_17774_ _08907_ net699 net223 VPWR VGND sg13g2_nand2_1
X_14986_ _06264_ net782 net890 u_FIR.sum\[5\]\[1\] VPWR VGND sg13g2_and3_1
X_19513_ _10569_ _10576_ _10577_ VPWR VGND sg13g2_nor2b_1
X_16725_ VGND VPWR net528 _07882_ _00277_ _07883_ sg13g2_a21oi_1
X_13937_ _05257_ _05232_ _05255_ VPWR VGND sg13g2_xnor2_1
X_19444_ _03248_ net101 _10508_ VPWR VGND sg13g2_nor2_1
XFILLER_34_234 VPWR VGND sg13g2_fill_2
X_16656_ u_LMS.w\[6\]\[24\] _07832_ _07833_ VPWR VGND sg13g2_nor2_1
X_13868_ _05187_ _05189_ _05191_ VPWR VGND sg13g2_nor2_1
XFILLER_62_565 VPWR VGND sg13g2_fill_2
X_15607_ _06861_ net786 net873 VPWR VGND sg13g2_nand2_1
X_12819_ _04181_ _04173_ _04180_ VPWR VGND sg13g2_xnor2_1
X_19375_ VGND VPWR net641 net188 _10439_ _10435_ sg13g2_a21oi_1
XFILLER_22_429 VPWR VGND sg13g2_fill_2
X_16587_ net983 VPWR _07782_ VGND net489 net770 sg13g2_o21ai_1
X_13799_ _05124_ u_FIR.w\[5\]\[6\] net839 VPWR VGND sg13g2_nand2b_1
XFILLER_43_790 VPWR VGND sg13g2_fill_1
XFILLER_15_481 VPWR VGND sg13g2_decap_8
XFILLER_72_1034 VPWR VGND sg13g2_fill_2
X_18326_ _09434_ _09433_ _09436_ VPWR VGND sg13g2_xor2_1
X_15538_ VGND VPWR _06758_ _06777_ _06794_ _06776_ sg13g2_a21oi_1
XFILLER_72_1056 VPWR VGND sg13g2_decap_4
XFILLER_33_1007 VPWR VGND sg13g2_fill_1
XFILLER_30_440 VPWR VGND sg13g2_fill_1
X_18257_ _09367_ net669 net251 VPWR VGND sg13g2_nand2_1
X_15469_ _06731_ _06719_ _06730_ VPWR VGND sg13g2_xnor2_1
X_17208_ _08361_ _08360_ _08364_ VPWR VGND sg13g2_xor2_1
X_18188_ _09298_ _09297_ _09295_ VPWR VGND sg13g2_nand2b_1
X_17139_ _08271_ _08262_ _08295_ VPWR VGND sg13g2_xor2_1
X_20150_ _11191_ net628 net213 VPWR VGND sg13g2_nand2_1
XFILLER_131_526 VPWR VGND sg13g2_decap_8
XFILLER_103_239 VPWR VGND sg13g2_decap_4
X_20081_ _11091_ _11121_ _11122_ VPWR VGND sg13g2_nor2b_1
Xrebuffer1646 _07974_ net1645 VPWR VGND sg13g2_buf_1
Xrebuffer1657 _09438_ net1656 VPWR VGND sg13g2_buf_1
Xrebuffer1668 _01031_ net1667 VPWR VGND sg13g2_buf_2
XFILLER_112_795 VPWR VGND sg13g2_decap_4
XFILLER_84_145 VPWR VGND sg13g2_fill_1
XFILLER_73_819 VPWR VGND sg13g2_fill_1
X_23771_ net994 VGND VPWR _00004_ u_spi_slave.rx_shift\[13\] clknet_3_3__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_20983_ _01581_ u_LMS.w\[6\]\[11\] _01623_ VPWR VGND sg13g2_xor2_1
X_22973__1637 VPWR net1636 clknet_3_7__leaf_spi_sclk VGND sg13g2_inv_1
X_22722_ u_debug_unit.mon_w0_sync\[5\] net349 _03079_ VPWR VGND sg13g2_nor2_1
XFILLER_129_1035 VPWR VGND sg13g2_decap_8
XFILLER_53_576 VPWR VGND sg13g2_fill_2
XFILLER_41_716 VPWR VGND sg13g2_fill_1
X_22653_ net460 coeff_force_packed\[27\] _03064_ _00646_ VPWR VGND sg13g2_mux2_1
X_21604_ _02169_ VPWR _02221_ VGND _02220_ _02219_ sg13g2_o21ai_1
XFILLER_22_941 VPWR VGND sg13g2_decap_8
X_22584_ _03054_ net950 _03053_ VPWR VGND sg13g2_nand2_1
XFILLER_22_985 VPWR VGND sg13g2_fill_1
X_21535_ _02152_ _02143_ _02151_ VPWR VGND sg13g2_xnor2_1
X_21466_ _02083_ net602 net211 VPWR VGND sg13g2_nand2_1
XFILLER_4_105 VPWR VGND sg13g2_decap_8
X_23205_ net1471 VGND VPWR _00267_ u_FIR.w\[7\]\[1\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
XFILLER_107_534 VPWR VGND sg13g2_decap_8
X_20417_ _01079_ net315 u_LMS.w\[5\]\[13\] coeff_force_packed\[36\] net564 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_49_1003 VPWR VGND sg13g2_fill_1
X_21397_ _02014_ net599 net244 VPWR VGND sg13g2_nand2_1
XFILLER_107_567 VPWR VGND sg13g2_decap_8
X_23136_ net1585 VGND VPWR _00198_ u_FIR.sum\[8\]\[8\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
X_20348_ _01011_ _03314_ _00998_ VPWR VGND sg13g2_xnor2_1
X_23067_ net1105 VGND VPWR _00129_ u_FIR.sum\[4\]\[10\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
X_20279_ _00942_ _00940_ _00941_ VPWR VGND sg13g2_nand2b_1
XFILLER_0_344 VPWR VGND sg13g2_decap_8
X_22018_ _02611_ _02523_ _02612_ VPWR VGND sg13g2_xor2_1
X_23514__1361 VPWR VGND net1360 sg13g2_tiehi
XFILLER_0_399 VPWR VGND sg13g2_decap_8
X_23271__1352 VPWR VGND net1351 sg13g2_tiehi
X_14840_ _06126_ _06125_ _06124_ VPWR VGND sg13g2_nand2b_1
XFILLER_75_134 VPWR VGND sg13g2_decap_4
XFILLER_57_871 VPWR VGND sg13g2_decap_8
X_14771_ net837 _06058_ net767 _06059_ VPWR VGND sg13g2_nand3_1
XFILLER_95_1001 VPWR VGND sg13g2_fill_2
X_11983_ net327 _03399_ _03400_ VPWR VGND sg13g2_nor2_1
XFILLER_1_1038 VPWR VGND sg13g2_decap_8
X_16510_ VGND VPWR net483 _07723_ _00221_ _07724_ sg13g2_a21oi_1
X_13722_ net852 net748 _05047_ _05049_ VPWR VGND sg13g2_a21o_1
XFILLER_44_532 VPWR VGND sg13g2_fill_2
XFILLER_17_60 VPWR VGND sg13g2_decap_4
X_17490_ net148 VPWR _08623_ VGND net698 net700 sg13g2_o21ai_1
XFILLER_71_351 VPWR VGND sg13g2_fill_1
X_16441_ _07669_ net270 _07670_ VPWR VGND sg13g2_xor2_1
X_13653_ _04982_ _04965_ _04981_ VPWR VGND sg13g2_nand2_1
XFILLER_72_896 VPWR VGND sg13g2_decap_4
XFILLER_71_395 VPWR VGND sg13g2_decap_8
X_12604_ _03953_ _03971_ _03972_ VPWR VGND sg13g2_nor2_1
X_19160_ _10247_ u_LMS.w\[3\]\[20\] net68 VPWR VGND sg13g2_nand2_1
X_16372_ _07603_ _07581_ _07605_ VPWR VGND sg13g2_xor2_1
X_13584_ _04913_ _04877_ _04915_ VPWR VGND sg13g2_xor2_1
XFILLER_9_923 VPWR VGND sg13g2_fill_2
XFILLER_8_400 VPWR VGND sg13g2_fill_2
X_18111_ VGND VPWR _09190_ _09199_ _09221_ net120 sg13g2_a21oi_1
X_15323_ _06591_ _06590_ _06554_ VPWR VGND sg13g2_nand2b_1
XFILLER_8_411 VPWR VGND sg13g2_fill_2
X_12535_ _03909_ _03883_ _03886_ _03908_ VPWR VGND sg13g2_and3_1
X_19091_ u_LMS.w\[3\]\[15\] _10177_ _10178_ VPWR VGND sg13g2_nor2_1
X_18042_ VPWR VGND _09158_ _08554_ net37 _03346_ _00319_ net369 sg13g2_a221oi_1
X_15254_ _06524_ _06492_ _06523_ VPWR VGND sg13g2_xnor2_1
X_12466_ _03842_ _03833_ _03840_ VPWR VGND sg13g2_xnor2_1
XFILLER_126_810 VPWR VGND sg13g2_decap_8
XFILLER_69_7 VPWR VGND sg13g2_fill_2
X_14205_ _05514_ _05506_ _05513_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_499 VPWR VGND sg13g2_decap_8
X_15185_ _06456_ net777 net848 VPWR VGND sg13g2_nand2_1
XFILLER_125_320 VPWR VGND sg13g2_decap_4
X_12397_ _03757_ _03774_ _03775_ VPWR VGND sg13g2_nor2b_1
X_14136_ _05431_ VPWR _05446_ VGND _05425_ _05429_ sg13g2_o21ai_1
X_19993_ _10939_ _10937_ _11034_ VPWR VGND sg13g2_xor2_1
XFILLER_113_526 VPWR VGND sg13g2_decap_8
XFILLER_125_397 VPWR VGND sg13g2_fill_2
X_18944_ VGND VPWR _10024_ _10030_ _10031_ _10023_ sg13g2_a21oi_1
X_14067_ _05379_ net762 net863 VPWR VGND sg13g2_nand2_1
X_13018_ _04372_ _04371_ _04364_ VPWR VGND sg13g2_nand2b_1
XFILLER_95_911 VPWR VGND sg13g2_fill_1
XFILLER_67_602 VPWR VGND sg13g2_decap_8
X_18875_ _03257_ _03258_ net99 _09962_ VGND VPWR net91 sg13g2_nor4_2
XFILLER_67_635 VPWR VGND sg13g2_decap_8
X_17826_ _08857_ VPWR _08959_ VGND _08956_ _08958_ sg13g2_o21ai_1
XFILLER_39_359 VPWR VGND sg13g2_fill_2
XFILLER_94_465 VPWR VGND sg13g2_fill_2
X_17757_ _08889_ VPWR _08890_ VGND _08860_ _08887_ sg13g2_o21ai_1
X_14969_ VGND VPWR net510 _06248_ _00155_ _06249_ sg13g2_a21oi_1
XFILLER_63_830 VPWR VGND sg13g2_fill_2
XFILLER_35_521 VPWR VGND sg13g2_fill_1
X_16708_ _07871_ _07869_ _07870_ VPWR VGND sg13g2_nand2_1
X_17688_ _08816_ _08820_ _08821_ VPWR VGND sg13g2_nor2b_1
X_19427_ _10488_ net118 _10491_ VPWR VGND sg13g2_xor2_1
XFILLER_35_587 VPWR VGND sg13g2_decap_8
XFILLER_23_727 VPWR VGND sg13g2_decap_8
X_16639_ VGND VPWR u_LMS.w\[5\]\[15\] _07812_ _07820_ _07813_ sg13g2_a21oi_1
Xfanout19 _01119_ net19 VPWR VGND sg13g2_buf_2
XFILLER_22_215 VPWR VGND sg13g2_decap_4
XFILLER_95_0 VPWR VGND sg13g2_decap_8
X_19358_ _10400_ _10421_ _10422_ VPWR VGND sg13g2_nor2b_1
XFILLER_13_29 VPWR VGND sg13g2_fill_2
X_18309_ _09419_ _09415_ _09416_ VPWR VGND sg13g2_xnor2_1
X_19289_ _10353_ net641 net132 VPWR VGND sg13g2_nand2_1
X_21320_ _01937_ _01936_ _01935_ VPWR VGND sg13g2_nand2b_1
XFILLER_129_670 VPWR VGND sg13g2_fill_2
X_21251_ _01868_ _01867_ _01863_ VPWR VGND sg13g2_nand2b_1
XFILLER_128_191 VPWR VGND sg13g2_fill_1
Xrebuffer2100 _09567_ net2099 VPWR VGND sg13g2_buf_1
XFILLER_117_876 VPWR VGND sg13g2_fill_1
X_20202_ _00863_ _00864_ _00865_ VPWR VGND sg13g2_nor2b_1
Xrebuffer2122 _00824_ net2121 VPWR VGND sg13g2_buf_1
XFILLER_89_204 VPWR VGND sg13g2_fill_1
X_21182_ _01797_ _01798_ _01799_ VPWR VGND sg13g2_nor2b_1
Xrebuffer2133 _00930_ net2132 VPWR VGND sg13g2_buf_1
XFILLER_1_119 VPWR VGND sg13g2_decap_8
Xrebuffer2144 _02251_ net2143 VPWR VGND sg13g2_buf_1
XFILLER_89_226 VPWR VGND sg13g2_decap_4
Xrebuffer2155 _02245_ net2154 VPWR VGND sg13g2_buf_1
X_20133_ VGND VPWR _11170_ _11171_ _11174_ _11173_ sg13g2_a21oi_1
Xfanout902 net903 net902 VPWR VGND sg13g2_buf_1
Xrebuffer2166 _02811_ net2165 VPWR VGND sg13g2_buf_1
Xfanout913 u_LMS.mu\[4\] net913 VPWR VGND sg13g2_buf_1
Xrebuffer2177 net2177 net2176 VPWR VGND sg13g2_buf_1
Xfanout924 net925 net924 VPWR VGND sg13g2_buf_1
XFILLER_131_367 VPWR VGND sg13g2_decap_8
Xfanout935 net942 net935 VPWR VGND sg13g2_buf_1
Xrebuffer2199 net124 net2198 VPWR VGND sg13g2_buf_1
X_20064_ _11103_ _11100_ _11105_ VPWR VGND sg13g2_xor2_1
Xfanout946 net3 net946 VPWR VGND sg13g2_buf_1
Xfanout957 net1043 net957 VPWR VGND sg13g2_buf_1
XFILLER_38_26 VPWR VGND sg13g2_fill_1
Xfanout968 net969 net968 VPWR VGND sg13g2_buf_1
Xfanout979 net1000 net979 VPWR VGND sg13g2_buf_1
XFILLER_85_432 VPWR VGND sg13g2_decap_4
XFILLER_58_646 VPWR VGND sg13g2_decap_8
XFILLER_57_156 VPWR VGND sg13g2_fill_2
X_23754_ net1338 VGND VPWR _00816_ u_LMS.x\[5\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
X_20966_ _01592_ _01605_ _01606_ VPWR VGND sg13g2_nor2_1
XFILLER_53_340 VPWR VGND sg13g2_fill_2
XFILLER_14_705 VPWR VGND sg13g2_fill_2
X_22705_ u_debug_unit.error_signal_sync\[3\] net1657 net332 _00691_ VPWR VGND sg13g2_mux2_1
XFILLER_54_896 VPWR VGND sg13g2_decap_8
X_23685_ net1020 VGND VPWR _00747_ u_debug_unit.mon_w7_sync\[2\] clknet_leaf_35_clkA
+ sg13g2_dfrbpq_1
X_20897_ VGND VPWR _01535_ _01536_ _01537_ _01334_ sg13g2_a21oi_1
XFILLER_80_181 VPWR VGND sg13g2_decap_8
XFILLER_13_237 VPWR VGND sg13g2_fill_1
XFILLER_80_192 VPWR VGND sg13g2_fill_1
X_22636_ net458 u_debug_unit.force_w1\[7\] _03062_ _00631_ VPWR VGND sg13g2_mux2_1
XFILLER_9_219 VPWR VGND sg13g2_fill_2
XFILLER_41_579 VPWR VGND sg13g2_decap_8
X_22567_ net917 _03041_ _03042_ _00582_ VPWR VGND sg13g2_nor3_1
X_12320_ _03699_ _03698_ _03700_ VPWR VGND sg13g2_nor2b_1
XFILLER_127_618 VPWR VGND sg13g2_fill_1
X_21518_ VGND VPWR net2163 _02128_ _02135_ _02134_ sg13g2_a21oi_1
XFILLER_6_926 VPWR VGND sg13g2_decap_8
X_22498_ VGND VPWR net442 _03219_ _00557_ _02998_ sg13g2_a21oi_1
XFILLER_126_117 VPWR VGND sg13g2_fill_2
X_23317__1285 VPWR VGND net1284 sg13g2_tiehi
X_12251_ _03612_ VPWR _03633_ VGND _03611_ _03614_ sg13g2_o21ai_1
X_21449_ _02066_ _02062_ _02064_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_447 VPWR VGND sg13g2_fill_2
XFILLER_107_342 VPWR VGND sg13g2_fill_1
XFILLER_5_469 VPWR VGND sg13g2_fill_2
XFILLER_123_813 VPWR VGND sg13g2_decap_8
X_12182_ net944 u_spi_slave.rx_shift\[12\] _00004_ VPWR VGND sg13g2_nor2b_1
XFILLER_123_824 VPWR VGND sg13g2_fill_2
X_23119_ net1610 VGND VPWR _00181_ u_FIR.sum\[7\]\[5\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
XFILLER_96_708 VPWR VGND sg13g2_fill_2
X_16990_ _08144_ _08141_ _08146_ VPWR VGND sg13g2_xor2_1
X_15941_ _07169_ VPWR _07185_ VGND net273 _07167_ sg13g2_o21ai_1
XFILLER_62_1033 VPWR VGND sg13g2_fill_2
XFILLER_76_421 VPWR VGND sg13g2_fill_2
XFILLER_62_1055 VPWR VGND sg13g2_decap_4
XFILLER_131_890 VPWR VGND sg13g2_fill_1
XFILLER_77_955 VPWR VGND sg13g2_fill_2
XFILLER_77_966 VPWR VGND sg13g2_fill_1
X_18660_ _09750_ _09634_ _09636_ VPWR VGND sg13g2_xnor2_1
X_15872_ _07105_ VPWR _07119_ VGND net274 _07103_ sg13g2_o21ai_1
XFILLER_76_454 VPWR VGND sg13g2_fill_1
XFILLER_92_914 VPWR VGND sg13g2_decap_8
XFILLER_76_465 VPWR VGND sg13g2_fill_2
X_23192__1495 VPWR VGND net1494 sg13g2_tiehi
XFILLER_36_307 VPWR VGND sg13g2_decap_8
X_17611_ _08744_ _08711_ _08743_ VPWR VGND sg13g2_xnor2_1
X_14823_ _06088_ _06109_ _06110_ VPWR VGND sg13g2_nor2b_1
X_18591_ VGND VPWR _09695_ _09696_ _00330_ net921 sg13g2_a21oi_1
XFILLER_91_435 VPWR VGND sg13g2_decap_8
XFILLER_63_126 VPWR VGND sg13g2_decap_8
X_17542_ VGND VPWR net686 net184 _08675_ _08671_ sg13g2_a21oi_1
X_14754_ _06043_ _06001_ _06004_ _06042_ VPWR VGND sg13g2_and3_1
X_11966_ u_spi_slave.rd_toggle u_spi_slave.rd_toggle_q _03386_ VPWR VGND sg13g2_xor2_1
XFILLER_44_362 VPWR VGND sg13g2_decap_8
X_13705_ _05031_ _05003_ _05033_ VPWR VGND sg13g2_xor2_1
X_17473_ net147 VPWR _08606_ VGND net691 net693 sg13g2_o21ai_1
X_14685_ net862 net767 _05973_ _05975_ VPWR VGND sg13g2_a21o_1
X_11897_ VPWR _03318_ u_LMS.w\[5\]\[21\] VGND sg13g2_inv_1
X_19212_ VGND VPWR u_LMS.w\[3\]\[18\] net304 _10293_ _10292_ sg13g2_a21oi_1
X_16424_ VGND VPWR _07631_ _07633_ _07654_ _07653_ sg13g2_a21oi_1
X_13636_ _04939_ VPWR _04965_ VGND _04891_ _04931_ sg13g2_o21ai_1
X_19143_ _10230_ _03335_ _10183_ VPWR VGND sg13g2_nand2_1
X_16355_ net272 _07585_ _07588_ VPWR VGND sg13g2_and2_1
X_13567_ _04896_ _04862_ _04898_ VPWR VGND sg13g2_xor2_1
XFILLER_118_607 VPWR VGND sg13g2_fill_2
X_15306_ _06574_ _06543_ _06546_ VPWR VGND sg13g2_nand2_1
X_12518_ _03892_ _03868_ _03871_ VPWR VGND sg13g2_nand2_1
X_19074_ _10160_ _10157_ _10161_ VPWR VGND sg13g2_xor2_1
X_16286_ _07521_ _07490_ _07493_ VPWR VGND sg13g2_nand2_1
XFILLER_8_252 VPWR VGND sg13g2_decap_8
X_13498_ _04830_ _04831_ _04832_ VPWR VGND sg13g2_nor2_1
XFILLER_117_117 VPWR VGND sg13g2_decap_8
X_18025_ VGND VPWR u_LMS.w\[1\]\[24\] net303 _09146_ _09122_ sg13g2_a21oi_1
X_15237_ net820 _06504_ net778 _06507_ VPWR VGND sg13g2_nand3_1
X_12449_ _03825_ _03716_ _03824_ VPWR VGND sg13g2_nand2_1
XFILLER_114_802 VPWR VGND sg13g2_fill_1
X_22972__1636 VPWR net1635 clknet_3_6__leaf_spi_sclk VGND sg13g2_inv_1
X_15168_ _06440_ _06435_ _06438_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_63 VPWR VGND sg13g2_decap_8
X_14119_ _05429_ _05425_ _05430_ VPWR VGND sg13g2_xor2_1
X_19976_ _11017_ _11005_ _11015_ VPWR VGND sg13g2_xnor2_1
Xfanout209 net215 net209 VPWR VGND sg13g2_buf_1
X_15099_ _06371_ _06372_ _00162_ VPWR VGND sg13g2_nor2_1
XFILLER_113_367 VPWR VGND sg13g2_decap_4
X_18927_ _03256_ net176 _10014_ VPWR VGND sg13g2_nor2_1
XFILLER_39_101 VPWR VGND sg13g2_fill_1
X_18858_ _09945_ net655 net238 VPWR VGND sg13g2_nand2_1
XFILLER_67_454 VPWR VGND sg13g2_fill_1
XFILLER_39_145 VPWR VGND sg13g2_decap_4
XFILLER_10_0 VPWR VGND sg13g2_decap_8
XFILLER_67_465 VPWR VGND sg13g2_fill_2
X_17809_ _08939_ VPWR _08942_ VGND net206 _08941_ sg13g2_o21ai_1
XFILLER_54_115 VPWR VGND sg13g2_decap_4
X_18789_ _09873_ _09874_ _09876_ VPWR VGND sg13g2_nor2b_1
X_20820_ _01459_ VPWR _01460_ VGND _01432_ _01457_ sg13g2_o21ai_1
XFILLER_54_148 VPWR VGND sg13g2_decap_4
XFILLER_35_351 VPWR VGND sg13g2_fill_1
X_23393__1170 VPWR VGND net1169 sg13g2_tiehi
X_20751_ _01391_ _01388_ _01390_ VPWR VGND sg13g2_nand2_1
XFILLER_51_844 VPWR VGND sg13g2_decap_4
XFILLER_51_866 VPWR VGND sg13g2_decap_4
X_23470_ net1518 VGND VPWR _00532_ u_LMS.x_r\[5\]\[5\] clknet_leaf_7_clkA sg13g2_dfrbpq_1
X_20682_ _01322_ _01319_ _01320_ VPWR VGND sg13g2_xnor2_1
XFILLER_126_1049 VPWR VGND sg13g2_decap_8
X_22421_ net949 VPWR _02960_ VGND net437 net651 sg13g2_o21ai_1
X_22352_ _02923_ _02924_ _00485_ VPWR VGND sg13g2_nor2_1
XFILLER_108_128 VPWR VGND sg13g2_decap_8
XFILLER_40_38 VPWR VGND sg13g2_fill_2
X_21303_ _01912_ VPWR _01920_ VGND _01913_ _01919_ sg13g2_o21ai_1
X_22283_ net561 coeff_force_packed\[62\] _02871_ VPWR VGND sg13g2_and2_1
X_21234_ _01851_ net116 _01849_ VPWR VGND sg13g2_xnor2_1
XFILLER_85_1055 VPWR VGND sg13g2_decap_4
XFILLER_49_14 VPWR VGND sg13g2_decap_4
X_21165_ VGND VPWR _01758_ _01761_ _01782_ net116 sg13g2_a21oi_1
Xfanout710 net711 net710 VPWR VGND sg13g2_buf_1
Xfanout721 u_FIR.w\[8\]\[4\] net721 VPWR VGND sg13g2_buf_1
X_20116_ _11157_ _11154_ _11156_ VPWR VGND sg13g2_xnor2_1
Xfanout732 u_FIR.w\[7\]\[3\] net732 VPWR VGND sg13g2_buf_1
XFILLER_131_164 VPWR VGND sg13g2_decap_8
X_21096_ _01604_ _01603_ _01720_ VPWR VGND sg13g2_xor2_1
Xfanout743 u_FIR.w\[6\]\[3\] net743 VPWR VGND sg13g2_buf_1
Xfanout754 u_FIR.w\[5\]\[1\] net754 VPWR VGND sg13g2_buf_1
XFILLER_58_421 VPWR VGND sg13g2_decap_4
Xfanout765 u_FIR.w\[4\]\[0\] net765 VPWR VGND sg13g2_buf_1
Xfanout776 u_FIR.w\[2\]\[5\] net776 VPWR VGND sg13g2_buf_1
X_20047_ _11088_ _11048_ _11054_ VPWR VGND sg13g2_xnor2_1
Xfanout787 u_FIR.w\[1\]\[3\] net787 VPWR VGND sg13g2_buf_1
Xfanout798 u_FIR.w\[0\]\[2\] net798 VPWR VGND sg13g2_buf_1
XFILLER_85_251 VPWR VGND sg13g2_decap_4
XFILLER_100_562 VPWR VGND sg13g2_decap_8
XFILLER_65_35 VPWR VGND sg13g2_decap_4
XFILLER_18_318 VPWR VGND sg13g2_fill_1
XFILLER_27_841 VPWR VGND sg13g2_decap_8
X_11820_ VPWR _03241_ net633 VGND sg13g2_inv_1
XFILLER_65_79 VPWR VGND sg13g2_fill_1
X_21998_ _02592_ _02574_ _02584_ VPWR VGND sg13g2_nand2_1
X_23737_ net989 VGND VPWR _00799_ spi_addr\[3\] clknet_3_4__leaf_spi_sclk sg13g2_dfrbpq_1
X_20949_ _01516_ _01496_ _01589_ VPWR VGND sg13g2_xor2_1
XFILLER_92_1026 VPWR VGND sg13g2_fill_2
XFILLER_26_395 VPWR VGND sg13g2_decap_4
XFILLER_42_855 VPWR VGND sg13g2_fill_2
XFILLER_42_866 VPWR VGND sg13g2_decap_4
X_14470_ _05757_ VPWR _05769_ VGND net278 _05755_ sg13g2_o21ai_1
X_23177__1521 VPWR VGND net1520 sg13g2_tiehi
X_23205__1472 VPWR VGND net1471 sg13g2_tiehi
X_23668_ net1021 VGND VPWR _00730_ u_debug_unit.mon_w4_sync\[6\] clknet_leaf_36_clkA
+ sg13g2_dfrbpq_1
X_13421_ _04763_ _04762_ _04761_ VPWR VGND sg13g2_nand2b_1
X_22619_ net429 _03435_ _03061_ VPWR VGND sg13g2_and2_1
XFILLER_14_50 VPWR VGND sg13g2_fill_2
XFILLER_14_61 VPWR VGND sg13g2_fill_1
X_23599_ net1012 VGND VPWR _00661_ coeff_force_packed\[40\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
X_16140_ net817 net800 _07377_ _07379_ VPWR VGND sg13g2_a21o_1
X_13352_ _04696_ _04659_ _04694_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_426 VPWR VGND sg13g2_decap_4
XFILLER_10_785 VPWR VGND sg13g2_fill_2
X_12303_ _03683_ _03652_ _03681_ VPWR VGND sg13g2_xnor2_1
X_16071_ _07312_ _07310_ _07311_ VPWR VGND sg13g2_nand2_1
X_13283_ _04627_ _04595_ _04629_ VPWR VGND sg13g2_xor2_1
XFILLER_5_244 VPWR VGND sg13g2_fill_1
X_15022_ _06296_ _06278_ _06298_ VPWR VGND sg13g2_xor2_1
X_12234_ _03617_ _03610_ _03615_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_789 VPWR VGND sg13g2_decap_8
X_19830_ _10886_ _10835_ _10885_ VPWR VGND sg13g2_nand2_1
XFILLER_123_643 VPWR VGND sg13g2_fill_2
X_12165_ _00037_ _03572_ _03573_ VPWR VGND sg13g2_and2_1
XFILLER_122_131 VPWR VGND sg13g2_fill_2
XFILLER_123_676 VPWR VGND sg13g2_decap_8
X_19761_ VGND VPWR _10397_ _10426_ _10825_ _10824_ sg13g2_a21oi_1
XFILLER_122_175 VPWR VGND sg13g2_fill_1
X_16973_ _08127_ _08126_ _08129_ VPWR VGND sg13g2_xor2_1
X_12096_ _03508_ net294 debug_load_bus\[3\] _03410_ u_debug_unit.mon_w4_sync\[3\]
+ VPWR VGND sg13g2_a22oi_1
X_23089__1073 VPWR VGND net1072 sg13g2_tiehi
X_18712_ net146 VPWR _09799_ VGND net666 net667 sg13g2_o21ai_1
X_15924_ _07169_ _07168_ _07150_ VPWR VGND sg13g2_nand2b_1
X_19692_ _10756_ u_LMS.w\[4\]\[11\] _10755_ VPWR VGND sg13g2_nand2_1
X_18643_ _09736_ _09737_ _00341_ VPWR VGND sg13g2_nor2_1
X_15855_ _07103_ u_FIR.sum\[6\]\[12\] net391 VPWR VGND sg13g2_xnor2_1
XFILLER_92_755 VPWR VGND sg13g2_decap_8
X_14806_ _06093_ net768 net824 VPWR VGND sg13g2_nand2_1
XFILLER_92_766 VPWR VGND sg13g2_fill_2
X_18574_ _09684_ net304 u_LMS.w\[2\]\[12\] coeff_force_packed\[14\] net559 VPWR VGND
+ sg13g2_a22oi_1
X_15786_ VPWR _07036_ _07035_ VGND sg13g2_inv_1
X_12998_ net1040 VPWR _04355_ VGND net545 u_FIR.sum\[1\]\[14\] sg13g2_o21ai_1
XFILLER_45_660 VPWR VGND sg13g2_fill_1
XFILLER_33_811 VPWR VGND sg13g2_decap_8
X_17525_ _08658_ _08657_ _08636_ VPWR VGND sg13g2_nand2b_1
X_14737_ _06019_ _06025_ _06026_ VPWR VGND sg13g2_nor2b_1
X_11949_ VPWR _03370_ u_FIR.w\[2\]\[6\] VGND sg13g2_inv_1
XFILLER_44_181 VPWR VGND sg13g2_fill_2
XFILLER_44_192 VPWR VGND sg13g2_decap_4
X_17456_ _08589_ net684 net159 VPWR VGND sg13g2_nand2_1
X_14668_ _05958_ _05930_ _05959_ VPWR VGND sg13g2_xor2_1
X_16407_ _07588_ _07617_ _07636_ _07638_ VPWR VGND sg13g2_or3_1
Xclkbuf_leaf_26_clkA clknet_4_14_0_clkA clknet_leaf_26_clkA VPWR VGND sg13g2_buf_8
X_13619_ _04949_ _04906_ _04947_ VPWR VGND sg13g2_xnor2_1
X_17387_ VGND VPWR _08533_ _08534_ _00288_ net932 sg13g2_a21oi_1
X_14599_ _05869_ _05878_ _05891_ VPWR VGND sg13g2_and2_1
XFILLER_125_1060 VPWR VGND sg13g2_fill_1
XFILLER_9_550 VPWR VGND sg13g2_fill_2
X_23716__1411 VPWR VGND net1410 sg13g2_tiehi
X_19126_ _10213_ _10212_ _10211_ VPWR VGND sg13g2_nand2b_1
X_16338_ _07551_ _07571_ _07572_ VPWR VGND sg13g2_nor2b_1
X_19057_ _09941_ _09911_ _10144_ VPWR VGND sg13g2_xor2_1
X_16269_ _07505_ _07465_ _07503_ VPWR VGND sg13g2_xnor2_1
X_23240__1410 VPWR VGND net1409 sg13g2_tiehi
X_18008_ _09132_ u_LMS.w\[1\]\[21\] net77 VPWR VGND sg13g2_xnor2_1
XFILLER_58_0 VPWR VGND sg13g2_decap_8
X_23455__1567 VPWR VGND net1566 sg13g2_tiehi
XFILLER_99_365 VPWR VGND sg13g2_decap_4
XFILLER_102_816 VPWR VGND sg13g2_decap_4
X_23516__1353 VPWR VGND net1352 sg13g2_tiehi
XFILLER_99_387 VPWR VGND sg13g2_fill_2
XFILLER_87_527 VPWR VGND sg13g2_fill_1
X_19959_ _10999_ _10986_ _11000_ VPWR VGND sg13g2_xor2_1
XFILLER_132_1031 VPWR VGND sg13g2_decap_8
XFILLER_110_860 VPWR VGND sg13g2_fill_2
XFILLER_83_700 VPWR VGND sg13g2_fill_1
X_21921_ _02507_ VPWR _02515_ VGND _02508_ _02514_ sg13g2_o21ai_1
XFILLER_56_936 VPWR VGND sg13g2_decap_8
XFILLER_110_893 VPWR VGND sg13g2_fill_2
XFILLER_95_593 VPWR VGND sg13g2_fill_2
XFILLER_83_733 VPWR VGND sg13g2_fill_2
XFILLER_67_284 VPWR VGND sg13g2_fill_1
XFILLER_55_424 VPWR VGND sg13g2_fill_1
XFILLER_82_221 VPWR VGND sg13g2_fill_1
X_21852_ _02446_ _02445_ net115 VPWR VGND sg13g2_nand2b_1
XFILLER_55_468 VPWR VGND sg13g2_fill_2
XFILLER_27_159 VPWR VGND sg13g2_fill_2
XFILLER_35_27 VPWR VGND sg13g2_decap_8
XFILLER_24_800 VPWR VGND sg13g2_fill_1
X_20803_ _01443_ _01441_ _01442_ VPWR VGND sg13g2_xnor2_1
XFILLER_82_298 VPWR VGND sg13g2_decap_4
X_21783_ VGND VPWR _02353_ _02355_ _02377_ net115 sg13g2_a21oi_1
XFILLER_63_490 VPWR VGND sg13g2_decap_4
X_23522_ net1328 VGND VPWR _00584_ u_LMS.count\[25\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
XFILLER_24_866 VPWR VGND sg13g2_decap_4
X_20734_ _01374_ net227 net612 net190 net615 VPWR VGND sg13g2_a22oi_1
XFILLER_50_151 VPWR VGND sg13g2_decap_8
XFILLER_23_365 VPWR VGND sg13g2_decap_8
XFILLER_50_162 VPWR VGND sg13g2_fill_1
XFILLER_23_376 VPWR VGND sg13g2_fill_1
XFILLER_52_1010 VPWR VGND sg13g2_decap_8
X_23453_ net1572 VGND VPWR _00515_ u_LMS.x_r\[3\]\[4\] clknet_leaf_65_clkA sg13g2_dfrbpq_1
XFILLER_52_1021 VPWR VGND sg13g2_fill_1
X_20665_ net609 net236 net607 _01305_ VPWR VGND net209 sg13g2_nand4_1
XFILLER_7_509 VPWR VGND sg13g2_decap_8
XFILLER_109_404 VPWR VGND sg13g2_fill_1
X_22404_ VGND VPWR net438 _03267_ _00510_ _02951_ sg13g2_a21oi_1
X_23384_ net1196 VGND VPWR _00446_ u_LMS.w\[7\]\[17\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
X_20596_ VPWR _01236_ _01235_ VGND sg13g2_inv_1
XFILLER_13_1049 VPWR VGND sg13g2_decap_8
X_22335_ net357 VPWR _02912_ VGND u_LMS.w\[8\]\[6\] net374 sg13g2_o21ai_1
XFILLER_124_407 VPWR VGND sg13g2_decap_4
X_22266_ net2168 u_LMS.w\[8\]\[15\] _02857_ VPWR VGND sg13g2_xor2_1
XFILLER_117_470 VPWR VGND sg13g2_fill_1
X_21217_ VGND VPWR net592 net188 _01834_ _01830_ sg13g2_a21oi_1
XFILLER_2_247 VPWR VGND sg13g2_decap_8
X_22197_ VGND VPWR u_LMS.w\[8\]\[4\] _02781_ _02791_ _02790_ sg13g2_a21oi_1
XFILLER_2_258 VPWR VGND sg13g2_fill_1
XFILLER_104_153 VPWR VGND sg13g2_decap_8
XFILLER_105_687 VPWR VGND sg13g2_decap_8
X_21148_ _01765_ _01756_ _01764_ VPWR VGND sg13g2_nand2b_1
Xfanout540 net541 net540 VPWR VGND sg13g2_buf_1
Xfanout551 u_p2s_output.o_valid net551 VPWR VGND sg13g2_buf_1
Xfanout562 net568 net562 VPWR VGND sg13g2_buf_1
XFILLER_93_508 VPWR VGND sg13g2_decap_4
X_21079_ net322 VPWR _01707_ VGND u_LMS.w\[6\]\[24\] net1659 sg13g2_o21ai_1
Xfanout573 net574 net573 VPWR VGND sg13g2_buf_1
X_13970_ _05288_ _05286_ _05287_ VPWR VGND sg13g2_xnor2_1
Xfanout584 net585 net584 VPWR VGND sg13g2_buf_1
XFILLER_86_560 VPWR VGND sg13g2_fill_2
Xfanout595 u_LMS.x_r\[7\]\[5\] net595 VPWR VGND sg13g2_buf_1
XFILLER_47_936 VPWR VGND sg13g2_decap_8
X_12921_ VGND VPWR net546 _04279_ _00076_ _04280_ sg13g2_a21oi_1
XFILLER_18_115 VPWR VGND sg13g2_decap_8
XFILLER_73_221 VPWR VGND sg13g2_fill_2
XFILLER_46_446 VPWR VGND sg13g2_fill_1
X_15640_ net483 VPWR _06894_ VGND _06892_ _06893_ sg13g2_o21ai_1
XFILLER_92_11 VPWR VGND sg13g2_fill_2
XFILLER_74_777 VPWR VGND sg13g2_decap_4
X_12852_ VGND VPWR _04213_ net734 u_FIR.w\[7\]\[3\] sg13g2_or2_1
XFILLER_62_928 VPWR VGND sg13g2_fill_2
XFILLER_132_84 VPWR VGND sg13g2_decap_8
XFILLER_33_118 VPWR VGND sg13g2_decap_8
X_11803_ VPWR _03224_ net603 VGND sg13g2_inv_1
X_22971__1635 VPWR net1634 clknet_3_7__leaf_spi_sclk VGND sg13g2_inv_1
Xclkbuf_leaf_49_clkA clknet_4_4_0_clkA clknet_leaf_49_clkA VPWR VGND sg13g2_buf_8
X_15571_ VGND VPWR _06826_ _06824_ _06795_ sg13g2_or2_1
X_12783_ _04145_ _04103_ _04146_ VPWR VGND sg13g2_xor2_1
XFILLER_92_77 VPWR VGND sg13g2_fill_2
XFILLER_109_1011 VPWR VGND sg13g2_fill_2
XFILLER_92_88 VPWR VGND sg13g2_decap_8
XFILLER_26_181 VPWR VGND sg13g2_fill_1
X_17310_ _08466_ _08465_ _08409_ VPWR VGND sg13g2_nand2b_1
X_14522_ _05817_ _05809_ _05816_ VPWR VGND sg13g2_nand2_1
X_18290_ VGND VPWR _09389_ _09391_ _09400_ _09399_ sg13g2_a21oi_1
XFILLER_30_803 VPWR VGND sg13g2_decap_4
XFILLER_42_685 VPWR VGND sg13g2_fill_1
XFILLER_15_899 VPWR VGND sg13g2_decap_4
X_17241_ _08065_ _08066_ _08397_ VPWR VGND sg13g2_nor2b_1
X_14453_ _05737_ VPWR _05753_ VGND net277 _05735_ sg13g2_o21ai_1
XFILLER_41_184 VPWR VGND sg13g2_fill_1
X_13404_ _04644_ _04745_ _04746_ VPWR VGND sg13g2_nor2_1
XFILLER_128_713 VPWR VGND sg13g2_decap_8
X_17172_ _08326_ _08322_ _08327_ _08328_ VPWR VGND sg13g2_a21o_1
X_14384_ _05688_ _05667_ _05687_ VPWR VGND sg13g2_xnor2_1
X_16123_ _07359_ VPWR _07362_ VGND _07326_ _07357_ sg13g2_o21ai_1
X_13335_ _04679_ _04648_ _04651_ VPWR VGND sg13g2_nand2_1
XFILLER_128_768 VPWR VGND sg13g2_fill_2
X_16054_ VGND VPWR _07295_ _07293_ _07256_ sg13g2_or2_1
X_13266_ _04612_ _04568_ _04611_ VPWR VGND sg13g2_xnor2_1
XFILLER_29_1012 VPWR VGND sg13g2_decap_8
X_15005_ _06280_ _06281_ _06282_ VPWR VGND sg13g2_nor2_1
X_12217_ _03599_ _03600_ _03601_ VPWR VGND sg13g2_nor2_1
X_13197_ _04545_ _04538_ _04544_ VPWR VGND sg13g2_xnor2_1
XFILLER_111_613 VPWR VGND sg13g2_fill_1
X_19813_ _10808_ _10809_ _10744_ _10872_ VPWR VGND sg13g2_nand3_1
XFILLER_69_527 VPWR VGND sg13g2_decap_8
XFILLER_123_473 VPWR VGND sg13g2_decap_4
X_12148_ _03557_ net286 u_debug_unit.sw_reset\[0\] _03434_ u_debug_unit.mon_w0_sync\[0\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_96_313 VPWR VGND sg13g2_fill_1
XFILLER_116_1059 VPWR VGND sg13g2_fill_2
X_19744_ _10745_ _10748_ _10808_ VPWR VGND _10806_ sg13g2_nand3b_1
X_16956_ _08112_ net711 net87 VPWR VGND sg13g2_nand2_1
X_12079_ VGND VPWR sys_enable_bus\[4\] net285 _03492_ _03385_ sg13g2_a21oi_1
XFILLER_2_42 VPWR VGND sg13g2_decap_8
X_15907_ _07153_ _07152_ _07131_ VPWR VGND sg13g2_nand2b_1
X_19675_ _10466_ VPWR _10739_ VGND _10736_ _10738_ sg13g2_o21ai_1
XFILLER_38_947 VPWR VGND sg13g2_decap_4
X_16887_ _08043_ _08029_ _08041_ VPWR VGND sg13g2_xnor2_1
X_18626_ VGND VPWR _09675_ _09676_ _09724_ _09677_ sg13g2_a21oi_1
X_15838_ VGND VPWR _07054_ _07078_ _07086_ _07077_ sg13g2_a21oi_1
XFILLER_18_682 VPWR VGND sg13g2_decap_4
X_18557_ _09666_ _09663_ _09667_ VPWR VGND _09665_ sg13g2_nand3b_1
XFILLER_52_438 VPWR VGND sg13g2_decap_8
XFILLER_24_129 VPWR VGND sg13g2_decap_8
X_15769_ _06987_ _06980_ _06994_ _07019_ VPWR VGND sg13g2_a21o_1
X_17508_ _08639_ _08640_ _08641_ VPWR VGND sg13g2_nor2b_1
X_23312__1290 VPWR VGND net1289 sg13g2_tiehi
X_18488_ _09598_ _09424_ net1669 VPWR VGND sg13g2_xnor2_1
XFILLER_36_1049 VPWR VGND sg13g2_decap_8
X_17439_ VGND VPWR net58 _08574_ _08575_ net42 sg13g2_a21oi_1
X_20450_ _01104_ u_LMS.w\[5\]\[21\] net1655 VPWR VGND sg13g2_xnor2_1
XFILLER_119_724 VPWR VGND sg13g2_fill_2
XFILLER_118_201 VPWR VGND sg13g2_fill_2
X_19109_ _10196_ _10125_ _10195_ VPWR VGND sg13g2_nand2_1
X_20381_ VPWR _01044_ _01043_ VGND sg13g2_inv_1
X_22120_ VGND VPWR _02591_ _02605_ _02714_ _02604_ sg13g2_a21oi_1
X_22051_ _02645_ _02530_ _02614_ VPWR VGND sg13g2_xnor2_1
X_21002_ VGND VPWR _01561_ _01639_ _01642_ _01641_ sg13g2_a21oi_1
XFILLER_87_313 VPWR VGND sg13g2_fill_2
XFILLER_87_324 VPWR VGND sg13g2_fill_1
XFILLER_82_1058 VPWR VGND sg13g2_fill_2
XFILLER_68_560 VPWR VGND sg13g2_decap_4
XFILLER_68_571 VPWR VGND sg13g2_decap_8
XFILLER_28_402 VPWR VGND sg13g2_fill_2
X_22953_ net459 u_spi_slave.rx_shift\[6\] _03575_ _00810_ VPWR VGND sg13g2_mux2_1
XFILLER_28_424 VPWR VGND sg13g2_fill_1
X_21904_ net582 net108 _02498_ VPWR VGND sg13g2_and2_1
X_22884_ _03170_ net553 u_s2p_input.reg_cnt\[1\] u_s2p_input.reg_cnt\[0\] VPWR VGND
+ sg13g2_and3_1
XFILLER_55_265 VPWR VGND sg13g2_decap_8
X_23047__1136 VPWR VGND net1135 sg13g2_tiehi
XFILLER_55_287 VPWR VGND sg13g2_decap_8
XFILLER_37_991 VPWR VGND sg13g2_fill_2
X_21835_ VGND VPWR net572 net185 _02429_ _02425_ sg13g2_a21oi_1
XFILLER_71_758 VPWR VGND sg13g2_decap_8
XFILLER_52_961 VPWR VGND sg13g2_fill_1
X_21766_ _02360_ _02351_ _02359_ VPWR VGND sg13g2_nand2b_1
X_20717_ _01355_ _01356_ _01357_ VPWR VGND sg13g2_nor2_1
X_23505_ net1394 VGND VPWR _00567_ u_LMS.count\[8\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
X_21697_ VGND VPWR _02302_ _02301_ _02300_ sg13g2_or2_1
X_23436_ net1625 VGND VPWR _00498_ u_LMS.x_r\[1\]\[3\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
X_20648_ VPWR _01288_ _01287_ VGND sg13g2_inv_1
XFILLER_109_245 VPWR VGND sg13g2_decap_4
X_23367_ net1234 VGND VPWR _00429_ u_LMS.w\[6\]\[23\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
X_20579_ _01209_ VPWR _01219_ VGND _01176_ _01210_ sg13g2_o21ai_1
X_13120_ _04470_ _04442_ _04469_ VPWR VGND sg13g2_xnor2_1
X_22318_ VGND VPWR net47 _02898_ _02899_ net6 sg13g2_a21oi_1
X_23298_ net1303 VGND VPWR _00360_ u_LMS.w\[3\]\[23\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
X_13051_ _04403_ _04402_ _04398_ VPWR VGND sg13g2_nand2b_1
XFILLER_106_963 VPWR VGND sg13g2_fill_2
X_22249_ _02843_ net716 net60 VPWR VGND sg13g2_nand2_1
XFILLER_106_985 VPWR VGND sg13g2_decap_8
XFILLER_127_84 VPWR VGND sg13g2_decap_8
X_12002_ VPWR VGND u_debug_unit.mon_w8_sync\[6\] _03414_ _03416_ u_debug_unit.mon_w1_sync\[6\]
+ _03419_ _03407_ sg13g2_a221oi_1
XFILLER_78_313 VPWR VGND sg13g2_decap_4
XFILLER_121_922 VPWR VGND sg13g2_decap_4
X_23354__1248 VPWR VGND net1247 sg13g2_tiehi
X_16810_ _07945_ _07965_ _07966_ VPWR VGND sg13g2_nor2_1
XFILLER_94_817 VPWR VGND sg13g2_decap_4
X_17790_ _08922_ VPWR _08923_ VGND _08913_ _08915_ sg13g2_o21ai_1
XFILLER_66_519 VPWR VGND sg13g2_fill_1
XFILLER_121_988 VPWR VGND sg13g2_decap_8
Xfanout370 net371 net370 VPWR VGND sg13g2_buf_1
XFILLER_120_476 VPWR VGND sg13g2_fill_1
Xfanout381 net383 net381 VPWR VGND sg13g2_buf_1
XFILLER_93_327 VPWR VGND sg13g2_decap_8
XFILLER_120_487 VPWR VGND sg13g2_fill_1
Xfanout392 _06921_ net392 VPWR VGND sg13g2_buf_1
X_16741_ u_FIR.sum\[8\]\[5\] _03378_ net1644 _07897_ VPWR VGND sg13g2_mux2_2
XFILLER_87_891 VPWR VGND sg13g2_fill_1
XFILLER_4_1025 VPWR VGND sg13g2_decap_8
X_13953_ _05272_ _05252_ _05271_ VPWR VGND sg13g2_xnor2_1
XFILLER_98_1021 VPWR VGND sg13g2_fill_2
XFILLER_98_1032 VPWR VGND sg13g2_fill_1
X_23423__1080 VPWR VGND net1079 sg13g2_tiehi
XFILLER_74_541 VPWR VGND sg13g2_decap_8
XFILLER_47_766 VPWR VGND sg13g2_fill_1
XFILLER_35_906 VPWR VGND sg13g2_decap_8
X_19460_ _10524_ _10519_ _10522_ VPWR VGND sg13g2_xnor2_1
X_12904_ _04264_ _04252_ _04263_ VPWR VGND sg13g2_xnor2_1
X_16672_ VGND VPWR u_LMS.w\[6\]\[17\] _07832_ _07844_ _07833_ sg13g2_a21oi_1
X_13884_ _05182_ _05206_ _05207_ VPWR VGND sg13g2_nor2b_1
X_18411_ _09521_ _09510_ _09512_ VPWR VGND sg13g2_xnor2_1
X_15623_ _06832_ _06834_ _06877_ VPWR VGND sg13g2_and2_1
X_19391_ _10455_ _10454_ net118 VPWR VGND sg13g2_nand2b_1
X_12835_ _04189_ _04196_ _04197_ VPWR VGND sg13g2_nor2b_1
XFILLER_34_449 VPWR VGND sg13g2_decap_4
XFILLER_27_490 VPWR VGND sg13g2_decap_8
XFILLER_15_630 VPWR VGND sg13g2_fill_1
X_18342_ _09452_ _09418_ _09419_ VPWR VGND sg13g2_xnor2_1
X_15554_ _06810_ _06809_ _06773_ VPWR VGND sg13g2_nand2b_1
X_12766_ _04128_ _04129_ _00072_ VPWR VGND sg13g2_nor2_1
XFILLER_99_7 VPWR VGND sg13g2_fill_2
X_14505_ _05799_ _05800_ _05801_ VPWR VGND sg13g2_nor2b_1
X_18273_ VPWR _09383_ _09382_ VGND sg13g2_inv_1
X_15485_ net900 u_FIR.sum\[6\]\[0\] net791 _06745_ VPWR VGND sg13g2_nand3_1
X_12697_ _04062_ _04020_ _04061_ VPWR VGND sg13g2_xnor2_1
X_23469__1522 VPWR VGND net1521 sg13g2_tiehi
X_17224_ VGND VPWR _08380_ _08379_ _08378_ sg13g2_or2_1
X_14436_ _05737_ _05736_ _05715_ VPWR VGND sg13g2_nand2b_1
XFILLER_30_688 VPWR VGND sg13g2_fill_2
XFILLER_128_543 VPWR VGND sg13g2_decap_8
X_17155_ _08311_ net714 net212 VPWR VGND sg13g2_nand2_1
X_14367_ _05639_ VPWR _05671_ VGND _03365_ net809 sg13g2_o21ai_1
X_16106_ _07346_ net802 net817 u_FIR.sum\[7\]\[6\] VPWR VGND sg13g2_and3_1
X_23287__1321 VPWR VGND net1320 sg13g2_tiehi
X_13318_ _04663_ _04618_ _04661_ VPWR VGND sg13g2_xnor2_1
XFILLER_116_738 VPWR VGND sg13g2_decap_4
X_17086_ _08211_ VPWR _08242_ VGND _08143_ _08189_ sg13g2_o21ai_1
X_14298_ _05579_ VPWR _05604_ VGND net279 _05580_ sg13g2_o21ai_1
X_16037_ _07231_ _07277_ _07278_ VPWR VGND sg13g2_nor2_1
X_13249_ _04586_ VPWR _04595_ VGND _04556_ _04587_ sg13g2_o21ai_1
XFILLER_69_313 VPWR VGND sg13g2_decap_8
XFILLER_123_281 VPWR VGND sg13g2_fill_1
XFILLER_112_955 VPWR VGND sg13g2_fill_1
XFILLER_96_132 VPWR VGND sg13g2_decap_8
X_17988_ _09048_ _09115_ _09116_ VPWR VGND sg13g2_and2_1
X_19727_ _10759_ u_LMS.w\[4\]\[9\] _10791_ VPWR VGND sg13g2_xor2_1
X_16939_ _08095_ _08092_ _08093_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_530 VPWR VGND sg13g2_decap_4
X_19658_ VGND VPWR _10651_ _10722_ _10721_ _10720_ sg13g2_a21oi_2
XFILLER_65_585 VPWR VGND sg13g2_decap_8
X_18609_ VGND VPWR u_LMS.w\[2\]\[20\] net301 _09711_ _09702_ sg13g2_a21oi_1
XFILLER_80_533 VPWR VGND sg13g2_fill_1
X_19589_ net652 net187 net649 _10653_ VPWR VGND net224 sg13g2_nand4_1
X_21620_ _02237_ _02233_ _02235_ _02236_ VPWR VGND sg13g2_and3_1
XFILLER_34_961 VPWR VGND sg13g2_decap_4
XFILLER_40_408 VPWR VGND sg13g2_decap_8
XFILLER_40_419 VPWR VGND sg13g2_decap_8
X_23043__1142 VPWR VGND net1141 sg13g2_tiehi
X_21551_ _02168_ _02167_ _02126_ VPWR VGND sg13g2_xnor2_1
X_20502_ _01144_ _01025_ _01027_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_39 VPWR VGND sg13g2_decap_8
X_21482_ _02099_ _02089_ _02098_ VPWR VGND sg13g2_nand2_1
XFILLER_119_521 VPWR VGND sg13g2_decap_8
XFILLER_119_532 VPWR VGND sg13g2_fill_2
X_23221_ net1442 VGND VPWR _00283_ u_LMS.w\[0\]\[15\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
X_20433_ _01091_ net316 u_LMS.w\[5\]\[17\] coeff_force_packed\[40\] net566 VPWR VGND
+ sg13g2_a22oi_1
X_23058__1120 VPWR VGND net1119 sg13g2_tiehi
X_23152_ net1561 VGND VPWR _00214_ u_FIR.x_reg\[5\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
X_20364_ _01027_ _01026_ _00990_ VPWR VGND sg13g2_nand2b_1
X_22103_ _02674_ _02696_ _02697_ VPWR VGND sg13g2_nor2b_1
X_23083_ net1081 VGND VPWR _00145_ u_FIR.sum\[5\]\[7\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
X_20295_ _00957_ VPWR _00958_ VGND _11025_ _00956_ sg13g2_o21ai_1
X_22970__1634 VPWR net1633 clknet_3_7__leaf_spi_sclk VGND sg13g2_inv_1
X_22034_ _02626_ _02627_ _02628_ VPWR VGND sg13g2_nor2_1
XFILLER_87_110 VPWR VGND sg13g2_decap_4
XFILLER_102_421 VPWR VGND sg13g2_fill_1
XFILLER_130_763 VPWR VGND sg13g2_fill_2
XFILLER_87_165 VPWR VGND sg13g2_decap_8
XFILLER_29_700 VPWR VGND sg13g2_fill_1
XFILLER_29_777 VPWR VGND sg13g2_decap_8
X_22936_ VGND VPWR net324 _03198_ _00799_ _03197_ sg13g2_a21oi_1
XFILLER_17_928 VPWR VGND sg13g2_fill_2
XFILLER_71_511 VPWR VGND sg13g2_fill_2
X_22867_ VGND VPWR net299 _03157_ _00766_ _03158_ sg13g2_a21oi_1
XFILLER_19_1000 VPWR VGND sg13g2_decap_8
X_12620_ _03987_ _03966_ _03988_ VPWR VGND sg13g2_xor2_1
XFILLER_31_408 VPWR VGND sg13g2_fill_2
X_21818_ _02412_ _02389_ _02410_ VPWR VGND sg13g2_xnor2_1
X_22798_ u_debug_unit.mon_w6_sync\[1\] net350 _03117_ VPWR VGND sg13g2_nor2_1
XFILLER_25_983 VPWR VGND sg13g2_fill_1
X_12551_ _03924_ _03916_ _03922_ VPWR VGND sg13g2_xnor2_1
X_21749_ _02343_ net572 net131 VPWR VGND sg13g2_nand2_1
XFILLER_11_110 VPWR VGND sg13g2_decap_4
XFILLER_12_644 VPWR VGND sg13g2_fill_1
XFILLER_12_666 VPWR VGND sg13g2_fill_2
X_15270_ _06537_ _06464_ _06538_ _06539_ VPWR VGND sg13g2_a21o_1
X_12482_ _03847_ VPWR _03857_ VGND _03790_ _03849_ sg13g2_o21ai_1
XFILLER_7_103 VPWR VGND sg13g2_fill_2
X_23398__1155 VPWR VGND net1154 sg13g2_tiehi
X_14221_ _05529_ net760 net838 VPWR VGND sg13g2_nand2_1
XFILLER_125_0 VPWR VGND sg13g2_decap_8
X_23419_ net1091 VGND VPWR _00481_ u_LMS.w\[8\]\[6\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
X_23698__1531 VPWR VGND net1530 sg13g2_tiehi
X_14152_ _05460_ _05461_ _05462_ VPWR VGND sg13g2_and2_1
X_23483__1473 VPWR VGND net1472 sg13g2_tiehi
XFILLER_125_535 VPWR VGND sg13g2_fill_2
XFILLER_98_32 VPWR VGND sg13g2_decap_8
X_13103_ _04453_ _04452_ _04448_ VPWR VGND sg13g2_nand2b_1
X_23518__1345 VPWR VGND net1344 sg13g2_tiehi
X_18960_ _10047_ _10041_ _10045_ VPWR VGND sg13g2_xnor2_1
X_14083_ _05395_ _05387_ _05394_ VPWR VGND sg13g2_nand2_1
XFILLER_65_1031 VPWR VGND sg13g2_fill_2
X_17911_ VGND VPWR net2210 _09042_ _09044_ _08987_ sg13g2_a21oi_1
X_13034_ _04387_ _04380_ _04386_ VPWR VGND sg13g2_xnor2_1
X_18891_ _09978_ _09972_ _09973_ VPWR VGND sg13g2_xnor2_1
XFILLER_105_281 VPWR VGND sg13g2_decap_8
XFILLER_78_132 VPWR VGND sg13g2_decap_4
XFILLER_26_1037 VPWR VGND sg13g2_fill_1
X_17842_ _08695_ _08697_ _08698_ _08975_ VPWR VGND sg13g2_or3_1
XFILLER_67_817 VPWR VGND sg13g2_decap_4
XFILLER_39_519 VPWR VGND sg13g2_fill_2
XFILLER_120_284 VPWR VGND sg13g2_decap_4
X_17773_ _08906_ _08895_ _08896_ VPWR VGND sg13g2_xnor2_1
XFILLER_14_7 VPWR VGND sg13g2_fill_2
X_14985_ _06262_ _06263_ _00157_ VPWR VGND sg13g2_nor2_1
XFILLER_19_221 VPWR VGND sg13g2_fill_1
X_19512_ _10575_ _10570_ _10576_ VPWR VGND sg13g2_xor2_1
X_16724_ net1031 VPWR _07883_ VGND net528 net721 sg13g2_o21ai_1
XFILLER_81_308 VPWR VGND sg13g2_fill_1
X_13936_ _05256_ _05255_ _05232_ VPWR VGND sg13g2_nand2b_1
XFILLER_35_714 VPWR VGND sg13g2_fill_2
XFILLER_35_736 VPWR VGND sg13g2_fill_1
X_19443_ _10507_ _10505_ _10506_ VPWR VGND sg13g2_nand2b_1
XFILLER_90_831 VPWR VGND sg13g2_decap_4
XFILLER_34_213 VPWR VGND sg13g2_decap_8
X_16655_ _07831_ VPWR _07832_ VGND _07827_ _07828_ sg13g2_o21ai_1
X_13867_ net282 _05189_ _05190_ VPWR VGND sg13g2_and2_1
XFILLER_90_864 VPWR VGND sg13g2_fill_1
XFILLER_34_246 VPWR VGND sg13g2_decap_4
X_15606_ _06838_ _06847_ _06860_ VPWR VGND sg13g2_and2_1
XFILLER_16_961 VPWR VGND sg13g2_decap_8
X_19374_ _10438_ net643 net169 VPWR VGND sg13g2_nand2_1
X_12818_ _04180_ _04174_ _04178_ VPWR VGND sg13g2_xnor2_1
X_16586_ VGND VPWR u_LMS.w\[3\]\[15\] _07773_ _07781_ _07774_ sg13g2_a21oi_1
XFILLER_50_728 VPWR VGND sg13g2_decap_8
XFILLER_34_279 VPWR VGND sg13g2_fill_1
XFILLER_15_460 VPWR VGND sg13g2_decap_8
X_13798_ u_FIR.w\[5\]\[4\] net810 _05123_ VPWR VGND sg13g2_and2_1
XFILLER_72_1013 VPWR VGND sg13g2_decap_8
X_18325_ _09433_ _09434_ _09435_ VPWR VGND sg13g2_nor2_1
X_15537_ VGND VPWR net477 _06792_ _00179_ _06793_ sg13g2_a21oi_1
X_12749_ _04074_ u_FIR.w\[7\]\[6\] _04072_ _04113_ VPWR VGND sg13g2_a21o_1
X_23167__1539 VPWR VGND net1538 sg13g2_tiehi
X_18256_ _09362_ _09361_ _09365_ _09366_ VPWR VGND sg13g2_a21o_1
X_15468_ _06730_ _06721_ _06728_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_63 VPWR VGND sg13g2_decap_8
XFILLER_30_485 VPWR VGND sg13g2_fill_1
X_17207_ VPWR _08363_ _08362_ VGND sg13g2_inv_1
XFILLER_8_74 VPWR VGND sg13g2_fill_1
X_14419_ _05674_ _05720_ _05721_ VPWR VGND sg13g2_nor2_1
X_18187_ _09294_ _09296_ _09297_ VPWR VGND sg13g2_nor2_1
XFILLER_129_874 VPWR VGND sg13g2_decap_8
X_15399_ _06659_ _06661_ _06664_ VPWR VGND sg13g2_nor2_1
X_17138_ _08292_ _08293_ _08294_ VPWR VGND sg13g2_and2_1
X_17069_ VGND VPWR net114 _08222_ _08225_ _08224_ sg13g2_a21oi_1
XFILLER_131_505 VPWR VGND sg13g2_decap_8
XFILLER_40_0 VPWR VGND sg13g2_decap_8
X_20080_ _11119_ VPWR _11121_ VGND _11115_ _11120_ sg13g2_o21ai_1
XFILLER_69_110 VPWR VGND sg13g2_decap_8
Xrebuffer1647 net1647 net1646 VPWR VGND sg13g2_buf_1
XFILLER_69_132 VPWR VGND sg13g2_fill_1
Xrebuffer1658 _07906_ net1657 VPWR VGND sg13g2_buf_1
Xrebuffer1669 _07973_ net1668 VPWR VGND sg13g2_buf_1
XFILLER_100_914 VPWR VGND sg13g2_decap_8
XFILLER_69_165 VPWR VGND sg13g2_decap_8
XFILLER_69_176 VPWR VGND sg13g2_fill_2
X_23770_ net989 VGND VPWR _00003_ u_spi_slave.rx_shift\[12\] clknet_3_1__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_20982_ u_LMS.w\[6\]\[11\] _01581_ _01622_ VPWR VGND sg13g2_nor2_1
XFILLER_84_179 VPWR VGND sg13g2_decap_8
XFILLER_66_894 VPWR VGND sg13g2_decap_8
X_22721_ VGND VPWR _07723_ net344 _00700_ _03078_ sg13g2_a21oi_1
XFILLER_25_235 VPWR VGND sg13g2_fill_1
XFILLER_129_1014 VPWR VGND sg13g2_decap_8
XFILLER_53_555 VPWR VGND sg13g2_decap_8
XFILLER_53_566 VPWR VGND sg13g2_fill_1
X_22652_ net462 coeff_force_packed\[26\] _03064_ _00645_ VPWR VGND sg13g2_mux2_1
XFILLER_40_216 VPWR VGND sg13g2_decap_8
XFILLER_22_920 VPWR VGND sg13g2_decap_8
X_21603_ _02220_ u_LMS.w\[7\]\[13\] _02168_ VPWR VGND sg13g2_xnor2_1
X_22583_ u_LMS.count\[28\] _03050_ u_LMS.count\[29\] _03053_ VPWR VGND sg13g2_nand3_1
XFILLER_22_964 VPWR VGND sg13g2_decap_8
X_21534_ _02151_ _02145_ _02150_ VPWR VGND sg13g2_xnor2_1
X_21465_ _02065_ _02081_ _02082_ VPWR VGND sg13g2_nor2_1
XFILLER_5_607 VPWR VGND sg13g2_decap_4
X_23204_ net1473 VGND VPWR _00266_ u_FIR.w\[7\]\[0\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
X_20416_ net22 VPWR _01078_ VGND net20 _01077_ sg13g2_o21ai_1
X_21396_ _02013_ net600 net226 VPWR VGND sg13g2_nand2_1
XFILLER_4_128 VPWR VGND sg13g2_fill_1
X_23135_ net1586 VGND VPWR _00197_ u_FIR.sum\[8\]\[7\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
X_20347_ _01000_ u_LMS.w\[5\]\[4\] _01009_ _01010_ VPWR VGND sg13g2_a21o_1
X_23230__1428 VPWR VGND net1427 sg13g2_tiehi
XFILLER_1_824 VPWR VGND sg13g2_fill_1
XFILLER_89_931 VPWR VGND sg13g2_decap_8
X_23066_ net1107 VGND VPWR _00128_ u_FIR.sum\[4\]\[9\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
X_20278_ _11120_ _11115_ _00941_ VPWR VGND sg13g2_xor2_1
XFILLER_1_846 VPWR VGND sg13g2_fill_2
X_22017_ _02611_ net578 net240 VPWR VGND sg13g2_nand2_1
XFILLER_48_305 VPWR VGND sg13g2_decap_4
XFILLER_49_839 VPWR VGND sg13g2_decap_8
XFILLER_48_316 VPWR VGND sg13g2_decap_8
XFILLER_0_389 VPWR VGND sg13g2_decap_4
XFILLER_102_273 VPWR VGND sg13g2_fill_1
XFILLER_88_496 VPWR VGND sg13g2_fill_1
XFILLER_124_52 VPWR VGND sg13g2_fill_1
XFILLER_48_349 VPWR VGND sg13g2_decap_8
XFILLER_64_809 VPWR VGND sg13g2_fill_2
XFILLER_75_157 VPWR VGND sg13g2_fill_1
X_14770_ _03367_ net850 _06058_ VPWR VGND sg13g2_nor2_1
X_11982_ net474 _03398_ spi_addr\[0\] _03399_ VPWR VGND sg13g2_nand3_1
XFILLER_1_1017 VPWR VGND sg13g2_decap_8
XFILLER_90_116 VPWR VGND sg13g2_fill_1
XFILLER_44_511 VPWR VGND sg13g2_fill_2
XFILLER_56_382 VPWR VGND sg13g2_decap_8
X_13721_ net852 _05047_ net748 _05048_ VPWR VGND sg13g2_nand3_1
XFILLER_16_224 VPWR VGND sg13g2_fill_1
X_22919_ VGND VPWR net555 u_s2p_input.reg_cnt\[0\] _03188_ u_s2p_input.reg_cnt\[1\]
+ sg13g2_a21oi_1
XFILLER_17_758 VPWR VGND sg13g2_fill_1
X_16440_ _07669_ u_FIR.sum\[7\]\[17\] net388 VPWR VGND sg13g2_xnor2_1
XFILLER_32_717 VPWR VGND sg13g2_fill_1
X_13652_ _04981_ _04974_ _04979_ VPWR VGND sg13g2_xnor2_1
XFILLER_16_279 VPWR VGND sg13g2_fill_2
XFILLER_32_739 VPWR VGND sg13g2_fill_1
X_12603_ _03971_ _03969_ _03970_ VPWR VGND sg13g2_nand2_1
X_16371_ _07581_ _07603_ _07604_ VPWR VGND sg13g2_nor2_1
X_13583_ _04877_ _04913_ _04914_ VPWR VGND sg13g2_nor2_1
XFILLER_24_290 VPWR VGND sg13g2_fill_1
XFILLER_12_441 VPWR VGND sg13g2_fill_1
X_18110_ VGND VPWR _09218_ _09219_ _09220_ _09213_ sg13g2_a21oi_1
X_15322_ _06590_ net276 _06589_ VPWR VGND sg13g2_xnor2_1
X_19090_ _10177_ _10146_ _10145_ VPWR VGND sg13g2_xnor2_1
X_12534_ _03908_ _03889_ _03907_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_946 VPWR VGND sg13g2_fill_1
XFILLER_40_783 VPWR VGND sg13g2_decap_8
XFILLER_9_968 VPWR VGND sg13g2_decap_4
X_18041_ _09017_ net39 _09157_ _09158_ VPWR VGND sg13g2_or3_1
XFILLER_129_159 VPWR VGND sg13g2_decap_8
X_15253_ _06523_ _06493_ _06521_ VPWR VGND sg13g2_xnor2_1
X_12465_ _03841_ _03833_ _03840_ VPWR VGND sg13g2_nand2_1
X_23001__1205 VPWR VGND net1204 sg13g2_tiehi
X_23163__1545 VPWR VGND net1544 sg13g2_tiehi
X_14204_ _05513_ _05470_ _05511_ VPWR VGND sg13g2_xnor2_1
X_15184_ _06455_ _06419_ _06422_ VPWR VGND sg13g2_nand2_1
X_12396_ _03774_ _03766_ _03772_ VPWR VGND sg13g2_xnor2_1
X_14135_ VGND VPWR _05407_ _05436_ _05445_ _05435_ sg13g2_a21oi_1
X_19992_ _11029_ VPWR _11033_ VGND _11030_ _11031_ sg13g2_o21ai_1
XFILLER_125_365 VPWR VGND sg13g2_fill_1
XFILLER_4_673 VPWR VGND sg13g2_decap_8
X_18943_ _10029_ net2119 _10030_ VPWR VGND sg13g2_xor2_1
X_14066_ _05378_ net761 net863 VPWR VGND sg13g2_nand2_1
XFILLER_98_249 VPWR VGND sg13g2_fill_1
XFILLER_79_441 VPWR VGND sg13g2_decap_8
X_13017_ _04369_ _04370_ _04371_ VPWR VGND sg13g2_nor2_1
X_18874_ _09961_ _09958_ _09959_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_400 VPWR VGND sg13g2_fill_2
XFILLER_67_614 VPWR VGND sg13g2_decap_4
X_17825_ VPWR _08958_ _08957_ VGND sg13g2_inv_1
XFILLER_39_338 VPWR VGND sg13g2_decap_8
X_17756_ net205 _08888_ net697 _08889_ VPWR VGND sg13g2_nand3_1
X_14968_ net1007 VPWR _06249_ VGND net510 u_FIR.sum\[5\]\[17\] sg13g2_o21ai_1
XFILLER_48_894 VPWR VGND sg13g2_fill_1
X_16707_ net716 u_LMS.w\[8\]\[23\] u_LMS.w\[8\]\[22\] u_LMS.w\[8\]\[21\] _07870_ VPWR
+ VGND sg13g2_nor4_1
X_13919_ _05240_ _05231_ _05238_ VPWR VGND sg13g2_xnor2_1
X_17687_ _08819_ _08818_ _08820_ VPWR VGND sg13g2_xor2_1
X_14899_ u_FIR.sum\[4\]\[14\] net396 _06183_ VPWR VGND sg13g2_and2_1
XFILLER_35_566 VPWR VGND sg13g2_fill_1
XFILLER_23_706 VPWR VGND sg13g2_fill_1
X_19426_ VPWR _10490_ _10489_ VGND sg13g2_inv_1
X_16638_ VGND VPWR net518 _07818_ _00254_ _07819_ sg13g2_a21oi_1
XFILLER_63_897 VPWR VGND sg13g2_fill_1
XFILLER_50_514 VPWR VGND sg13g2_decap_8
XFILLER_16_780 VPWR VGND sg13g2_decap_8
X_19357_ _10419_ _10420_ _10421_ VPWR VGND sg13g2_and2_1
X_16569_ VGND VPWR _03341_ net480 _00237_ _07767_ sg13g2_a21oi_1
X_18308_ _09411_ VPWR _09418_ VGND _09407_ _09412_ sg13g2_o21ai_1
XFILLER_88_0 VPWR VGND sg13g2_decap_4
X_19288_ _10352_ net639 net162 VPWR VGND sg13g2_nand2_1
XFILLER_30_282 VPWR VGND sg13g2_decap_4
X_18239_ _09349_ _09345_ _09348_ VPWR VGND sg13g2_nand2_1
X_21250_ _01867_ _01866_ _01864_ VPWR VGND sg13g2_nand2b_1
X_20201_ _00864_ _00833_ _00834_ VPWR VGND sg13g2_xnor2_1
Xrebuffer2101 _09591_ net2100 VPWR VGND sg13g2_buf_1
XFILLER_116_343 VPWR VGND sg13g2_fill_2
X_21181_ _01794_ VPWR _01798_ VGND _01795_ _01796_ sg13g2_o21ai_1
XFILLER_132_814 VPWR VGND sg13g2_fill_1
Xrebuffer2123 _00855_ net2122 VPWR VGND sg13g2_buf_1
Xrebuffer2134 _10803_ net2133 VPWR VGND sg13g2_buf_1
XFILLER_116_376 VPWR VGND sg13g2_fill_2
Xrebuffer2145 net2145 net2144 VPWR VGND sg13g2_buf_1
X_20132_ net425 _11172_ _11173_ VPWR VGND sg13g2_nor2_1
Xrebuffer2156 _07904_ net2155 VPWR VGND sg13g2_buf_1
Xfanout903 net911 net903 VPWR VGND sg13g2_buf_1
Xrebuffer2167 net2179 net2166 VPWR VGND sg13g2_buf_1
Xfanout914 net915 net914 VPWR VGND sg13g2_buf_1
Xrebuffer2178 _02840_ net2177 VPWR VGND sg13g2_buf_1
XFILLER_98_750 VPWR VGND sg13g2_fill_1
Xfanout925 net926 net925 VPWR VGND sg13g2_buf_1
Xfanout936 net937 net936 VPWR VGND sg13g2_buf_1
X_20063_ _11104_ _11103_ _11100_ VPWR VGND sg13g2_nand2b_1
XFILLER_86_912 VPWR VGND sg13g2_decap_8
Xfanout947 net948 net947 VPWR VGND sg13g2_buf_1
Xfanout958 net959 net958 VPWR VGND sg13g2_buf_1
Xfanout969 net970 net969 VPWR VGND sg13g2_buf_1
XFILLER_58_636 VPWR VGND sg13g2_decap_4
XFILLER_38_38 VPWR VGND sg13g2_decap_8
XFILLER_86_956 VPWR VGND sg13g2_fill_2
XFILLER_57_135 VPWR VGND sg13g2_decap_8
XFILLER_86_989 VPWR VGND sg13g2_decap_4
XFILLER_73_617 VPWR VGND sg13g2_decap_4
XFILLER_39_872 VPWR VGND sg13g2_fill_2
XFILLER_54_831 VPWR VGND sg13g2_fill_1
X_20965_ _01603_ _01604_ _01605_ VPWR VGND sg13g2_nor2_1
X_23753_ net1346 VGND VPWR _00815_ u_LMS.x\[4\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
XFILLER_26_555 VPWR VGND sg13g2_fill_1
X_22704_ u_debug_unit.error_signal_sync\[2\] _07913_ net332 _00690_ VPWR VGND sg13g2_mux2_1
X_20896_ _01536_ _01303_ _01333_ VPWR VGND sg13g2_xnor2_1
X_23684_ net1017 VGND VPWR _00746_ u_debug_unit.mon_w7_sync\[1\] clknet_leaf_18_clkA
+ sg13g2_dfrbpq_1
X_22635_ net460 coeff_force_packed\[13\] _03062_ _00630_ VPWR VGND sg13g2_mux2_1
X_23274__1346 VPWR VGND net1345 sg13g2_tiehi
X_22566_ _03042_ u_LMS.count\[23\] u_LMS.count\[22\] _03039_ VPWR VGND sg13g2_and3_1
X_21517_ _02134_ _02130_ _02133_ VPWR VGND sg13g2_nand2_1
X_22497_ net958 VPWR _02998_ VGND net441 net574 sg13g2_o21ai_1
XFILLER_126_107 VPWR VGND sg13g2_fill_2
X_12250_ _03632_ _03623_ _03630_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_426 VPWR VGND sg13g2_decap_8
X_21448_ VPWR _02065_ _02064_ VGND sg13g2_inv_1
X_12181_ net943 u_spi_slave.rx_shift\[11\] _00003_ VPWR VGND sg13g2_nor2b_1
X_21379_ _01989_ VPWR _01996_ VGND _01970_ _01979_ sg13g2_o21ai_1
XFILLER_79_67 VPWR VGND sg13g2_decap_8
X_23118_ net1612 VGND VPWR _00180_ u_FIR.sum\[7\]\[4\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
XFILLER_123_858 VPWR VGND sg13g2_fill_2
X_23049_ net1132 VGND VPWR _00111_ u_FIR.sum\[3\]\[11\] clknet_leaf_33_clkA sg13g2_dfrbpq_1
X_15940_ VGND VPWR net498 _07183_ _00191_ _07184_ sg13g2_a21oi_1
XFILLER_95_11 VPWR VGND sg13g2_fill_2
XFILLER_88_271 VPWR VGND sg13g2_fill_1
XFILLER_0_175 VPWR VGND sg13g2_decap_8
XFILLER_0_197 VPWR VGND sg13g2_decap_8
X_15871_ VGND VPWR _07087_ _07110_ _07118_ _07109_ sg13g2_a21oi_1
XFILLER_49_658 VPWR VGND sg13g2_fill_2
X_17610_ _08743_ net691 net166 VPWR VGND sg13g2_nand2_1
XFILLER_64_606 VPWR VGND sg13g2_fill_1
X_14822_ _06109_ _06101_ _06107_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_477 VPWR VGND sg13g2_decap_8
X_18590_ _09696_ net304 u_LMS.w\[2\]\[16\] coeff_force_packed\[18\] net559 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_36_319 VPWR VGND sg13g2_fill_1
XFILLER_91_425 VPWR VGND sg13g2_decap_4
XFILLER_45_820 VPWR VGND sg13g2_decap_8
XFILLER_17_511 VPWR VGND sg13g2_decap_8
XFILLER_17_522 VPWR VGND sg13g2_fill_2
X_17541_ _08674_ net689 net166 VPWR VGND sg13g2_nand2_1
XFILLER_63_138 VPWR VGND sg13g2_fill_2
X_14753_ _06040_ _06007_ _06042_ VPWR VGND sg13g2_xor2_1
XFILLER_91_458 VPWR VGND sg13g2_fill_2
X_11965_ _03385_ u_spi_slave.rd_toggle_q u_spi_slave.rd_toggle VPWR VGND sg13g2_xnor2_1
XFILLER_44_330 VPWR VGND sg13g2_fill_2
X_13704_ _05032_ _05003_ _05031_ VPWR VGND sg13g2_nand2b_1
X_17472_ VGND VPWR _08596_ _08604_ _08605_ _08594_ sg13g2_a21oi_1
X_14684_ net862 _05973_ net767 _05974_ VPWR VGND sg13g2_nand3_1
XFILLER_60_823 VPWR VGND sg13g2_decap_8
XFILLER_32_514 VPWR VGND sg13g2_fill_2
X_11896_ VPWR _03317_ u_LMS.w\[5\]\[22\] VGND sg13g2_inv_1
XFILLER_44_385 VPWR VGND sg13g2_fill_1
X_19211_ net560 coeff_force_packed\[27\] _10292_ VPWR VGND sg13g2_and2_1
X_16423_ _07653_ _07635_ _07652_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_547 VPWR VGND sg13g2_decap_4
X_13635_ _04950_ VPWR _04964_ VGND _04901_ _04940_ sg13g2_o21ai_1
X_19142_ _10186_ VPWR _10229_ VGND _10227_ _10226_ sg13g2_o21ai_1
X_16354_ _07522_ _07586_ _07587_ VPWR VGND sg13g2_nor2_1
X_13566_ VGND VPWR _04897_ _04895_ _04863_ sg13g2_or2_1
XFILLER_81_7 VPWR VGND sg13g2_decap_4
X_15305_ _06548_ VPWR _06573_ VGND net250 _06549_ sg13g2_o21ai_1
X_19073_ _10160_ _10159_ _10158_ VPWR VGND sg13g2_nand2b_1
X_12517_ _03873_ VPWR _03891_ VGND _03832_ _03875_ sg13g2_o21ai_1
X_16285_ _07495_ VPWR _07520_ VGND net272 _07496_ sg13g2_o21ai_1
X_13497_ VGND VPWR _04827_ _04829_ _04831_ _04815_ sg13g2_a21oi_1
XFILLER_9_787 VPWR VGND sg13g2_decap_8
X_18024_ _09145_ net321 _09144_ VPWR VGND sg13g2_nand2_1
X_15236_ _06506_ net778 _06504_ VPWR VGND sg13g2_nand2_1
X_12448_ _03805_ VPWR _03824_ VGND _03767_ _03803_ sg13g2_o21ai_1
X_15167_ _06438_ _06435_ _06439_ VPWR VGND sg13g2_nor2b_1
XFILLER_125_151 VPWR VGND sg13g2_fill_2
X_12379_ VGND VPWR _03723_ _03730_ _03757_ _03737_ sg13g2_a21oi_1
XFILLER_5_42 VPWR VGND sg13g2_decap_8
XFILLER_99_525 VPWR VGND sg13g2_fill_2
X_14118_ _05429_ u_FIR.w\[4\]\[6\] _05428_ VPWR VGND sg13g2_xnor2_1
XFILLER_4_481 VPWR VGND sg13g2_decap_8
XFILLER_113_335 VPWR VGND sg13g2_fill_1
X_19975_ _11016_ _11005_ _11015_ VPWR VGND sg13g2_nand2_1
X_15098_ net980 VPWR _06372_ VGND net484 u_FIR.sum\[6\]\[5\] sg13g2_o21ai_1
XFILLER_113_357 VPWR VGND sg13g2_fill_2
X_18926_ _10011_ _09978_ _10013_ VPWR VGND sg13g2_xor2_1
X_14049_ _05361_ _05334_ _05362_ VPWR VGND sg13g2_xor2_1
XFILLER_68_934 VPWR VGND sg13g2_decap_4
XFILLER_68_956 VPWR VGND sg13g2_fill_2
X_18857_ _09944_ u_LMS.x_r\[3\]\[7\] net251 VPWR VGND sg13g2_nand2_1
XFILLER_68_978 VPWR VGND sg13g2_fill_1
X_17808_ VGND VPWR _08941_ _08936_ _08930_ sg13g2_or2_1
X_18788_ _09870_ _09872_ _09874_ _09875_ VPWR VGND sg13g2_nor3_1
XFILLER_94_285 VPWR VGND sg13g2_fill_1
XFILLER_94_296 VPWR VGND sg13g2_fill_2
X_17739_ _08843_ _08871_ _08872_ VPWR VGND sg13g2_and2_1
XFILLER_78_1030 VPWR VGND sg13g2_decap_8
XFILLER_35_330 VPWR VGND sg13g2_decap_8
X_23367__1235 VPWR VGND net1234 sg13g2_tiehi
XFILLER_82_469 VPWR VGND sg13g2_decap_4
X_20750_ _01389_ _01340_ _01390_ VPWR VGND sg13g2_nor2_2
XFILLER_91_981 VPWR VGND sg13g2_decap_8
XFILLER_39_1025 VPWR VGND sg13g2_decap_4
XFILLER_23_514 VPWR VGND sg13g2_decap_4
X_19409_ _10473_ _10472_ _10468_ VPWR VGND sg13g2_nand2b_1
X_20681_ _01321_ _01319_ _01320_ VPWR VGND sg13g2_nand2_1
XFILLER_126_1028 VPWR VGND sg13g2_decap_8
X_23428__1065 VPWR VGND net1064 sg13g2_tiehi
XFILLER_51_889 VPWR VGND sg13g2_decap_8
X_22420_ VGND VPWR net432 net422 _00518_ _02959_ sg13g2_a21oi_1
XFILLER_31_580 VPWR VGND sg13g2_decap_4
XFILLER_31_591 VPWR VGND sg13g2_fill_1
X_22351_ net358 VPWR _02924_ VGND u_LMS.w\[8\]\[10\] net376 sg13g2_o21ai_1
XFILLER_40_28 VPWR VGND sg13g2_decap_4
X_21302_ _01919_ _01914_ _01917_ VPWR VGND sg13g2_xnor2_1
X_22282_ net2171 VPWR _02870_ VGND _02826_ _02869_ sg13g2_o21ai_1
X_21233_ _01850_ _01849_ net116 VPWR VGND sg13g2_nand2b_1
XFILLER_2_429 VPWR VGND sg13g2_decap_8
XFILLER_105_847 VPWR VGND sg13g2_decap_8
X_21164_ net152 VPWR _01781_ VGND net603 net605 sg13g2_o21ai_1
XFILLER_132_644 VPWR VGND sg13g2_decap_8
XFILLER_104_346 VPWR VGND sg13g2_fill_1
Xfanout700 u_LMS.x_r\[1\]\[0\] net700 VPWR VGND sg13g2_buf_1
XFILLER_49_37 VPWR VGND sg13g2_fill_1
XFILLER_104_368 VPWR VGND sg13g2_fill_2
X_20115_ _03236_ _03237_ net236 net252 _11156_ VPWR VGND sg13g2_nor4_1
X_23121__1608 VPWR VGND net1607 sg13g2_tiehi
Xfanout711 u_LMS.x_r\[0\]\[2\] net711 VPWR VGND sg13g2_buf_1
Xfanout722 u_FIR.w\[8\]\[3\] net722 VPWR VGND sg13g2_buf_1
X_21095_ _01718_ _01719_ _00433_ VPWR VGND sg13g2_nor2_1
Xfanout733 net734 net733 VPWR VGND sg13g2_buf_1
Xfanout744 u_FIR.w\[6\]\[2\] net744 VPWR VGND sg13g2_buf_1
XFILLER_86_720 VPWR VGND sg13g2_decap_4
Xfanout755 u_FIR.w\[5\]\[0\] net755 VPWR VGND sg13g2_buf_1
XFILLER_131_187 VPWR VGND sg13g2_decap_8
X_20046_ _11087_ _11079_ _11086_ VPWR VGND sg13g2_nand2_1
Xfanout766 u_FIR.w\[4\]\[0\] net766 VPWR VGND sg13g2_buf_1
Xfanout777 u_FIR.w\[2\]\[4\] net777 VPWR VGND sg13g2_buf_1
XFILLER_59_967 VPWR VGND sg13g2_fill_1
Xfanout788 u_FIR.w\[1\]\[2\] net788 VPWR VGND sg13g2_buf_1
XFILLER_86_764 VPWR VGND sg13g2_decap_8
XFILLER_19_809 VPWR VGND sg13g2_fill_1
Xfanout799 net800 net799 VPWR VGND sg13g2_buf_1
XFILLER_45_105 VPWR VGND sg13g2_decap_4
XFILLER_39_680 VPWR VGND sg13g2_decap_8
XFILLER_61_609 VPWR VGND sg13g2_decap_8
X_21997_ _02581_ VPWR _02591_ VGND _02576_ _02582_ sg13g2_o21ai_1
XFILLER_42_812 VPWR VGND sg13g2_fill_1
XFILLER_27_886 VPWR VGND sg13g2_decap_8
X_23736_ net996 VGND VPWR _00798_ spi_addr\[2\] clknet_3_5__leaf_spi_sclk sg13g2_dfrbpq_1
XFILLER_14_514 VPWR VGND sg13g2_fill_1
X_20948_ _03304_ _01587_ _01588_ VPWR VGND sg13g2_nor2_1
XFILLER_41_300 VPWR VGND sg13g2_fill_1
XFILLER_121_75 VPWR VGND sg13g2_decap_8
XFILLER_121_86 VPWR VGND sg13g2_fill_2
XFILLER_41_344 VPWR VGND sg13g2_fill_2
X_23667_ net1010 VGND VPWR _00729_ u_debug_unit.mon_w4_sync\[5\] clknet_leaf_17_clkA
+ sg13g2_dfrbpq_1
XFILLER_81_57 VPWR VGND sg13g2_fill_2
X_20879_ VGND VPWR _01517_ _01518_ _01519_ _01495_ sg13g2_a21oi_1
X_13420_ _04760_ VPWR _04762_ VGND _04733_ _04735_ sg13g2_o21ai_1
X_22618_ net458 sys_enable_bus\[7\] _03060_ _00615_ VPWR VGND sg13g2_mux2_1
X_23598_ net1017 VGND VPWR _00660_ coeff_force_packed\[39\] clknet_leaf_20_clkA sg13g2_dfrbpq_1
XFILLER_128_917 VPWR VGND sg13g2_fill_1
X_13351_ _04695_ _04694_ _04659_ VPWR VGND sg13g2_nand2b_1
X_22549_ _03030_ _03031_ _00575_ VPWR VGND sg13g2_nor2_1
XFILLER_127_416 VPWR VGND sg13g2_fill_1
X_12302_ _03682_ _03681_ _03652_ VPWR VGND sg13g2_nand2b_1
X_16070_ net832 net802 u_FIR.sum\[7\]\[5\] _07311_ VPWR VGND sg13g2_a21o_1
X_13282_ _04627_ _04595_ _04628_ VPWR VGND sg13g2_nor2b_1
XFILLER_108_663 VPWR VGND sg13g2_decap_8
X_15021_ VGND VPWR _06297_ _06296_ _06278_ sg13g2_or2_1
X_12233_ _03616_ _03610_ _03615_ VPWR VGND sg13g2_nand2_1
XFILLER_30_61 VPWR VGND sg13g2_decap_4
XFILLER_123_600 VPWR VGND sg13g2_decap_8
X_23074__1096 VPWR VGND net1095 sg13g2_tiehi
X_12164_ _03572_ u_spi_slave.bit_cnt\[1\] u_spi_slave.bit_cnt\[0\] u_spi_slave.bit_cnt\[2\]
+ VPWR VGND sg13g2_and3_1
XFILLER_68_208 VPWR VGND sg13g2_fill_2
X_19760_ _10397_ _10416_ _10425_ _10824_ VPWR VGND sg13g2_nor3_1
X_16972_ _08128_ _08126_ _08127_ VPWR VGND sg13g2_nand2_1
X_12095_ _03507_ net288 coeff_force_packed\[59\] _03416_ u_debug_unit.mon_w8_sync\[3\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_2_985 VPWR VGND sg13g2_decap_8
XFILLER_110_338 VPWR VGND sg13g2_decap_4
X_18711_ _09798_ net667 net145 VPWR VGND sg13g2_nand2_1
X_15923_ _07167_ net273 _07168_ VPWR VGND sg13g2_xor2_1
X_19691_ _10755_ _10722_ _10723_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_1045 VPWR VGND sg13g2_decap_8
XFILLER_65_915 VPWR VGND sg13g2_fill_2
X_18642_ net354 VPWR _09737_ VGND u_LMS.w\[2\]\[4\] net370 sg13g2_o21ai_1
XFILLER_76_263 VPWR VGND sg13g2_decap_8
X_15854_ _07102_ u_FIR.sum\[6\]\[12\] net391 VPWR VGND sg13g2_nand2_1
XFILLER_49_488 VPWR VGND sg13g2_decap_8
XFILLER_92_745 VPWR VGND sg13g2_decap_4
X_14805_ _06092_ u_FIR.w\[3\]\[6\] net837 VPWR VGND sg13g2_nand2b_1
X_18573_ _09682_ net33 net35 _09683_ VPWR VGND sg13g2_a21o_1
XFILLER_64_458 VPWR VGND sg13g2_fill_1
X_15785_ _06991_ VPWR _07035_ VGND _06949_ _06989_ sg13g2_o21ai_1
X_12997_ _04354_ _04353_ _04352_ VPWR VGND sg13g2_nand2b_1
XFILLER_73_970 VPWR VGND sg13g2_decap_8
X_17524_ _08655_ _08656_ _08657_ VPWR VGND sg13g2_and2_1
X_14736_ _06025_ _05980_ _06024_ VPWR VGND sg13g2_xnor2_1
XFILLER_18_897 VPWR VGND sg13g2_decap_4
X_11948_ VPWR _03369_ net772 VGND sg13g2_inv_1
XFILLER_33_856 VPWR VGND sg13g2_decap_8
X_17455_ _03269_ net99 _08588_ VPWR VGND sg13g2_nor2_1
XFILLER_60_642 VPWR VGND sg13g2_decap_8
X_14667_ _05957_ _05949_ _05958_ VPWR VGND sg13g2_xor2_1
X_11879_ VPWR _03300_ u_LMS.w\[7\]\[5\] VGND sg13g2_inv_1
X_16406_ _07636_ VPWR _07637_ VGND _07588_ _07617_ sg13g2_o21ai_1
XFILLER_60_686 VPWR VGND sg13g2_fill_1
X_13618_ _04948_ _04947_ _04906_ VPWR VGND sg13g2_nand2b_1
X_17386_ VGND VPWR u_LMS.w\[0\]\[20\] net313 _08534_ _08524_ sg13g2_a21oi_1
X_14598_ _05876_ VPWR _05890_ VGND _05871_ _05874_ sg13g2_o21ai_1
X_19125_ _10212_ u_LMS.w\[3\]\[6\] _10194_ VPWR VGND sg13g2_xnor2_1
X_16337_ _07571_ _07564_ _07569_ VPWR VGND sg13g2_xnor2_1
X_13549_ _04881_ _04859_ _04879_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_562 VPWR VGND sg13g2_decap_8
XFILLER_9_573 VPWR VGND sg13g2_fill_2
X_19056_ VGND VPWR _09976_ _10143_ _10141_ _09977_ sg13g2_a21oi_2
XFILLER_118_449 VPWR VGND sg13g2_fill_1
X_16268_ _07504_ _07503_ _07465_ VPWR VGND sg13g2_nand2b_1
X_18007_ VGND VPWR _09130_ _09131_ _00311_ net919 sg13g2_a21oi_1
X_15219_ net1003 VPWR _06490_ VGND net496 u_FIR.sum\[6\]\[8\] sg13g2_o21ai_1
X_16199_ _07437_ _07402_ _07435_ VPWR VGND sg13g2_xnor2_1
XFILLER_114_611 VPWR VGND sg13g2_decap_8
X_23749__1379 VPWR VGND net1378 sg13g2_tiehi
XFILLER_101_305 VPWR VGND sg13g2_fill_1
X_19958_ _10999_ _10987_ _10997_ VPWR VGND sg13g2_xnor2_1
XFILLER_68_731 VPWR VGND sg13g2_fill_2
XFILLER_132_1010 VPWR VGND sg13g2_decap_8
X_18909_ _03257_ net139 _09996_ VPWR VGND sg13g2_nor2_1
X_19889_ net360 VPWR _10932_ VGND u_LMS.w\[4\]\[10\] net376 sg13g2_o21ai_1
XFILLER_67_252 VPWR VGND sg13g2_fill_2
XFILLER_110_872 VPWR VGND sg13g2_decap_8
X_21920_ _02514_ _02509_ _02512_ VPWR VGND sg13g2_xnor2_1
XFILLER_55_414 VPWR VGND sg13g2_fill_2
XFILLER_82_211 VPWR VGND sg13g2_fill_1
X_21851_ _02439_ VPWR _02445_ VGND _02349_ _02440_ sg13g2_o21ai_1
X_20802_ _01435_ VPWR _01442_ VGND _01404_ _01433_ sg13g2_o21ai_1
X_21782_ net148 VPWR _02376_ VGND net585 net588 sg13g2_o21ai_1
XFILLER_42_119 VPWR VGND sg13g2_decap_8
XFILLER_63_480 VPWR VGND sg13g2_decap_8
X_23521_ net1332 VGND VPWR _00583_ u_LMS.count\[24\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
X_20733_ _01335_ _01372_ _01373_ VPWR VGND sg13g2_nor2_1
XFILLER_23_344 VPWR VGND sg13g2_decap_8
XFILLER_50_141 VPWR VGND sg13g2_fill_1
XFILLER_51_686 VPWR VGND sg13g2_fill_1
X_20664_ _01304_ net606 net236 VPWR VGND sg13g2_nand2_1
X_23452_ net1575 VGND VPWR _00514_ u_LMS.x_r\[3\]\[3\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
XFILLER_23_388 VPWR VGND sg13g2_decap_4
X_22403_ net949 VPWR _02951_ VGND net438 u_LMS.x_r\[2\]\[7\] sg13g2_o21ai_1
XFILLER_13_1006 VPWR VGND sg13g2_fill_1
X_23383_ net1199 VGND VPWR _00445_ u_LMS.w\[7\]\[16\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
X_20595_ VGND VPWR _01215_ _01217_ _01235_ _01234_ sg13g2_a21oi_1
XFILLER_109_427 VPWR VGND sg13g2_fill_1
XFILLER_13_1028 VPWR VGND sg13g2_decap_8
XFILLER_129_7 VPWR VGND sg13g2_decap_8
XFILLER_109_438 VPWR VGND sg13g2_fill_1
XFILLER_109_449 VPWR VGND sg13g2_fill_1
X_22334_ VGND VPWR net47 _02910_ _02911_ net6 sg13g2_a21oi_1
XFILLER_118_972 VPWR VGND sg13g2_decap_8
X_22265_ VGND VPWR _02855_ _02856_ _00466_ net930 sg13g2_a21oi_1
X_21216_ _01833_ net594 net169 VPWR VGND sg13g2_nand2_1
X_22196_ _02789_ _02788_ _02790_ VPWR VGND sg13g2_nor2b_1
XFILLER_132_463 VPWR VGND sg13g2_decap_8
X_21147_ net150 VPWR _01764_ VGND net596 net598 sg13g2_o21ai_1
XFILLER_132_474 VPWR VGND sg13g2_fill_2
Xfanout530 net531 net530 VPWR VGND sg13g2_buf_1
Xfanout541 net548 net541 VPWR VGND sg13g2_buf_1
XFILLER_116_75 VPWR VGND sg13g2_decap_8
Xfanout552 u_p2s_output.o_valid net552 VPWR VGND sg13g2_buf_1
X_21078_ _01655_ VPWR _01706_ VGND net2070 _01654_ sg13g2_o21ai_1
Xfanout563 net568 net563 VPWR VGND sg13g2_buf_1
XFILLER_76_46 VPWR VGND sg13g2_decap_8
Xfanout574 net575 net574 VPWR VGND sg13g2_buf_1
XFILLER_101_861 VPWR VGND sg13g2_fill_2
XFILLER_47_915 VPWR VGND sg13g2_decap_8
Xfanout585 u_LMS.x_r\[8\]\[1\] net585 VPWR VGND sg13g2_buf_1
X_20029_ _03238_ net142 _11070_ VPWR VGND sg13g2_nor2_1
Xfanout596 u_LMS.x_r\[7\]\[4\] net596 VPWR VGND sg13g2_buf_1
X_12920_ net1040 VPWR _04280_ VGND net546 u_FIR.sum\[1\]\[11\] sg13g2_o21ai_1
XFILLER_59_797 VPWR VGND sg13g2_fill_2
XFILLER_58_285 VPWR VGND sg13g2_fill_2
X_12851_ _04180_ _04173_ _04187_ _04212_ VPWR VGND sg13g2_a21o_1
XFILLER_132_63 VPWR VGND sg13g2_decap_8
XFILLER_34_609 VPWR VGND sg13g2_fill_1
XFILLER_73_266 VPWR VGND sg13g2_fill_2
X_11802_ VPWR _03223_ net600 VGND sg13g2_inv_1
X_15570_ _06795_ _06824_ _06825_ VPWR VGND sg13g2_nor2_1
XFILLER_15_823 VPWR VGND sg13g2_fill_1
X_12782_ _04145_ net733 net830 VPWR VGND sg13g2_nand2_1
X_14521_ _05816_ _05810_ _05814_ VPWR VGND sg13g2_xnor2_1
XFILLER_70_951 VPWR VGND sg13g2_decap_4
X_23719_ net1389 VGND VPWR _00781_ u_s2p_input.reg_sh\[0\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
XFILLER_25_61 VPWR VGND sg13g2_decap_4
XFILLER_14_355 VPWR VGND sg13g2_decap_4
XFILLER_109_1056 VPWR VGND sg13g2_decap_4
X_17240_ _08396_ u_LMS.w\[0\]\[19\] net71 VPWR VGND sg13g2_xnor2_1
XFILLER_25_94 VPWR VGND sg13g2_fill_2
X_14452_ VGND VPWR _05720_ _05751_ _05752_ _05740_ sg13g2_a21oi_1
X_13403_ _04742_ _04744_ _04745_ VPWR VGND sg13g2_nor2_1
X_17171_ _03282_ net237 net231 _08323_ _08327_ VPWR VGND sg13g2_nor4_1
X_14383_ _05687_ _05668_ _05685_ VPWR VGND sg13g2_xnor2_1
XFILLER_10_550 VPWR VGND sg13g2_fill_1
XFILLER_128_736 VPWR VGND sg13g2_decap_8
X_16122_ VGND VPWR net476 _07360_ _00196_ _07361_ sg13g2_a21oi_1
X_13334_ _04653_ VPWR _04678_ VGND _04643_ _04654_ sg13g2_o21ai_1
XFILLER_6_532 VPWR VGND sg13g2_fill_1
XFILLER_127_257 VPWR VGND sg13g2_fill_2
XFILLER_109_972 VPWR VGND sg13g2_fill_2
X_16053_ _07256_ _07293_ _07294_ VPWR VGND sg13g2_nor2_1
X_13265_ _04608_ _04610_ _04611_ VPWR VGND sg13g2_nor2b_1
X_15004_ _06281_ net902 net780 net888 net781 VPWR VGND sg13g2_a22oi_1
XFILLER_124_942 VPWR VGND sg13g2_fill_1
X_12216_ _03600_ net906 net724 net894 net725 VPWR VGND sg13g2_a22oi_1
XFILLER_44_7 VPWR VGND sg13g2_fill_2
XFILLER_124_953 VPWR VGND sg13g2_decap_8
X_13196_ _04544_ _04539_ _04542_ VPWR VGND sg13g2_xnor2_1
XFILLER_29_1035 VPWR VGND sg13g2_fill_2
XFILLER_124_986 VPWR VGND sg13g2_decap_8
X_19812_ VGND VPWR _10870_ _10871_ _00376_ net930 sg13g2_a21oi_1
XFILLER_97_826 VPWR VGND sg13g2_decap_8
X_12147_ _03556_ net294 net569 _03400_ u_debug_unit.mon_w3_sync\[0\] VPWR VGND sg13g2_a22oi_1
XFILLER_110_124 VPWR VGND sg13g2_fill_1
XFILLER_2_21 VPWR VGND sg13g2_decap_8
XFILLER_1_281 VPWR VGND sg13g2_decap_8
X_19743_ VGND VPWR _10748_ _10805_ _10807_ _10747_ sg13g2_a21oi_1
XFILLER_96_358 VPWR VGND sg13g2_decap_8
X_16955_ _08111_ _08108_ _08109_ VPWR VGND sg13g2_xnor2_1
X_12078_ _03488_ _03489_ _03487_ _03491_ VPWR VGND _03490_ sg13g2_nand4_1
XFILLER_49_263 VPWR VGND sg13g2_fill_2
X_15906_ _07151_ net273 _07152_ VPWR VGND sg13g2_xor2_1
X_19674_ _10738_ _10466_ _10737_ VPWR VGND sg13g2_nand2_1
X_16886_ _08042_ _08041_ _08029_ VPWR VGND sg13g2_nand2b_1
XFILLER_64_211 VPWR VGND sg13g2_decap_8
XFILLER_2_98 VPWR VGND sg13g2_decap_8
XFILLER_37_447 VPWR VGND sg13g2_decap_8
X_18625_ VGND VPWR _09722_ _09723_ _00337_ net919 sg13g2_a21oi_1
X_15837_ _07080_ _07082_ _07085_ VPWR VGND sg13g2_nor2_1
XFILLER_52_406 VPWR VGND sg13g2_fill_1
XFILLER_18_672 VPWR VGND sg13g2_fill_2
X_18556_ _09666_ u_LMS.w\[2\]\[21\] net70 VPWR VGND sg13g2_nand2_1
X_15768_ VGND VPWR _06979_ _06995_ _07018_ _07004_ sg13g2_a21oi_1
XFILLER_17_182 VPWR VGND sg13g2_decap_4
X_17507_ _08636_ VPWR _08640_ VGND _08637_ _08638_ sg13g2_o21ai_1
X_14719_ _05995_ VPWR _06008_ VGND _05991_ _05993_ sg13g2_o21ai_1
X_18487_ _09597_ u_LMS.w\[2\]\[13\] net1653 VPWR VGND sg13g2_nand2_1
X_15699_ _06951_ net832 net787 net819 net788 VPWR VGND sg13g2_a22oi_1
X_17438_ _08574_ _08450_ _08452_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_196 VPWR VGND sg13g2_fill_2
X_17369_ _08520_ net315 u_LMS.w\[0\]\[17\] coeff_force_packed\[5\] net567 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_70_0 VPWR VGND sg13g2_decap_8
X_19108_ _10120_ _10123_ _10117_ _10195_ VPWR VGND sg13g2_nand3_1
XFILLER_118_224 VPWR VGND sg13g2_fill_2
X_20380_ _01043_ u_LMS.w\[5\]\[16\] _00976_ VPWR VGND sg13g2_xnor2_1
X_19039_ _10115_ _10107_ _10126_ VPWR VGND sg13g2_xor2_1
XFILLER_127_791 VPWR VGND sg13g2_fill_2
X_22050_ _02644_ net2169 _02642_ VPWR VGND sg13g2_xnor2_1
XFILLER_115_942 VPWR VGND sg13g2_decap_4
XFILLER_88_804 VPWR VGND sg13g2_decap_8
X_21001_ VPWR _01641_ _01640_ VGND sg13g2_inv_1
XFILLER_114_463 VPWR VGND sg13g2_decap_4
XFILLER_115_997 VPWR VGND sg13g2_decap_8
XFILLER_99_174 VPWR VGND sg13g2_fill_1
XFILLER_101_113 VPWR VGND sg13g2_decap_8
XFILLER_88_859 VPWR VGND sg13g2_decap_4
XFILLER_101_124 VPWR VGND sg13g2_fill_2
XFILLER_130_956 VPWR VGND sg13g2_fill_2
X_23032__1159 VPWR VGND net1158 sg13g2_tiehi
X_22952_ net461 u_spi_slave.rx_shift\[5\] _03575_ _00809_ VPWR VGND sg13g2_mux2_1
XFILLER_29_959 VPWR VGND sg13g2_decap_4
X_21903_ _02497_ _02495_ _02496_ VPWR VGND sg13g2_nand2b_1
XFILLER_55_233 VPWR VGND sg13g2_decap_4
X_22883_ _03162_ _03169_ _00771_ VPWR VGND sg13g2_nor2_1
XFILLER_102_33 VPWR VGND sg13g2_decap_8
X_21834_ _02428_ net576 net167 VPWR VGND sg13g2_nand2_1
XFILLER_102_88 VPWR VGND sg13g2_fill_2
X_21765_ net150 VPWR _02359_ VGND net578 net581 sg13g2_o21ai_1
X_23504_ net1398 VGND VPWR _00566_ u_LMS.count\[7\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
X_20716_ _01356_ _01317_ _01318_ VPWR VGND sg13g2_xnor2_1
X_21696_ net322 VPWR _02301_ VGND u_LMS.w\[7\]\[24\] net63 sg13g2_o21ai_1
X_23435_ net VGND VPWR _00497_ u_LMS.x_r\[1\]\[2\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
X_20647_ _01287_ _01281_ _01286_ VPWR VGND sg13g2_xnor2_1
X_20578_ _01213_ VPWR _01218_ VGND _01201_ _01211_ sg13g2_o21ai_1
X_23366_ net1235 VGND VPWR _00428_ u_LMS.w\[6\]\[22\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
XFILLER_125_717 VPWR VGND sg13g2_decap_4
XFILLER_109_268 VPWR VGND sg13g2_fill_1
X_22317_ _02898_ u_LMS.w\[8\]\[2\] _02687_ VPWR VGND sg13g2_xnor2_1
X_23297_ net1304 VGND VPWR _00359_ u_LMS.w\[3\]\[22\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
XFILLER_3_513 VPWR VGND sg13g2_fill_1
XFILLER_124_238 VPWR VGND sg13g2_fill_2
X_13050_ _04400_ _04376_ _04402_ VPWR VGND sg13g2_xor2_1
X_22248_ _02842_ net2172 _02841_ VPWR VGND sg13g2_nand2_1
XFILLER_127_63 VPWR VGND sg13g2_decap_8
XFILLER_79_815 VPWR VGND sg13g2_fill_1
X_12001_ net327 _03417_ _03418_ VPWR VGND sg13g2_nor2_1
XFILLER_3_579 VPWR VGND sg13g2_fill_1
XFILLER_121_912 VPWR VGND sg13g2_fill_1
X_22179_ _02773_ _02699_ _02701_ VPWR VGND sg13g2_xnor2_1
XFILLER_120_400 VPWR VGND sg13g2_decap_4
XFILLER_105_485 VPWR VGND sg13g2_fill_1
XFILLER_120_422 VPWR VGND sg13g2_decap_8
X_23362__1240 VPWR VGND net1239 sg13g2_tiehi
XFILLER_121_956 VPWR VGND sg13g2_decap_8
XFILLER_121_967 VPWR VGND sg13g2_fill_2
XFILLER_120_444 VPWR VGND sg13g2_decap_4
Xfanout360 net367 net360 VPWR VGND sg13g2_buf_1
Xclkbuf_leaf_16_clkA clknet_4_8_0_clkA clknet_leaf_16_clkA VPWR VGND sg13g2_buf_8
Xfanout371 net372 net371 VPWR VGND sg13g2_buf_1
XFILLER_4_1004 VPWR VGND sg13g2_decap_8
Xfanout382 net383 net382 VPWR VGND sg13g2_buf_1
X_16740_ u_FIR.sum\[8\]\[5\] net1644 _07896_ VPWR VGND sg13g2_nor2_1
Xfanout393 net394 net393 VPWR VGND sg13g2_buf_1
X_13952_ _05271_ net281 _05270_ VPWR VGND sg13g2_xnor2_1
XFILLER_47_723 VPWR VGND sg13g2_fill_2
XFILLER_93_339 VPWR VGND sg13g2_decap_8
XFILLER_19_425 VPWR VGND sg13g2_decap_4
XFILLER_86_380 VPWR VGND sg13g2_decap_8
XFILLER_46_222 VPWR VGND sg13g2_decap_4
X_12903_ _04262_ _04217_ _04263_ VPWR VGND sg13g2_xor2_1
XFILLER_98_1044 VPWR VGND sg13g2_decap_8
XFILLER_100_190 VPWR VGND sg13g2_fill_2
X_16671_ VGND VPWR net533 _07842_ _00263_ _07843_ sg13g2_a21oi_1
X_13883_ _05204_ _05183_ _05206_ VPWR VGND sg13g2_xor2_1
XFILLER_46_255 VPWR VGND sg13g2_decap_8
X_18410_ _09520_ _09515_ _09516_ VPWR VGND sg13g2_xnor2_1
X_15622_ _06875_ _06836_ _06876_ VPWR VGND sg13g2_xor2_1
XFILLER_61_203 VPWR VGND sg13g2_decap_4
X_19390_ _10448_ VPWR _10454_ VGND _10360_ _10449_ sg13g2_o21ai_1
X_12834_ _04196_ _04155_ _04194_ VPWR VGND sg13g2_xnor2_1
XFILLER_74_597 VPWR VGND sg13g2_fill_1
X_18341_ _09447_ _09450_ _09451_ VPWR VGND sg13g2_nor2_1
X_15553_ _06808_ _06805_ _06809_ VPWR VGND sg13g2_xor2_1
X_12765_ net1039 VPWR _04129_ VGND net544 u_FIR.sum\[1\]\[7\] sg13g2_o21ai_1
XFILLER_61_269 VPWR VGND sg13g2_decap_8
XFILLER_42_450 VPWR VGND sg13g2_fill_1
X_14504_ _05783_ VPWR _05800_ VGND _05784_ _05785_ sg13g2_o21ai_1
XFILLER_43_995 VPWR VGND sg13g2_fill_1
XFILLER_30_612 VPWR VGND sg13g2_fill_2
X_18272_ _09382_ _09363_ _09364_ VPWR VGND sg13g2_xnor2_1
X_15484_ VGND VPWR net501 _06743_ _00175_ _06744_ sg13g2_a21oi_1
X_12696_ _04059_ _04056_ _04061_ VPWR VGND sg13g2_xor2_1
X_17223_ _08065_ _08099_ _08377_ _08379_ VPWR VGND sg13g2_nor3_1
X_14435_ _05735_ net277 _05736_ VPWR VGND sg13g2_xor2_1
XFILLER_128_522 VPWR VGND sg13g2_decap_8
X_17154_ _08310_ _08305_ _08308_ VPWR VGND sg13g2_xnor2_1
X_14366_ _05670_ _05641_ _05643_ _05606_ net758 VPWR VGND sg13g2_a22oi_1
XFILLER_10_380 VPWR VGND sg13g2_decap_4
X_16105_ _07301_ _07303_ _07345_ VPWR VGND sg13g2_and2_1
X_13317_ _04662_ _04661_ _04618_ VPWR VGND sg13g2_nand2b_1
X_17085_ _08239_ _08238_ _08241_ VPWR VGND sg13g2_xor2_1
XFILLER_6_362 VPWR VGND sg13g2_decap_8
X_14297_ VGND VPWR _05567_ _05581_ _05603_ _05590_ sg13g2_a21oi_1
XFILLER_109_791 VPWR VGND sg13g2_decap_8
X_16036_ _07277_ net899 net797 net886 net799 VPWR VGND sg13g2_a22oi_1
XFILLER_108_290 VPWR VGND sg13g2_decap_8
X_13248_ _04593_ _04594_ _00089_ VPWR VGND sg13g2_nor2_1
XFILLER_42_4 VPWR VGND sg13g2_fill_2
X_13179_ _04527_ _04521_ _04525_ VPWR VGND sg13g2_xnor2_1
XFILLER_97_634 VPWR VGND sg13g2_fill_1
XFILLER_96_100 VPWR VGND sg13g2_decap_4
XFILLER_2_590 VPWR VGND sg13g2_decap_8
XFILLER_112_967 VPWR VGND sg13g2_decap_8
XFILLER_97_667 VPWR VGND sg13g2_fill_2
XFILLER_112_978 VPWR VGND sg13g2_decap_8
X_17987_ _09046_ _09047_ _08982_ _09115_ VPWR VGND sg13g2_nand3_1
XFILLER_42_1021 VPWR VGND sg13g2_decap_4
XFILLER_112_989 VPWR VGND sg13g2_fill_1
XFILLER_38_701 VPWR VGND sg13g2_decap_8
XFILLER_38_712 VPWR VGND sg13g2_fill_1
X_19726_ u_LMS.w\[4\]\[9\] _10759_ _10790_ VPWR VGND sg13g2_nor2_1
X_16938_ _08092_ _08093_ _08094_ VPWR VGND sg13g2_nor2b_1
XFILLER_38_756 VPWR VGND sg13g2_fill_2
X_19657_ _10650_ _10649_ _10721_ VPWR VGND sg13g2_xor2_1
X_16869_ VGND VPWR _08023_ _08024_ _08025_ _08017_ sg13g2_a21oi_1
XFILLER_37_266 VPWR VGND sg13g2_decap_8
XFILLER_19_970 VPWR VGND sg13g2_fill_2
XFILLER_80_512 VPWR VGND sg13g2_decap_8
X_18608_ _09709_ net33 net36 _09710_ VPWR VGND sg13g2_a21o_1
X_19588_ _10652_ net651 net221 VPWR VGND sg13g2_nand2_1
X_18539_ VGND VPWR _09649_ _09593_ u_LMS.w\[2\]\[14\] sg13g2_or2_1
XFILLER_52_269 VPWR VGND sg13g2_fill_1
XFILLER_34_995 VPWR VGND sg13g2_decap_4
XFILLER_21_612 VPWR VGND sg13g2_fill_2
X_21550_ VGND VPWR _02111_ _02121_ _02167_ _02119_ sg13g2_a21oi_1
XFILLER_33_494 VPWR VGND sg13g2_fill_2
X_20501_ _01142_ _01143_ _00415_ VPWR VGND sg13g2_nor2_1
X_21481_ _02098_ _02097_ _02090_ VPWR VGND sg13g2_nand2b_1
X_20432_ net22 VPWR _01090_ VGND net20 _01089_ sg13g2_o21ai_1
X_23220_ net1444 VGND VPWR _00282_ u_LMS.w\[0\]\[14\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
X_20363_ _01026_ _03311_ _00989_ VPWR VGND sg13g2_nand2_1
X_23151_ net1562 VGND VPWR _00213_ u_FIR.x_reg\[4\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
XFILLER_106_238 VPWR VGND sg13g2_fill_1
X_22102_ _02685_ VPWR _02696_ VGND _02694_ _02695_ sg13g2_o21ai_1
X_23082_ net1083 VGND VPWR _00144_ u_FIR.sum\[5\]\[6\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
X_20294_ _11022_ VPWR _00957_ VGND _11023_ _11056_ sg13g2_o21ai_1
XFILLER_103_901 VPWR VGND sg13g2_fill_1
Xclkbuf_leaf_39_clkA clknet_4_7_0_clkA clknet_leaf_39_clkA VPWR VGND sg13g2_buf_8
XFILLER_115_761 VPWR VGND sg13g2_decap_4
X_22033_ _02627_ _02550_ _02562_ VPWR VGND sg13g2_xnor2_1
XFILLER_115_772 VPWR VGND sg13g2_fill_1
XFILLER_103_934 VPWR VGND sg13g2_fill_2
XFILLER_87_122 VPWR VGND sg13g2_fill_1
XFILLER_102_433 VPWR VGND sg13g2_decap_4
XFILLER_87_133 VPWR VGND sg13g2_fill_1
XFILLER_76_818 VPWR VGND sg13g2_decap_8
XFILLER_75_306 VPWR VGND sg13g2_fill_2
XFILLER_69_881 VPWR VGND sg13g2_fill_1
XFILLER_87_199 VPWR VGND sg13g2_fill_1
XFILLER_75_339 VPWR VGND sg13g2_decap_4
XFILLER_113_32 VPWR VGND sg13g2_decap_8
X_22935_ _03198_ net323 u_spi_slave.rx_shift\[2\] u_spi_slave.rx_shift\[10\] net428
+ VPWR VGND sg13g2_a22oi_1
XFILLER_84_884 VPWR VGND sg13g2_fill_1
XFILLER_44_715 VPWR VGND sg13g2_fill_2
XFILLER_83_372 VPWR VGND sg13g2_fill_1
X_22866_ net950 VPWR _03158_ VGND u_p2s_output.reg_sh\[5\] net299 sg13g2_o21ai_1
XFILLER_16_439 VPWR VGND sg13g2_fill_1
XFILLER_73_58 VPWR VGND sg13g2_decap_4
X_21817_ _02389_ _02410_ _02411_ VPWR VGND sg13g2_nor2b_1
X_22797_ VGND VPWR _07834_ net351 _00738_ _03116_ sg13g2_a21oi_1
XFILLER_25_995 VPWR VGND sg13g2_decap_8
X_12550_ _03923_ _03916_ _03922_ VPWR VGND sg13g2_nand2_1
XFILLER_40_932 VPWR VGND sg13g2_fill_1
X_21748_ _02342_ net570 net162 VPWR VGND sg13g2_nand2_1
XFILLER_24_494 VPWR VGND sg13g2_fill_1
XFILLER_19_1056 VPWR VGND sg13g2_decap_4
X_12481_ net940 _03856_ _00060_ VPWR VGND sg13g2_nor2_1
XFILLER_40_987 VPWR VGND sg13g2_fill_1
X_21679_ VGND VPWR _02286_ _02287_ _00449_ net933 sg13g2_a21oi_1
X_14220_ _05528_ _05491_ _05494_ VPWR VGND sg13g2_nand2_1
X_23418_ net1094 VGND VPWR _00480_ u_LMS.w\[8\]\[5\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
X_14151_ net822 net764 _05459_ _05461_ VPWR VGND sg13g2_a21o_1
XFILLER_118_0 VPWR VGND sg13g2_decap_8
X_23349_ net1252 VGND VPWR _00411_ u_LMS.w\[5\]\[5\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
X_23439__1615 VPWR VGND net1614 sg13g2_tiehi
XFILLER_22_95 VPWR VGND sg13g2_decap_8
X_13102_ _04450_ _04416_ _04452_ VPWR VGND sg13g2_xor2_1
XFILLER_4_844 VPWR VGND sg13g2_fill_1
X_14082_ _05394_ _05354_ _05392_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_0 VPWR VGND sg13g2_decap_8
X_17910_ _09043_ _09042_ _08987_ VPWR VGND sg13g2_nand2b_1
X_13033_ _04384_ _04385_ _04386_ VPWR VGND sg13g2_nor2_1
X_18890_ _09977_ _09975_ _09974_ VPWR VGND sg13g2_nand2b_1
X_23303__1299 VPWR VGND net1298 sg13g2_tiehi
XFILLER_67_807 VPWR VGND sg13g2_decap_4
X_17841_ VGND VPWR _08973_ _08974_ _08971_ _08967_ sg13g2_a21oi_2
X_17772_ _08905_ _08900_ _08901_ VPWR VGND sg13g2_xnor2_1
X_14984_ net975 VPWR _06263_ VGND net481 u_FIR.sum\[6\]\[0\] sg13g2_o21ai_1
Xfanout190 net191 net190 VPWR VGND sg13g2_buf_1
X_19511_ _10575_ _10573_ _10574_ VPWR VGND sg13g2_nand2_1
X_16723_ VGND VPWR u_LMS.w\[8\]\[16\] _07872_ _07882_ _07873_ sg13g2_a21oi_1
X_13935_ _05255_ net281 _05254_ VPWR VGND sg13g2_xnor2_1
XFILLER_75_862 VPWR VGND sg13g2_fill_1
XFILLER_47_70 VPWR VGND sg13g2_fill_2
XFILLER_47_81 VPWR VGND sg13g2_fill_2
XFILLER_74_361 VPWR VGND sg13g2_fill_1
XFILLER_34_203 VPWR VGND sg13g2_fill_1
X_19442_ _10471_ _10469_ _10506_ VPWR VGND sg13g2_xor2_1
X_16654_ _07831_ _07829_ _07830_ VPWR VGND sg13g2_nand2_1
X_13866_ _05123_ _05156_ _05188_ _05189_ VPWR VGND sg13g2_nor3_1
XFILLER_62_545 VPWR VGND sg13g2_fill_2
X_15605_ _06845_ VPWR _06859_ VGND _06840_ _06843_ sg13g2_o21ai_1
XFILLER_16_951 VPWR VGND sg13g2_fill_2
X_12817_ _04179_ _04178_ _04174_ VPWR VGND sg13g2_nand2b_1
XFILLER_50_707 VPWR VGND sg13g2_fill_1
X_19373_ net188 _10435_ net641 _10437_ VPWR VGND sg13g2_nand3_1
X_16585_ VGND VPWR net491 _07779_ _00240_ _07780_ sg13g2_a21oi_1
X_13797_ _05122_ _05091_ _05094_ VPWR VGND sg13g2_nand2_1
X_18324_ _09398_ _09392_ _09434_ VPWR VGND sg13g2_xor2_1
X_15536_ net973 VPWR _06793_ VGND net477 u_FIR.sum\[7\]\[3\] sg13g2_o21ai_1
X_12748_ _04112_ _04092_ _04110_ VPWR VGND sg13g2_xnor2_1
X_18255_ _09363_ _09364_ _09365_ VPWR VGND sg13g2_and2_1
X_15467_ _06721_ _06728_ _06729_ VPWR VGND sg13g2_nor2b_1
X_12679_ _04043_ _04008_ _04045_ VPWR VGND sg13g2_xor2_1
XFILLER_8_42 VPWR VGND sg13g2_decap_8
XFILLER_31_998 VPWR VGND sg13g2_decap_4
X_17206_ _08360_ _08361_ _08362_ VPWR VGND sg13g2_nor2b_1
XFILLER_129_842 VPWR VGND sg13g2_fill_2
X_14418_ _05720_ _05698_ _05718_ VPWR VGND sg13g2_xnor2_1
X_18186_ _09296_ net195 net669 net217 net670 VPWR VGND sg13g2_a22oi_1
XFILLER_128_330 VPWR VGND sg13g2_fill_1
X_15398_ VGND VPWR net502 _06662_ _00170_ _06663_ sg13g2_a21oi_1
XFILLER_8_86 VPWR VGND sg13g2_decap_4
XFILLER_128_352 VPWR VGND sg13g2_fill_1
X_17137_ _08293_ _08175_ _08260_ VPWR VGND sg13g2_xnor2_1
X_14349_ _05654_ _05618_ _05652_ VPWR VGND sg13g2_xnor2_1
X_17068_ _08224_ net87 net715 net112 net712 VPWR VGND sg13g2_a22oi_1
X_16019_ VGND VPWR _07260_ _07258_ _07242_ sg13g2_or2_1
XFILLER_112_731 VPWR VGND sg13g2_decap_4
Xrebuffer1648 _07974_ net1647 VPWR VGND sg13g2_buf_8
XFILLER_33_0 VPWR VGND sg13g2_decap_8
Xrebuffer1659 _07906_ net1658 VPWR VGND sg13g2_buf_1
XFILLER_98_976 VPWR VGND sg13g2_fill_1
XFILLER_97_497 VPWR VGND sg13g2_fill_1
XFILLER_66_851 VPWR VGND sg13g2_fill_2
X_19709_ _10769_ u_LMS.w\[4\]\[3\] _10773_ VPWR VGND sg13g2_xor2_1
XFILLER_72_309 VPWR VGND sg13g2_decap_4
X_20981_ VGND VPWR _01584_ _01621_ _01619_ _01618_ sg13g2_a21oi_2
XFILLER_65_361 VPWR VGND sg13g2_fill_1
XFILLER_93_681 VPWR VGND sg13g2_decap_8
XFILLER_81_821 VPWR VGND sg13g2_fill_2
X_22720_ u_debug_unit.mon_w0_sync\[4\] net344 _03078_ VPWR VGND sg13g2_nor2_1
XFILLER_92_191 VPWR VGND sg13g2_decap_8
XFILLER_41_707 VPWR VGND sg13g2_decap_8
X_22651_ net464 coeff_force_packed\[25\] _03064_ _00644_ VPWR VGND sg13g2_mux2_1
XFILLER_81_887 VPWR VGND sg13g2_fill_2
XFILLER_53_578 VPWR VGND sg13g2_fill_1
XFILLER_53_589 VPWR VGND sg13g2_decap_8
X_21602_ VGND VPWR _02216_ _02217_ _02219_ _02171_ sg13g2_a21oi_1
X_22582_ VGND VPWR u_LMS.count\[28\] _03050_ _03052_ u_LMS.count\[29\] sg13g2_a21oi_1
X_21533_ _02150_ _01789_ _02149_ VPWR VGND sg13g2_xnor2_1
X_21464_ _02081_ net262 net599 net244 net601 VPWR VGND sg13g2_a22oi_1
X_23203_ net1475 VGND VPWR _00265_ u_FIR.w\[6\]\[6\] clknet_leaf_30_clkA sg13g2_dfrbpq_1
X_20415_ _01035_ _01034_ _01077_ VPWR VGND sg13g2_xor2_1
XFILLER_111_7 VPWR VGND sg13g2_decap_4
X_21395_ _02012_ _01932_ _01937_ VPWR VGND sg13g2_xnor2_1
XFILLER_49_1016 VPWR VGND sg13g2_fill_2
X_23134_ net1588 VGND VPWR _00196_ u_FIR.sum\[8\]\[6\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
X_20346_ _01008_ _01007_ _01009_ VPWR VGND sg13g2_nor2b_1
XFILLER_0_302 VPWR VGND sg13g2_fill_1
X_20277_ VGND VPWR _11132_ _11152_ _00940_ _11151_ sg13g2_a21oi_1
X_23065_ net1108 VGND VPWR _00127_ u_FIR.sum\[4\]\[8\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
XFILLER_122_539 VPWR VGND sg13g2_decap_8
XFILLER_68_58 VPWR VGND sg13g2_decap_8
X_22016_ _02610_ net580 net240 VPWR VGND sg13g2_nand2_1
XFILLER_0_368 VPWR VGND sg13g2_decap_8
XFILLER_76_637 VPWR VGND sg13g2_decap_4
XFILLER_130_583 VPWR VGND sg13g2_decap_8
XFILLER_124_42 VPWR VGND sg13g2_decap_4
XFILLER_76_659 VPWR VGND sg13g2_decap_8
XFILLER_112_1052 VPWR VGND sg13g2_decap_8
X_11981_ spi_addr\[3\] spi_addr\[2\] _03398_ VPWR VGND sg13g2_nor2_1
XFILLER_95_1003 VPWR VGND sg13g2_fill_1
XFILLER_56_361 VPWR VGND sg13g2_decap_8
X_13720_ _03363_ net864 _05047_ VPWR VGND sg13g2_nor2_1
X_22918_ VGND VPWR net553 u_s2p_input.reg_cnt\[0\] _00788_ _03187_ sg13g2_a21oi_1
XFILLER_16_214 VPWR VGND sg13g2_fill_1
X_13651_ _04974_ _04979_ _04980_ VPWR VGND sg13g2_nor2b_1
X_22849_ _03146_ _03145_ _07897_ _03142_ u_p2s_output.reg_sh\[0\] VPWR VGND sg13g2_a22oi_1
XFILLER_17_95 VPWR VGND sg13g2_fill_2
X_12602_ net867 net736 u_FIR.sum\[0\]\[3\] _03970_ VPWR VGND sg13g2_a21o_1
X_16370_ _07603_ _07582_ _07602_ VPWR VGND sg13g2_xnor2_1
X_13582_ _04913_ _04904_ _04911_ VPWR VGND sg13g2_xnor2_1
X_15321_ _06589_ u_FIR.sum\[5\]\[11\] net394 VPWR VGND sg13g2_xnor2_1
XFILLER_13_965 VPWR VGND sg13g2_decap_8
X_12533_ _03907_ _03860_ _03906_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_925 VPWR VGND sg13g2_fill_1
XFILLER_8_402 VPWR VGND sg13g2_fill_1
XFILLER_13_976 VPWR VGND sg13g2_fill_2
XFILLER_129_105 VPWR VGND sg13g2_decap_8
XFILLER_12_464 VPWR VGND sg13g2_fill_2
XFILLER_129_127 VPWR VGND sg13g2_fill_2
X_18040_ _09015_ _09016_ _09157_ VPWR VGND sg13g2_and2_1
X_15252_ _06493_ _06521_ _06522_ VPWR VGND sg13g2_nor2b_1
X_12464_ _03840_ _03834_ _03838_ VPWR VGND sg13g2_xnor2_1
X_14203_ _05512_ _05511_ _05470_ VPWR VGND sg13g2_nand2b_1
XFILLER_69_9 VPWR VGND sg13g2_fill_1
X_15183_ VGND VPWR _06416_ _06423_ _06454_ _06430_ sg13g2_a21oi_1
X_12395_ _03766_ _03772_ _03773_ VPWR VGND sg13g2_nor2b_1
X_14134_ _05438_ _05441_ _05444_ VPWR VGND sg13g2_nor2_1
X_19991_ _11028_ _11031_ _11032_ VPWR VGND sg13g2_nor2_1
XFILLER_98_206 VPWR VGND sg13g2_fill_2
XFILLER_98_228 VPWR VGND sg13g2_decap_8
X_18942_ _10028_ _10027_ _10029_ VPWR VGND sg13g2_xor2_1
X_14065_ _05377_ net763 net851 VPWR VGND sg13g2_nand2_1
XFILLER_3_162 VPWR VGND sg13g2_decap_8
XFILLER_4_696 VPWR VGND sg13g2_decap_8
XFILLER_3_173 VPWR VGND sg13g2_fill_1
X_22989__1223 VPWR VGND net1222 sg13g2_tiehi
X_13016_ VGND VPWR net746 net895 _04370_ u_FIR.sum\[1\]\[1\] sg13g2_a21oi_1
X_18873_ _09958_ _09959_ _09960_ VPWR VGND sg13g2_nor2b_1
XFILLER_79_475 VPWR VGND sg13g2_decap_8
XFILLER_39_317 VPWR VGND sg13g2_decap_4
X_17824_ _08856_ _08855_ _08957_ VPWR VGND sg13g2_xor2_1
XFILLER_66_125 VPWR VGND sg13g2_decap_4
XFILLER_48_851 VPWR VGND sg13g2_fill_1
XFILLER_94_467 VPWR VGND sg13g2_fill_1
XFILLER_82_607 VPWR VGND sg13g2_decap_8
XFILLER_66_158 VPWR VGND sg13g2_decap_8
X_17755_ _08887_ _08860_ _08888_ VPWR VGND sg13g2_xor2_1
X_14967_ _06248_ _06235_ _06247_ VPWR VGND sg13g2_xnor2_1
XFILLER_81_106 VPWR VGND sg13g2_decap_8
X_16706_ u_LMS.w\[8\]\[20\] u_LMS.w\[8\]\[19\] u_LMS.w\[8\]\[18\] _07869_ VPWR VGND
+ sg13g2_nor3_1
XFILLER_81_128 VPWR VGND sg13g2_fill_2
XFILLER_47_383 VPWR VGND sg13g2_decap_8
X_13918_ _05231_ _05238_ _05239_ VPWR VGND sg13g2_nor2b_1
X_17686_ _08805_ VPWR _08819_ VGND _08764_ _08801_ sg13g2_o21ai_1
X_14898_ VGND VPWR _06154_ _06162_ _06182_ _06169_ sg13g2_a21oi_1
XFILLER_35_545 VPWR VGND sg13g2_fill_1
XFILLER_35_556 VPWR VGND sg13g2_fill_1
X_19425_ net118 _10488_ _10489_ VPWR VGND sg13g2_nor2b_1
XFILLER_90_662 VPWR VGND sg13g2_decap_8
XFILLER_63_876 VPWR VGND sg13g2_fill_1
XFILLER_62_353 VPWR VGND sg13g2_decap_8
X_16637_ net1026 VPWR _07819_ VGND net521 net752 sg13g2_o21ai_1
X_13849_ _05173_ _05166_ _05171_ VPWR VGND sg13g2_xnor2_1
X_19356_ _10418_ VPWR _10420_ VGND _03243_ net85 sg13g2_o21ai_1
X_16568_ net976 VPWR _07767_ VGND net480 u_FIR.w\[2\]\[6\] sg13g2_o21ai_1
XFILLER_15_291 VPWR VGND sg13g2_fill_1
X_18307_ _09417_ _09415_ _09416_ VPWR VGND sg13g2_nand2b_1
X_15519_ _06764_ _06775_ _06776_ VPWR VGND sg13g2_nor2_1
X_19287_ _03245_ net101 _10351_ VPWR VGND sg13g2_nor2_1
X_16499_ VGND VPWR u_LMS.w\[0\]\[13\] _07713_ _07717_ _07714_ sg13g2_a21oi_1
X_18238_ _09215_ _09346_ _09348_ VPWR VGND sg13g2_nor2b_1
X_18169_ _09195_ _09186_ _09279_ VPWR VGND sg13g2_xor2_1
XFILLER_117_856 VPWR VGND sg13g2_fill_2
X_20200_ VGND VPWR _00861_ _00862_ _00863_ _00860_ sg13g2_a21oi_1
X_23139__1581 VPWR VGND net1580 sg13g2_tiehi
X_21180_ _01794_ _01795_ _01796_ _01797_ VPWR VGND sg13g2_nor3_1
Xrebuffer2102 _09652_ net2101 VPWR VGND sg13g2_buf_1
Xrebuffer2124 _00875_ net2123 VPWR VGND sg13g2_buf_1
XFILLER_131_303 VPWR VGND sg13g2_fill_2
X_20131_ _11172_ _11170_ _11171_ VPWR VGND sg13g2_xnor2_1
Xrebuffer2135 _10832_ net2134 VPWR VGND sg13g2_buf_1
Xrebuffer2146 net2146 net2145 VPWR VGND sg13g2_buf_1
Xrebuffer2157 _02023_ net2156 VPWR VGND sg13g2_buf_1
Xfanout904 net905 net904 VPWR VGND sg13g2_buf_1
Xrebuffer2168 _02552_ net2167 VPWR VGND sg13g2_buf_1
XFILLER_48_1060 VPWR VGND sg13g2_fill_1
Xfanout915 u_LMS.mu\[2\] net915 VPWR VGND sg13g2_buf_1
Xrebuffer2179 _02722_ net2178 VPWR VGND sg13g2_buf_1
X_20062_ _11102_ _11069_ _11103_ VPWR VGND sg13g2_xor2_1
Xfanout926 net928 net926 VPWR VGND sg13g2_buf_1
Xfanout937 net938 net937 VPWR VGND sg13g2_buf_1
XFILLER_58_604 VPWR VGND sg13g2_fill_1
Xfanout948 net957 net948 VPWR VGND sg13g2_buf_1
Xfanout959 net970 net959 VPWR VGND sg13g2_buf_1
XFILLER_57_114 VPWR VGND sg13g2_decap_4
XFILLER_100_767 VPWR VGND sg13g2_decap_8
XFILLER_85_467 VPWR VGND sg13g2_decap_8
XFILLER_57_158 VPWR VGND sg13g2_fill_1
XFILLER_100_778 VPWR VGND sg13g2_fill_2
XFILLER_85_478 VPWR VGND sg13g2_fill_2
XFILLER_54_810 VPWR VGND sg13g2_fill_1
XFILLER_66_681 VPWR VGND sg13g2_fill_2
X_23752_ net1354 VGND VPWR _00814_ u_LMS.x\[3\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
X_20964_ _01604_ _03307_ _01591_ VPWR VGND sg13g2_xnor2_1
XFILLER_26_545 VPWR VGND sg13g2_fill_2
XFILLER_54_865 VPWR VGND sg13g2_fill_2
XFILLER_53_342 VPWR VGND sg13g2_fill_1
X_22703_ u_debug_unit.error_signal_sync\[1\] net2097 net332 _00689_ VPWR VGND sg13g2_mux2_1
XFILLER_14_718 VPWR VGND sg13g2_decap_8
X_23683_ net1016 VGND VPWR _00745_ u_debug_unit.mon_w7_sync\[0\] clknet_leaf_18_clkA
+ sg13g2_dfrbpq_1
X_20895_ _01535_ _01533_ _01534_ VPWR VGND sg13g2_nand2_2
XFILLER_13_228 VPWR VGND sg13g2_decap_8
X_22634_ net462 coeff_force_packed\[12\] _03062_ _00629_ VPWR VGND sg13g2_mux2_1
XFILLER_55_1031 VPWR VGND sg13g2_fill_2
XFILLER_55_1053 VPWR VGND sg13g2_decap_8
XFILLER_110_77 VPWR VGND sg13g2_decap_8
X_22565_ VGND VPWR u_LMS.count\[22\] _03039_ _03041_ u_LMS.count\[23\] sg13g2_a21oi_1
X_21516_ _01892_ _01893_ _02133_ VPWR VGND sg13g2_nor2b_1
XFILLER_127_609 VPWR VGND sg13g2_decap_8
XFILLER_10_957 VPWR VGND sg13g2_decap_4
X_22496_ VGND VPWR net441 _03220_ _00556_ _02997_ sg13g2_a21oi_1
X_21447_ net601 net244 net599 _02064_ VPWR VGND net262 sg13g2_nand4_1
XFILLER_119_171 VPWR VGND sg13g2_decap_8
XFILLER_5_449 VPWR VGND sg13g2_fill_1
XFILLER_108_867 VPWR VGND sg13g2_fill_1
X_12180_ net943 u_spi_slave.rx_shift\[10\] _00002_ VPWR VGND sg13g2_nor2b_1
XFILLER_79_35 VPWR VGND sg13g2_fill_1
X_21378_ _01986_ VPWR _01995_ VGND _01981_ _01987_ sg13g2_o21ai_1
XFILLER_123_837 VPWR VGND sg13g2_decap_8
X_23117_ net1613 VGND VPWR _00179_ u_FIR.sum\[7\]\[3\] clknet_leaf_47_clkA sg13g2_dfrbpq_1
X_20329_ _00992_ u_LMS.w\[5\]\[9\] _00991_ VPWR VGND sg13g2_nand2_1
XFILLER_123_848 VPWR VGND sg13g2_fill_1
XFILLER_1_655 VPWR VGND sg13g2_decap_4
XFILLER_110_509 VPWR VGND sg13g2_fill_2
X_23048_ net1134 VGND VPWR _00110_ u_FIR.sum\[3\]\[10\] clknet_leaf_33_clkA sg13g2_dfrbpq_1
XFILLER_95_209 VPWR VGND sg13g2_fill_1
XFILLER_0_154 VPWR VGND sg13g2_decap_8
XFILLER_103_561 VPWR VGND sg13g2_fill_2
XFILLER_62_1035 VPWR VGND sg13g2_fill_1
X_15870_ _07112_ _07114_ _07117_ VPWR VGND sg13g2_nor2_1
XFILLER_77_957 VPWR VGND sg13g2_fill_1
XFILLER_95_78 VPWR VGND sg13g2_decap_8
XFILLER_77_979 VPWR VGND sg13g2_fill_1
X_14821_ _06101_ _06107_ _06108_ VPWR VGND sg13g2_nor2b_1
XFILLER_17_501 VPWR VGND sg13g2_decap_4
X_17540_ net184 _08671_ net686 _08673_ VPWR VGND sg13g2_nand3_1
X_14752_ _06040_ _06007_ _06041_ VPWR VGND sg13g2_nor2b_1
XFILLER_28_94 VPWR VGND sg13g2_fill_2
X_13703_ _05031_ _05023_ _05030_ VPWR VGND sg13g2_xnor2_1
X_17471_ _08604_ _08597_ _08602_ VPWR VGND sg13g2_xnor2_1
XFILLER_72_662 VPWR VGND sg13g2_decap_8
X_14683_ _03367_ net877 _05973_ VPWR VGND sg13g2_nor2_1
X_11895_ VPWR _03316_ u_LMS.w\[5\]\[23\] VGND sg13g2_inv_1
XFILLER_71_161 VPWR VGND sg13g2_decap_8
XFILLER_32_526 VPWR VGND sg13g2_decap_8
X_19210_ net31 VPWR _10291_ VGND net29 _10290_ sg13g2_o21ai_1
XFILLER_72_695 VPWR VGND sg13g2_decap_8
X_16422_ _07651_ _07629_ _07652_ VPWR VGND sg13g2_xor2_1
X_13634_ _04948_ VPWR _04963_ VGND _04942_ _04946_ sg13g2_o21ai_1
X_19141_ _10185_ u_LMS.w\[3\]\[11\] _10228_ VPWR VGND sg13g2_xor2_1
X_16353_ _07554_ VPWR _07586_ VGND _03375_ net803 sg13g2_o21ai_1
XFILLER_9_711 VPWR VGND sg13g2_decap_8
X_13565_ _04896_ net752 net864 VPWR VGND sg13g2_nand2_1
XFILLER_9_733 VPWR VGND sg13g2_fill_2
X_15304_ VGND VPWR _06535_ _06550_ _06572_ _06559_ sg13g2_a21oi_1
X_19072_ _09784_ VPWR _10159_ VGND _09829_ _09835_ sg13g2_o21ai_1
X_12516_ _03877_ VPWR _03890_ VGND _03862_ _03878_ sg13g2_o21ai_1
X_16284_ VGND VPWR _07483_ _07497_ _07519_ _07506_ sg13g2_a21oi_1
XFILLER_118_609 VPWR VGND sg13g2_fill_1
X_13496_ _04830_ _04815_ _04827_ _04829_ VPWR VGND sg13g2_and3_1
XFILLER_8_243 VPWR VGND sg13g2_fill_1
X_18023_ VGND VPWR _09089_ _09090_ _09144_ _09095_ sg13g2_a21oi_1
X_15235_ VGND VPWR net778 net820 _06505_ _06504_ sg13g2_a21oi_1
XFILLER_8_276 VPWR VGND sg13g2_fill_1
X_12447_ _03810_ VPWR _03823_ VGND _03792_ _03811_ sg13g2_o21ai_1
XFILLER_8_298 VPWR VGND sg13g2_decap_8
X_15166_ _06438_ u_FIR.sum\[5\]\[7\] net395 VPWR VGND sg13g2_xnor2_1
XFILLER_5_21 VPWR VGND sg13g2_decap_8
X_12378_ _03756_ _03717_ _03753_ VPWR VGND sg13g2_xnor2_1
XFILLER_114_815 VPWR VGND sg13g2_decap_8
X_14117_ _05426_ _05427_ _05428_ VPWR VGND sg13g2_nor2_1
XFILLER_99_537 VPWR VGND sg13g2_fill_2
X_19974_ _11015_ _10962_ _11014_ VPWR VGND sg13g2_xnor2_1
X_15097_ VGND VPWR _06369_ _06370_ _06371_ net411 sg13g2_a21oi_1
XFILLER_119_1047 VPWR VGND sg13g2_decap_8
XFILLER_5_98 VPWR VGND sg13g2_decap_8
X_18925_ _09978_ _10011_ _10012_ VPWR VGND sg13g2_nor2_1
X_14048_ _05361_ _05352_ _05359_ VPWR VGND sg13g2_xnor2_1
XFILLER_67_401 VPWR VGND sg13g2_fill_1
X_18856_ _09943_ _09911_ _09941_ VPWR VGND sg13g2_nand2_1
X_17807_ _08930_ _08936_ _08940_ VPWR VGND sg13g2_nor2_1
X_18787_ _09824_ _09800_ _09874_ VPWR VGND sg13g2_xor2_1
X_15999_ _07240_ net799 net872 VPWR VGND sg13g2_nand2_1
X_17738_ _08842_ VPWR _08871_ VGND _03274_ net140 sg13g2_o21ai_1
XFILLER_39_1004 VPWR VGND sg13g2_decap_8
XFILLER_51_802 VPWR VGND sg13g2_decap_4
X_17669_ _08764_ _08801_ _08802_ VPWR VGND sg13g2_nor2_1
X_19408_ _10472_ _10471_ _10469_ VPWR VGND sg13g2_nand2b_1
XFILLER_126_1007 VPWR VGND sg13g2_decap_8
X_20680_ _01320_ _01280_ _01287_ VPWR VGND sg13g2_xnor2_1
XFILLER_62_194 VPWR VGND sg13g2_decap_4
X_23452__1576 VPWR VGND net1575 sg13g2_tiehi
X_19339_ _10400_ _10401_ _10402_ _10403_ VPWR VGND sg13g2_nor3_1
X_22350_ VGND VPWR net48 _02922_ _02923_ _02897_ sg13g2_a21oi_1
X_21301_ _01918_ _01914_ _01917_ VPWR VGND sg13g2_nand2_1
X_23485__1466 VPWR VGND net1465 sg13g2_tiehi
X_22281_ _02869_ _02756_ net2170 _02825_ VPWR VGND sg13g2_and3_1
X_21232_ _01843_ VPWR _01849_ VGND _01755_ _01844_ sg13g2_o21ai_1
XFILLER_132_623 VPWR VGND sg13g2_decap_8
XFILLER_116_174 VPWR VGND sg13g2_fill_2
XFILLER_104_325 VPWR VGND sg13g2_decap_4
X_21163_ _01780_ net605 net152 VPWR VGND sg13g2_nand2_1
Xfanout701 u_LMS.x_r\[1\]\[0\] net701 VPWR VGND sg13g2_buf_1
X_20114_ _11155_ u_LMS.x_r\[5\]\[5\] net264 VPWR VGND sg13g2_nand2_1
Xfanout712 u_LMS.x_r\[0\]\[1\] net712 VPWR VGND sg13g2_buf_1
XFILLER_59_902 VPWR VGND sg13g2_fill_2
XFILLER_120_818 VPWR VGND sg13g2_fill_1
X_21094_ net361 VPWR _01719_ VGND u_LMS.w\[6\]\[4\] net378 sg13g2_o21ai_1
Xfanout723 u_FIR.w\[8\]\[3\] net723 VPWR VGND sg13g2_buf_1
XFILLER_132_689 VPWR VGND sg13g2_fill_2
Xfanout734 u_FIR.w\[7\]\[2\] net734 VPWR VGND sg13g2_buf_1
Xfanout745 u_FIR.w\[6\]\[1\] net745 VPWR VGND sg13g2_buf_1
X_20045_ _11084_ _11083_ _11086_ VPWR VGND sg13g2_xor2_1
Xfanout756 u_FIR.w\[5\]\[0\] net756 VPWR VGND sg13g2_buf_1
XFILLER_113_892 VPWR VGND sg13g2_fill_1
XFILLER_100_520 VPWR VGND sg13g2_fill_2
Xfanout767 net768 net767 VPWR VGND sg13g2_buf_1
XFILLER_58_434 VPWR VGND sg13g2_decap_8
Xfanout778 net779 net778 VPWR VGND sg13g2_buf_1
Xfanout789 u_FIR.w\[1\]\[1\] net789 VPWR VGND sg13g2_buf_1
XFILLER_46_618 VPWR VGND sg13g2_fill_2
XFILLER_18_309 VPWR VGND sg13g2_decap_8
XFILLER_58_489 VPWR VGND sg13g2_decap_4
XFILLER_22_1052 VPWR VGND sg13g2_decap_8
X_21996_ _02586_ _02589_ _02590_ VPWR VGND sg13g2_nor2_1
XFILLER_26_331 VPWR VGND sg13g2_fill_1
X_23735_ net996 VGND VPWR _00797_ spi_addr\[1\] clknet_3_4__leaf_spi_sclk sg13g2_dfrbpq_1
X_20947_ _01587_ _01517_ _01518_ VPWR VGND sg13g2_xnor2_1
XFILLER_42_857 VPWR VGND sg13g2_fill_1
X_23666_ net1021 VGND VPWR _00728_ u_debug_unit.mon_w4_sync\[4\] clknet_leaf_36_clkA
+ sg13g2_dfrbpq_1
XFILLER_53_194 VPWR VGND sg13g2_fill_2
X_20878_ _01494_ _01493_ _01518_ VPWR VGND sg13g2_xor2_1
X_22617_ net460 sys_enable_bus\[6\] _03060_ _00614_ VPWR VGND sg13g2_mux2_1
XFILLER_14_41 VPWR VGND sg13g2_fill_1
XFILLER_10_710 VPWR VGND sg13g2_fill_1
X_23597_ net1017 VGND VPWR _00659_ coeff_force_packed\[38\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
XFILLER_14_52 VPWR VGND sg13g2_fill_1
XFILLER_10_732 VPWR VGND sg13g2_decap_8
X_13350_ _04693_ net283 _04694_ VPWR VGND sg13g2_xor2_1
XFILLER_14_74 VPWR VGND sg13g2_fill_2
X_22548_ net952 VPWR _03031_ VGND u_LMS.count\[16\] _03029_ sg13g2_o21ai_1
X_12301_ net907 net718 _03681_ VPWR VGND sg13g2_nor2b_1
XFILLER_127_439 VPWR VGND sg13g2_decap_8
X_13281_ _04627_ _04596_ _04626_ VPWR VGND sg13g2_xnor2_1
X_22479_ net959 VPWR _02989_ VGND net446 net595 sg13g2_o21ai_1
XFILLER_6_758 VPWR VGND sg13g2_decap_8
X_15020_ _06296_ net779 net903 VPWR VGND sg13g2_nand2_1
X_12232_ _03614_ _03611_ _03615_ VPWR VGND sg13g2_xor2_1
XFILLER_100_0 VPWR VGND sg13g2_decap_4
X_12163_ VPWR _00040_ _03571_ VGND sg13g2_inv_1
XFILLER_122_122 VPWR VGND sg13g2_decap_4
XFILLER_122_133 VPWR VGND sg13g2_fill_1
XFILLER_96_507 VPWR VGND sg13g2_decap_8
XFILLER_2_964 VPWR VGND sg13g2_decap_8
X_16971_ _08091_ _08090_ _08127_ VPWR VGND sg13g2_xor2_1
X_12094_ _03506_ net286 u_debug_unit.sw_reset\[3\] net289 coeff_force_packed\[24\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_7_1002 VPWR VGND sg13g2_fill_2
X_18710_ _09781_ _09796_ _09797_ VPWR VGND sg13g2_nor2_1
XFILLER_7_1024 VPWR VGND sg13g2_decap_8
X_15922_ _07167_ u_FIR.sum\[6\]\[15\] net390 VPWR VGND sg13g2_xnor2_1
XFILLER_77_732 VPWR VGND sg13g2_fill_1
X_19690_ _03328_ _10753_ _10754_ VPWR VGND sg13g2_nor2_1
XFILLER_49_467 VPWR VGND sg13g2_fill_1
XFILLER_37_607 VPWR VGND sg13g2_decap_8
X_18641_ VGND VPWR _09681_ _09735_ _09736_ _09728_ sg13g2_a21oi_1
X_15853_ _07101_ _07089_ _07100_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_798 VPWR VGND sg13g2_decap_8
XFILLER_64_415 VPWR VGND sg13g2_decap_8
XFILLER_58_990 VPWR VGND sg13g2_decap_8
X_14804_ u_FIR.w\[3\]\[4\] net806 _06091_ VPWR VGND sg13g2_and2_1
X_18572_ _09645_ net1662 _09682_ VPWR VGND sg13g2_xor2_1
X_15784_ _07034_ _07019_ _07033_ VPWR VGND sg13g2_xnor2_1
X_12996_ _04351_ VPWR _04353_ VGND _04334_ _04336_ sg13g2_o21ai_1
X_17523_ _08654_ VPWR _08656_ VGND net419 net81 sg13g2_o21ai_1
X_14735_ VGND VPWR net823 _06022_ _06024_ _06020_ sg13g2_a21oi_1
X_11947_ VPWR _03368_ net770 VGND sg13g2_inv_1
XFILLER_72_492 VPWR VGND sg13g2_decap_4
X_17454_ _08586_ _08584_ _08583_ _08587_ VPWR VGND sg13g2_a21o_1
X_14666_ _05957_ _05950_ _05956_ VPWR VGND sg13g2_xnor2_1
X_11878_ VPWR _03299_ u_LMS.w\[7\]\[8\] VGND sg13g2_inv_1
X_16405_ _07636_ _07589_ _07634_ VPWR VGND sg13g2_xnor2_1
X_13617_ _04946_ _04942_ _04947_ VPWR VGND sg13g2_xor2_1
X_17385_ net45 VPWR _08533_ VGND net43 _08532_ sg13g2_o21ai_1
X_14597_ VGND VPWR _05854_ _05881_ _05889_ _05880_ sg13g2_a21oi_1
XFILLER_125_1051 VPWR VGND sg13g2_decap_8
XFILLER_119_907 VPWR VGND sg13g2_fill_2
X_19124_ _10197_ _10210_ _10211_ VPWR VGND sg13g2_nor2_1
X_16336_ _07564_ _07569_ _07570_ VPWR VGND sg13g2_nor2b_1
X_13548_ _04880_ _04879_ _04859_ VPWR VGND sg13g2_nand2b_1
X_19055_ _09976_ _09977_ _10142_ VPWR VGND sg13g2_nor2b_1
X_16267_ _07503_ _07499_ _07502_ VPWR VGND sg13g2_xnor2_1
X_13479_ _04814_ net753 net905 VPWR VGND sg13g2_nand2_1
X_18006_ VGND VPWR u_LMS.w\[1\]\[20\] net302 _09131_ _09122_ sg13g2_a21oi_1
X_15218_ VGND VPWR _06487_ _06488_ _06489_ net411 sg13g2_a21oi_1
X_16198_ _07402_ _07435_ _07436_ VPWR VGND sg13g2_nor2b_1
X_15149_ _06419_ _06420_ _06421_ VPWR VGND sg13g2_and2_1
XFILLER_114_634 VPWR VGND sg13g2_fill_1
XFILLER_99_345 VPWR VGND sg13g2_fill_2
X_19957_ _10998_ _10987_ _10997_ VPWR VGND sg13g2_nand2_1
XFILLER_114_689 VPWR VGND sg13g2_decap_8
XFILLER_45_1030 VPWR VGND sg13g2_decap_4
X_18908_ _03258_ net126 net2198 net123 _09995_ VPWR VGND sg13g2_nor4_1
X_19888_ VGND VPWR net54 _10930_ _10931_ _10905_ sg13g2_a21oi_1
XFILLER_110_862 VPWR VGND sg13g2_fill_1
X_18839_ _09918_ _09917_ _09926_ VPWR VGND sg13g2_xor2_1
XFILLER_110_895 VPWR VGND sg13g2_fill_1
XFILLER_56_949 VPWR VGND sg13g2_decap_8
XFILLER_95_595 VPWR VGND sg13g2_fill_1
X_21850_ _02444_ _02443_ _02442_ VPWR VGND sg13g2_nand2b_1
X_23316__1286 VPWR VGND net1285 sg13g2_tiehi
XFILLER_71_919 VPWR VGND sg13g2_fill_2
X_20801_ _01441_ _01416_ _01440_ VPWR VGND sg13g2_nand2_1
X_21781_ _02375_ net587 net148 VPWR VGND sg13g2_nand2_1
X_23520_ net1336 VGND VPWR _00582_ u_LMS.count\[23\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
XFILLER_35_183 VPWR VGND sg13g2_fill_2
X_20732_ _01372_ net614 net227 VPWR VGND sg13g2_nand2_1
XFILLER_24_879 VPWR VGND sg13g2_decap_8
X_23451_ net1578 VGND VPWR _00513_ u_LMS.x_r\[3\]\[2\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
X_20663_ _01303_ _01294_ _01299_ VPWR VGND sg13g2_xnor2_1
X_22402_ VGND VPWR net431 _03268_ _00509_ _02950_ sg13g2_a21oi_1
X_23382_ net1202 VGND VPWR _00444_ u_LMS.w\[7\]\[15\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
X_20594_ _01234_ _01199_ _01233_ VPWR VGND sg13g2_xnor2_1
X_22333_ _02910_ _02794_ _02795_ VPWR VGND sg13g2_xnor2_1
X_22264_ _02856_ net311 u_LMS.w\[8\]\[14\] coeff_force_packed\[58\] net561 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_118_984 VPWR VGND sg13g2_decap_8
Xclkbuf_4_0_0_clkA clknet_0_clkA clknet_4_0_0_clkA VPWR VGND sg13g2_buf_8
X_21215_ net188 _01830_ net592 _01832_ VPWR VGND sg13g2_nand3_1
X_23208__1467 VPWR VGND net1466 sg13g2_tiehi
X_22195_ _02789_ u_LMS.w\[8\]\[4\] _02781_ VPWR VGND sg13g2_xnor2_1
XFILLER_4_7 VPWR VGND sg13g2_decap_8
X_21146_ VGND VPWR _01754_ _01762_ _01763_ _01752_ sg13g2_a21oi_1
XFILLER_120_604 VPWR VGND sg13g2_decap_4
Xfanout520 net523 net520 VPWR VGND sg13g2_buf_1
Xfanout531 net549 net531 VPWR VGND sg13g2_buf_1
XFILLER_59_721 VPWR VGND sg13g2_fill_2
Xfanout542 net543 net542 VPWR VGND sg13g2_buf_1
X_21077_ VPWR VGND _01705_ net939 _01685_ _03309_ _00429_ net314 sg13g2_a221oi_1
Xfanout553 net555 net553 VPWR VGND sg13g2_buf_1
Xfanout564 net566 net564 VPWR VGND sg13g2_buf_1
Xfanout575 u_LMS.x_r\[8\]\[6\] net575 VPWR VGND sg13g2_buf_1
XFILLER_76_58 VPWR VGND sg13g2_fill_1
Xfanout586 net587 net586 VPWR VGND sg13g2_buf_1
XFILLER_76_69 VPWR VGND sg13g2_decap_8
X_20028_ _11069_ net630 net135 VPWR VGND sg13g2_nand2_1
Xfanout597 u_LMS.x_r\[7\]\[4\] net597 VPWR VGND sg13g2_buf_1
XFILLER_74_724 VPWR VGND sg13g2_fill_2
XFILLER_73_212 VPWR VGND sg13g2_fill_1
X_12850_ VGND VPWR _04172_ _04188_ _04211_ _04197_ sg13g2_a21oi_1
XFILLER_132_42 VPWR VGND sg13g2_decap_8
XFILLER_55_960 VPWR VGND sg13g2_decap_4
X_11801_ VPWR _03222_ net598 VGND sg13g2_inv_1
XFILLER_61_407 VPWR VGND sg13g2_decap_8
XFILLER_55_971 VPWR VGND sg13g2_decap_8
XFILLER_27_662 VPWR VGND sg13g2_fill_2
X_12781_ _04144_ u_FIR.w\[7\]\[1\] net814 VPWR VGND sg13g2_nand2_1
X_21979_ _02573_ _02568_ _02571_ VPWR VGND sg13g2_xnor2_1
XFILLER_73_289 VPWR VGND sg13g2_fill_2
XFILLER_14_301 VPWR VGND sg13g2_decap_8
X_14520_ _05815_ _05814_ _05810_ VPWR VGND sg13g2_nand2b_1
XFILLER_92_79 VPWR VGND sg13g2_fill_1
XFILLER_109_1013 VPWR VGND sg13g2_fill_1
X_23718_ net1396 VGND VPWR _00780_ u_FIR.x\[7\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
XFILLER_70_941 VPWR VGND sg13g2_decap_4
XFILLER_25_51 VPWR VGND sg13g2_fill_2
XFILLER_41_131 VPWR VGND sg13g2_decap_8
X_14451_ _05674_ _05738_ _05751_ VPWR VGND sg13g2_nor2_1
X_23649_ net981 VGND VPWR _00711_ u_debug_unit.mon_w2_sync\[1\] clknet_leaf_52_clkA
+ sg13g2_dfrbpq_1
XFILLER_41_175 VPWR VGND sg13g2_decap_8
X_13402_ _04680_ _04713_ _04743_ _04744_ VPWR VGND sg13g2_nor3_1
X_17170_ _08326_ _08282_ _08324_ VPWR VGND sg13g2_xnor2_1
X_14382_ _05668_ _05685_ _05686_ VPWR VGND sg13g2_nor2b_1
XFILLER_10_540 VPWR VGND sg13g2_fill_1
XFILLER_127_203 VPWR VGND sg13g2_fill_1
X_16121_ net973 VPWR _07361_ VGND net476 u_FIR.sum\[8\]\[6\] sg13g2_o21ai_1
XFILLER_6_500 VPWR VGND sg13g2_fill_1
XFILLER_10_562 VPWR VGND sg13g2_decap_4
X_13333_ VGND VPWR _04638_ _04655_ _04677_ _04664_ sg13g2_a21oi_1
XFILLER_127_214 VPWR VGND sg13g2_decap_4
XFILLER_127_236 VPWR VGND sg13g2_decap_8
XFILLER_6_544 VPWR VGND sg13g2_fill_1
XFILLER_109_962 VPWR VGND sg13g2_decap_4
X_16052_ _07293_ net794 net887 VPWR VGND sg13g2_nand2_1
XFILLER_115_409 VPWR VGND sg13g2_fill_2
X_13264_ VGND VPWR _04610_ _04609_ net410 sg13g2_or2_1
X_15003_ VPWR _06280_ _06279_ VGND sg13g2_inv_1
X_12215_ _03599_ net725 net906 _03598_ VPWR VGND sg13g2_and3_1
XFILLER_123_420 VPWR VGND sg13g2_decap_8
X_13195_ _04542_ _04539_ _04543_ VPWR VGND sg13g2_nor2b_1
XFILLER_123_431 VPWR VGND sg13g2_fill_1
XFILLER_97_805 VPWR VGND sg13g2_fill_2
X_19811_ _10871_ net311 u_LMS.w\[4\]\[16\] coeff_force_packed\[32\] net562 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_124_976 VPWR VGND sg13g2_fill_2
X_12146_ _03538_ VPWR _00041_ VGND _03554_ _03555_ sg13g2_o21ai_1
XFILLER_96_326 VPWR VGND sg13g2_fill_2
XFILLER_1_260 VPWR VGND sg13g2_decap_8
XFILLER_2_794 VPWR VGND sg13g2_fill_2
X_19742_ VPWR VGND _10804_ _10750_ _10803_ u_LMS.w\[4\]\[15\] _10806_ _10746_ sg13g2_a221oi_1
X_16954_ _08110_ _08108_ _08109_ VPWR VGND sg13g2_nand2_1
X_12077_ _03490_ net288 coeff_force_packed\[60\] _03418_ u_debug_unit.mon_w2_sync\[4\]
+ VPWR VGND sg13g2_a22oi_1
X_15905_ _07151_ u_FIR.sum\[6\]\[14\] net390 VPWR VGND sg13g2_xnor2_1
X_19673_ VGND VPWR _10737_ _10465_ _10464_ sg13g2_or2_1
X_23243__1405 VPWR VGND net1404 sg13g2_tiehi
X_16885_ _08040_ _08030_ _08041_ VPWR VGND sg13g2_xor2_1
XFILLER_65_724 VPWR VGND sg13g2_fill_1
XFILLER_2_77 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_1_clkA clknet_4_2_0_clkA clknet_leaf_1_clkA VPWR VGND sg13g2_buf_8
X_18624_ VGND VPWR u_LMS.w\[2\]\[23\] net301 _09723_ _09702_ sg13g2_a21oi_1
XFILLER_92_532 VPWR VGND sg13g2_decap_8
XFILLER_49_297 VPWR VGND sg13g2_fill_2
X_15836_ VGND VPWR net495 _07083_ _00187_ _07084_ sg13g2_a21oi_1
XFILLER_66_80 VPWR VGND sg13g2_decap_8
XFILLER_46_971 VPWR VGND sg13g2_decap_4
X_18555_ u_LMS.w\[2\]\[20\] net70 _09665_ VPWR VGND sg13g2_and2_1
X_15767_ _07002_ VPWR _07017_ VGND _06998_ _07000_ sg13g2_o21ai_1
X_12979_ _04335_ _04312_ _04337_ VPWR VGND sg13g2_xor2_1
XFILLER_18_695 VPWR VGND sg13g2_fill_1
X_17506_ _08636_ _08637_ _08638_ _08639_ VPWR VGND sg13g2_nor3_1
X_14718_ _05998_ VPWR _06007_ VGND _05968_ _05999_ sg13g2_o21ai_1
XFILLER_61_952 VPWR VGND sg13g2_decap_4
X_18486_ _09596_ _09595_ _09556_ VPWR VGND sg13g2_xnor2_1
X_15698_ _03374_ net410 _06910_ _06950_ VPWR VGND sg13g2_nor3_1
X_17437_ _08572_ _08573_ _00299_ VPWR VGND sg13g2_nor2_1
X_14649_ _05940_ _05932_ _05939_ VPWR VGND sg13g2_xnor2_1
X_17368_ net46 VPWR _08519_ VGND net44 _08518_ sg13g2_o21ai_1
XFILLER_20_359 VPWR VGND sg13g2_decap_8
XFILLER_118_203 VPWR VGND sg13g2_fill_1
X_19107_ _10194_ _10125_ _10126_ VPWR VGND sg13g2_xnor2_1
X_16319_ VGND VPWR _07522_ _07526_ _07553_ _07525_ sg13g2_a21oi_1
XFILLER_118_236 VPWR VGND sg13g2_decap_8
X_17299_ _08455_ _08454_ _08418_ VPWR VGND sg13g2_nand2b_1
XFILLER_63_0 VPWR VGND sg13g2_decap_4
X_19038_ VPWR _10125_ _10124_ VGND sg13g2_inv_1
XFILLER_114_420 VPWR VGND sg13g2_fill_2
X_21000_ net73 VPWR _01640_ VGND u_LMS.w\[6\]\[19\] u_LMS.w\[6\]\[18\] sg13g2_o21ai_1
XFILLER_99_164 VPWR VGND sg13g2_fill_2
XFILLER_101_103 VPWR VGND sg13g2_fill_2
X_22951_ net462 u_spi_slave.rx_shift\[4\] _03575_ _00808_ VPWR VGND sg13g2_mux2_1
XFILLER_96_882 VPWR VGND sg13g2_fill_2
XFILLER_28_415 VPWR VGND sg13g2_decap_8
X_21902_ _02462_ _02460_ _02496_ VPWR VGND sg13g2_xor2_1
X_22882_ net951 _03139_ net552 _03169_ VPWR VGND sg13g2_nand3_1
X_21833_ net185 _02425_ net572 _02427_ VPWR VGND sg13g2_nand3_1
XFILLER_83_587 VPWR VGND sg13g2_fill_2
XFILLER_43_418 VPWR VGND sg13g2_decap_8
XFILLER_43_429 VPWR VGND sg13g2_fill_1
XFILLER_71_749 VPWR VGND sg13g2_decap_4
XFILLER_24_643 VPWR VGND sg13g2_fill_2
X_21764_ _02347_ _02357_ _02358_ VPWR VGND sg13g2_nor2_1
XFILLER_62_27 VPWR VGND sg13g2_decap_8
XFILLER_24_665 VPWR VGND sg13g2_decap_8
XFILLER_12_805 VPWR VGND sg13g2_decap_8
X_23503_ net1401 VGND VPWR _00565_ u_LMS.count\[6\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
X_20715_ VGND VPWR _01349_ _01350_ _01355_ _01354_ sg13g2_a21oi_1
XFILLER_52_996 VPWR VGND sg13g2_decap_8
X_21695_ VGND VPWR net2140 _02246_ _02300_ _02247_ sg13g2_a21oi_1
X_23434_ net1046 VGND VPWR _00496_ u_LMS.x_r\[1\]\[1\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
XFILLER_11_348 VPWR VGND sg13g2_fill_1
X_20646_ VGND VPWR _01247_ _01282_ _01286_ _01285_ sg13g2_a21oi_1
X_23365_ net1236 VGND VPWR _00427_ u_LMS.w\[6\]\[21\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
X_20577_ _01217_ _01191_ _01216_ VPWR VGND sg13g2_nand2_1
X_22316_ _02897_ net373 _02847_ VPWR VGND sg13g2_nand2_1
X_23296_ net1306 VGND VPWR _00358_ u_LMS.w\[3\]\[21\] clknet_leaf_52_clkA sg13g2_dfrbpq_1
XFILLER_118_770 VPWR VGND sg13g2_decap_4
XFILLER_106_943 VPWR VGND sg13g2_fill_2
X_22247_ net60 VPWR _02841_ VGND u_LMS.w\[8\]\[23\] u_LMS.w\[8\]\[22\] sg13g2_o21ai_1
XFILLER_127_42 VPWR VGND sg13g2_decap_8
X_12000_ net474 _03398_ _03417_ VPWR VGND spi_addr\[0\] sg13g2_nand3b_1
X_22178_ _03291_ _02771_ _02772_ VPWR VGND sg13g2_nor2_1
XFILLER_132_283 VPWR VGND sg13g2_decap_8
X_21129_ _03220_ net100 _01746_ VPWR VGND sg13g2_nor2_1
XFILLER_78_348 VPWR VGND sg13g2_decap_8
XFILLER_78_359 VPWR VGND sg13g2_fill_2
Xfanout350 net352 net350 VPWR VGND sg13g2_buf_1
Xfanout361 net362 net361 VPWR VGND sg13g2_buf_1
XFILLER_87_860 VPWR VGND sg13g2_fill_2
XFILLER_120_467 VPWR VGND sg13g2_fill_2
Xfanout372 _08491_ net372 VPWR VGND sg13g2_buf_1
XFILLER_115_1050 VPWR VGND sg13g2_decap_8
Xfanout383 net384 net383 VPWR VGND sg13g2_buf_1
X_13951_ _05270_ u_FIR.sum\[2\]\[17\] net403 VPWR VGND sg13g2_xnor2_1
Xfanout394 _06436_ net394 VPWR VGND sg13g2_buf_1
X_23008__1195 VPWR VGND net1194 sg13g2_tiehi
X_12902_ _04262_ _04253_ _04260_ VPWR VGND sg13g2_xnor2_1
X_16670_ net1034 VPWR _07843_ VGND net533 net741 sg13g2_o21ai_1
X_13882_ _05183_ _05204_ _05205_ VPWR VGND sg13g2_nor2_1
XFILLER_19_459 VPWR VGND sg13g2_decap_8
XFILLER_59_1007 VPWR VGND sg13g2_decap_8
XFILLER_47_779 VPWR VGND sg13g2_decap_4
X_23395__1164 VPWR VGND net1163 sg13g2_tiehi
X_15621_ _06875_ _06867_ _06873_ VPWR VGND sg13g2_xnor2_1
X_12833_ _04195_ _04194_ _04155_ VPWR VGND sg13g2_nand2b_1
XFILLER_34_429 VPWR VGND sg13g2_decap_8
XFILLER_27_470 VPWR VGND sg13g2_fill_1
XFILLER_61_226 VPWR VGND sg13g2_decap_8
X_18340_ _09448_ _09449_ _09450_ VPWR VGND sg13g2_nor2b_1
X_15552_ _06808_ _06806_ _06807_ VPWR VGND sg13g2_nand2_1
X_12764_ VGND VPWR _04126_ _04127_ _04128_ net414 sg13g2_a21oi_1
XFILLER_42_440 VPWR VGND sg13g2_fill_1
XFILLER_43_974 VPWR VGND sg13g2_fill_1
X_14503_ _05799_ _05793_ _05798_ VPWR VGND sg13g2_xnor2_1
X_18271_ _09379_ _09378_ _09381_ VPWR VGND sg13g2_xor2_1
X_15483_ net1004 VPWR _06744_ VGND net501 u_FIR.sum\[6\]\[18\] sg13g2_o21ai_1
XFILLER_14_164 VPWR VGND sg13g2_decap_4
X_12695_ _04060_ _04059_ _04056_ VPWR VGND sg13g2_nand2b_1
X_17222_ VGND VPWR _08066_ _08098_ _08378_ _08065_ sg13g2_a21oi_1
X_14434_ _05735_ u_FIR.sum\[3\]\[16\] net399 VPWR VGND sg13g2_xnor2_1
X_17153_ VPWR _08309_ _08308_ VGND sg13g2_inv_1
X_14365_ _05645_ VPWR _05669_ VGND net279 _05647_ sg13g2_o21ai_1
XFILLER_122_1043 VPWR VGND sg13g2_decap_8
X_16104_ _07343_ _07305_ _07344_ VPWR VGND sg13g2_xor2_1
X_13316_ _04661_ _04657_ _04660_ VPWR VGND sg13g2_xnor2_1
X_17084_ _08238_ _08239_ _08240_ VPWR VGND sg13g2_nor2_1
X_14296_ _05588_ VPWR _05602_ VGND _05584_ _05586_ sg13g2_o21ai_1
XFILLER_109_781 VPWR VGND sg13g2_fill_2
XFILLER_6_374 VPWR VGND sg13g2_decap_8
X_16035_ _07276_ _07272_ _07273_ VPWR VGND sg13g2_xnor2_1
X_13247_ net1034 VPWR _04594_ VGND net534 u_FIR.sum\[2\]\[8\] sg13g2_o21ai_1
X_13178_ _04526_ _04525_ _04521_ VPWR VGND sg13g2_nand2b_1
XFILLER_35_4 VPWR VGND sg13g2_fill_1
XFILLER_123_272 VPWR VGND sg13g2_decap_8
XFILLER_112_946 VPWR VGND sg13g2_decap_8
X_12129_ _03539_ _03438_ u_debug_unit.error_signal_sync\[1\] _03407_ u_debug_unit.mon_w1_sync\[1\]
+ VPWR VGND sg13g2_a22oi_1
X_17986_ VGND VPWR _09113_ _09114_ _00307_ net923 sg13g2_a21oi_1
XFILLER_97_679 VPWR VGND sg13g2_fill_2
XFILLER_81_1060 VPWR VGND sg13g2_fill_1
X_19725_ VGND VPWR _10786_ _10787_ _10789_ _10762_ sg13g2_a21oi_1
X_16937_ _08093_ _08022_ _08024_ VPWR VGND sg13g2_xnor2_1
XFILLER_84_329 VPWR VGND sg13g2_decap_8
XFILLER_37_212 VPWR VGND sg13g2_decap_8
X_19656_ _10671_ VPWR _10720_ VGND _10717_ _10718_ sg13g2_o21ai_1
X_16868_ _08016_ _08000_ _08024_ VPWR VGND sg13g2_xor2_1
XFILLER_93_874 VPWR VGND sg13g2_fill_1
XFILLER_26_919 VPWR VGND sg13g2_decap_8
X_18607_ _09709_ _09664_ _09708_ VPWR VGND sg13g2_xnor2_1
X_15819_ _07068_ _07056_ _07067_ VPWR VGND sg13g2_xnor2_1
XFILLER_52_204 VPWR VGND sg13g2_fill_2
X_19587_ _10649_ _10650_ _10651_ VPWR VGND sg13g2_nor2_1
XFILLER_25_429 VPWR VGND sg13g2_decap_4
X_16799_ _07951_ _07953_ _07955_ VPWR VGND sg13g2_nor2b_2
X_18538_ _09597_ VPWR _09648_ VGND _09646_ _09647_ sg13g2_o21ai_1
XFILLER_52_259 VPWR VGND sg13g2_fill_1
X_18469_ _09579_ _09578_ _09577_ VPWR VGND sg13g2_nand2b_1
XFILLER_60_270 VPWR VGND sg13g2_decap_8
XFILLER_20_101 VPWR VGND sg13g2_fill_2
X_20500_ net363 VPWR _01143_ VGND u_LMS.w\[5\]\[9\] net381 sg13g2_o21ai_1
XFILLER_60_292 VPWR VGND sg13g2_fill_1
X_21480_ _02091_ _02096_ _02097_ VPWR VGND sg13g2_nor2_1
XFILLER_20_167 VPWR VGND sg13g2_decap_8
X_20431_ _01046_ _01045_ _01089_ VPWR VGND sg13g2_xor2_1
X_23150_ net1564 VGND VPWR _00212_ u_FIR.x_reg\[3\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
XFILLER_119_578 VPWR VGND sg13g2_fill_2
X_20362_ _00992_ VPWR _01025_ VGND _01022_ _01023_ sg13g2_o21ai_1
X_22101_ _02684_ _02675_ _02695_ VPWR VGND sg13g2_xor2_1
X_23081_ net1084 VGND VPWR _00143_ u_FIR.sum\[5\]\[5\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
X_20293_ _11058_ VPWR _00956_ VGND _00951_ _00954_ sg13g2_o21ai_1
X_22032_ VGND VPWR _02608_ _02615_ _02626_ _02625_ sg13g2_a21oi_1
XFILLER_103_946 VPWR VGND sg13g2_decap_8
XFILLER_103_957 VPWR VGND sg13g2_fill_2
XFILLER_87_156 VPWR VGND sg13g2_fill_1
XFILLER_29_713 VPWR VGND sg13g2_fill_2
XFILLER_68_392 VPWR VGND sg13g2_fill_1
X_22934_ spi_addr\[3\] net324 _03197_ VPWR VGND sg13g2_nor2_1
XFILLER_56_543 VPWR VGND sg13g2_fill_1
XFILLER_3_1060 VPWR VGND sg13g2_fill_1
X_22865_ VGND VPWR u_p2s_output.reg_sh\[4\] net551 _03157_ _03156_ sg13g2_a21oi_1
XFILLER_73_48 VPWR VGND sg13g2_decap_4
X_21816_ _02408_ _02409_ _02410_ VPWR VGND sg13g2_and2_1
XFILLER_43_248 VPWR VGND sg13g2_decap_4
X_22796_ u_debug_unit.mon_w6_sync\[0\] net350 _03116_ VPWR VGND sg13g2_nor2_1
XFILLER_25_963 VPWR VGND sg13g2_fill_2
XFILLER_19_1035 VPWR VGND sg13g2_decap_8
X_21747_ net576 net110 _02341_ VPWR VGND sg13g2_and2_1
XFILLER_106_1005 VPWR VGND sg13g2_fill_1
XFILLER_12_635 VPWR VGND sg13g2_decap_8
X_12480_ _03855_ VPWR _03856_ VGND net542 u_FIR.sum\[0\]\[10\] sg13g2_o21ai_1
XFILLER_12_668 VPWR VGND sg13g2_fill_1
X_21678_ VGND VPWR u_LMS.w\[7\]\[20\] net320 _02287_ _02276_ sg13g2_a21oi_1
XFILLER_12_679 VPWR VGND sg13g2_fill_2
X_23417_ net1097 VGND VPWR _00479_ u_LMS.w\[8\]\[4\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
X_20629_ _01266_ _01268_ _01269_ VPWR VGND sg13g2_nor2_1
X_14150_ net822 _05459_ net763 _05460_ VPWR VGND sg13g2_nand3_1
X_23348_ net1253 VGND VPWR _00410_ u_LMS.w\[5\]\[4\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
XFILLER_4_812 VPWR VGND sg13g2_decap_8
X_13101_ VGND VPWR _04451_ _04449_ _04417_ sg13g2_or2_1
X_14081_ _05393_ _05392_ _05354_ VPWR VGND sg13g2_nand2b_1
X_23279_ net1335 VGND VPWR _00341_ u_LMS.w\[2\]\[4\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
XFILLER_106_751 VPWR VGND sg13g2_decap_8
X_13032_ VGND VPWR _04381_ _04383_ _04385_ _04369_ sg13g2_a21oi_1
XFILLER_106_773 VPWR VGND sg13g2_decap_8
X_23498__1420 VPWR VGND net1419 sg13g2_tiehi
XFILLER_65_1055 VPWR VGND sg13g2_decap_4
X_23311__1291 VPWR VGND net1290 sg13g2_tiehi
X_17840_ _08973_ _08731_ _08972_ VPWR VGND sg13g2_nand2_1
XFILLER_26_1028 VPWR VGND sg13g2_decap_8
X_17771_ VGND VPWR _08904_ _08903_ _08902_ sg13g2_or2_1
XFILLER_94_638 VPWR VGND sg13g2_decap_8
XFILLER_78_189 VPWR VGND sg13g2_decap_8
Xfanout180 net181 net180 VPWR VGND sg13g2_buf_2
X_14983_ VGND VPWR _06260_ _06261_ _06262_ net412 sg13g2_a21oi_1
XFILLER_94_649 VPWR VGND sg13g2_fill_2
XFILLER_59_381 VPWR VGND sg13g2_decap_8
XFILLER_47_521 VPWR VGND sg13g2_decap_8
XFILLER_14_9 VPWR VGND sg13g2_fill_1
Xfanout191 net194 net191 VPWR VGND sg13g2_buf_2
X_19510_ _10572_ VPWR _10574_ VGND _03247_ net181 sg13g2_o21ai_1
X_16722_ VGND VPWR net529 _07880_ _00276_ _07881_ sg13g2_a21oi_1
X_13934_ _05251_ _05252_ _05254_ VPWR VGND sg13g2_nor2b_1
XFILLER_74_340 VPWR VGND sg13g2_decap_8
XFILLER_47_576 VPWR VGND sg13g2_fill_1
XFILLER_35_716 VPWR VGND sg13g2_fill_1
X_19441_ _10501_ VPWR _10505_ VGND _10502_ _10504_ sg13g2_o21ai_1
X_16653_ u_LMS.w\[6\]\[24\] u_LMS.w\[6\]\[23\] u_LMS.w\[6\]\[22\] u_LMS.w\[6\]\[21\]
+ _07830_ VPWR VGND sg13g2_nor4_1
X_13865_ _03363_ net810 _05188_ VPWR VGND sg13g2_nor2_1
X_15604_ VGND VPWR _06823_ _06850_ _06858_ _06849_ sg13g2_a21oi_1
X_19372_ net424 _03244_ net181 net225 _10436_ VPWR VGND sg13g2_nor4_1
X_12816_ _04176_ _04177_ _04178_ VPWR VGND sg13g2_and2_1
X_16584_ net991 VPWR _07780_ VGND net491 net771 sg13g2_o21ai_1
X_13796_ _05096_ VPWR _05121_ VGND net282 _05097_ sg13g2_o21ai_1
XFILLER_62_579 VPWR VGND sg13g2_fill_1
XFILLER_90_899 VPWR VGND sg13g2_decap_4
X_18323_ _09433_ _09432_ _09430_ VPWR VGND sg13g2_nand2b_1
X_15535_ _06792_ _06770_ _06790_ VPWR VGND sg13g2_xnor2_1
X_12747_ _04111_ _04092_ _04110_ VPWR VGND sg13g2_nand2_1
XFILLER_31_955 VPWR VGND sg13g2_decap_4
X_18254_ _09362_ _09361_ _09364_ VPWR VGND sg13g2_xor2_1
XFILLER_8_21 VPWR VGND sg13g2_decap_8
X_15466_ _06728_ _06720_ _06727_ VPWR VGND sg13g2_xnor2_1
X_12678_ _04008_ _04043_ _04044_ VPWR VGND sg13g2_nor2_1
X_17205_ _08250_ VPWR _08361_ VGND _08237_ _08248_ sg13g2_o21ai_1
X_14417_ _05719_ _05718_ _05698_ VPWR VGND sg13g2_nand2b_1
X_18185_ _09295_ net672 net182 VPWR VGND sg13g2_nand2_1
X_15397_ net1002 VPWR _06663_ VGND net502 u_FIR.sum\[6\]\[13\] sg13g2_o21ai_1
XFILLER_8_98 VPWR VGND sg13g2_fill_2
X_17136_ _08291_ _08283_ _08292_ VPWR VGND sg13g2_xor2_1
XFILLER_129_887 VPWR VGND sg13g2_fill_2
X_14348_ _05653_ _05652_ _05618_ VPWR VGND sg13g2_nand2b_1
XFILLER_129_898 VPWR VGND sg13g2_fill_2
XFILLER_128_397 VPWR VGND sg13g2_decap_4
X_17067_ _08223_ net112 _08222_ VPWR VGND sg13g2_nand2_1
X_14279_ _05586_ u_FIR.sum\[3\]\[10\] net401 VPWR VGND sg13g2_xnor2_1
XFILLER_98_900 VPWR VGND sg13g2_fill_2
X_16018_ _07259_ net797 net872 VPWR VGND sg13g2_nand2_1
XFILLER_69_101 VPWR VGND sg13g2_fill_1
XFILLER_97_421 VPWR VGND sg13g2_decap_8
XFILLER_124_581 VPWR VGND sg13g2_fill_1
XFILLER_112_743 VPWR VGND sg13g2_fill_2
Xrebuffer1649 net2201 net1648 VPWR VGND sg13g2_buf_2
XFILLER_98_966 VPWR VGND sg13g2_fill_1
XFILLER_112_754 VPWR VGND sg13g2_decap_8
XFILLER_97_465 VPWR VGND sg13g2_fill_2
XFILLER_26_0 VPWR VGND sg13g2_decap_4
X_17969_ _09040_ _09039_ _09101_ VPWR VGND sg13g2_xor2_1
X_19708_ u_LMS.w\[4\]\[3\] _10769_ _10772_ VPWR VGND sg13g2_nor2_1
X_20980_ _01620_ _01619_ _01584_ VPWR VGND sg13g2_nand2b_1
XFILLER_66_863 VPWR VGND sg13g2_fill_2
XFILLER_38_554 VPWR VGND sg13g2_decap_8
XFILLER_38_565 VPWR VGND sg13g2_fill_2
X_19639_ _10703_ _10702_ _10693_ VPWR VGND sg13g2_nand2b_1
XFILLER_38_598 VPWR VGND sg13g2_fill_1
XFILLER_81_855 VPWR VGND sg13g2_decap_4
X_22650_ net466 coeff_force_packed\[24\] _03064_ _00643_ VPWR VGND sg13g2_mux2_1
XFILLER_129_1049 VPWR VGND sg13g2_decap_8
X_23128__1598 VPWR VGND net1597 sg13g2_tiehi
X_21601_ _02218_ _02217_ _02171_ VPWR VGND sg13g2_nand2b_1
X_22581_ net917 _03051_ _00587_ VPWR VGND sg13g2_nor2_1
XFILLER_33_270 VPWR VGND sg13g2_fill_1
XFILLER_61_590 VPWR VGND sg13g2_fill_2
XFILLER_22_955 VPWR VGND sg13g2_decap_4
X_21532_ _02148_ VPWR _02149_ VGND _03219_ _01794_ sg13g2_o21ai_1
X_23353__1249 VPWR VGND net1248 sg13g2_tiehi
X_21463_ _02080_ _02069_ _02071_ VPWR VGND sg13g2_xnor2_1
X_23202_ net1477 VGND VPWR _00264_ u_FIR.w\[6\]\[5\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
XFILLER_107_504 VPWR VGND sg13g2_fill_1
X_20414_ VGND VPWR _01075_ _01076_ _00395_ net934 sg13g2_a21oi_1
X_21394_ VGND VPWR _02011_ _02010_ _01994_ sg13g2_or2_1
XFILLER_4_119 VPWR VGND sg13g2_decap_8
XFILLER_119_397 VPWR VGND sg13g2_fill_1
X_23133_ net1589 VGND VPWR _00195_ u_FIR.sum\[8\]\[5\] clknet_leaf_46_clkA sg13g2_dfrbpq_1
X_20345_ _01008_ u_LMS.w\[5\]\[4\] _01000_ VPWR VGND sg13g2_xnor2_1
XFILLER_104_7 VPWR VGND sg13g2_fill_2
XFILLER_108_33 VPWR VGND sg13g2_decap_8
XFILLER_108_55 VPWR VGND sg13g2_decap_4
X_23064_ net1110 VGND VPWR _00126_ u_FIR.sum\[4\]\[7\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
X_20276_ _00838_ VPWR _00939_ VGND _00938_ _00936_ sg13g2_o21ai_1
XFILLER_115_570 VPWR VGND sg13g2_decap_8
X_22015_ _02609_ net582 net221 VPWR VGND sg13g2_nand2_1
XFILLER_102_220 VPWR VGND sg13g2_fill_1
XFILLER_102_231 VPWR VGND sg13g2_fill_1
XFILLER_0_358 VPWR VGND sg13g2_decap_4
XFILLER_102_242 VPWR VGND sg13g2_fill_1
XFILLER_89_999 VPWR VGND sg13g2_fill_1
XFILLER_130_562 VPWR VGND sg13g2_decap_8
XFILLER_124_21 VPWR VGND sg13g2_decap_8
XFILLER_84_14 VPWR VGND sg13g2_decap_4
X_11980_ _03397_ _03396_ spi_addr\[4\] VPWR VGND sg13g2_nand2b_1
XFILLER_91_608 VPWR VGND sg13g2_decap_8
XFILLER_57_863 VPWR VGND sg13g2_decap_4
XFILLER_84_58 VPWR VGND sg13g2_fill_2
XFILLER_57_885 VPWR VGND sg13g2_decap_4
XFILLER_17_716 VPWR VGND sg13g2_fill_2
X_22917_ net1028 VPWR _03187_ VGND net553 u_s2p_input.reg_cnt\[0\] sg13g2_o21ai_1
X_22848_ net552 _03142_ _03145_ VPWR VGND sg13g2_nor2_1
X_13650_ _04977_ _04978_ _04979_ VPWR VGND sg13g2_and2_1
XFILLER_25_760 VPWR VGND sg13g2_decap_8
X_12601_ net867 u_FIR.sum\[0\]\[3\] net736 _03969_ VPWR VGND sg13g2_nand3_1
X_13581_ _04912_ _04904_ _04911_ VPWR VGND sg13g2_nand2_1
X_22779_ VGND VPWR _07805_ net340 _00729_ _03107_ sg13g2_a21oi_1
X_15320_ _06588_ u_FIR.sum\[5\]\[11\] net394 VPWR VGND sg13g2_nand2_1
X_12532_ _03904_ _03890_ _03906_ VPWR VGND sg13g2_xor2_1
X_23329__1273 VPWR VGND net1272 sg13g2_tiehi
XFILLER_130_0 VPWR VGND sg13g2_decap_8
X_15251_ _06521_ _06512_ _06519_ VPWR VGND sg13g2_xnor2_1
X_12463_ _03839_ _03838_ _03834_ VPWR VGND sg13g2_nand2b_1
XFILLER_32_1054 VPWR VGND sg13g2_decap_8
X_14202_ _05511_ _05507_ _05510_ VPWR VGND sg13g2_xnor2_1
X_15182_ _06432_ VPWR _06453_ VGND _06433_ _06441_ sg13g2_o21ai_1
X_12394_ _03770_ _03771_ _03772_ VPWR VGND sg13g2_nor2b_1
XFILLER_126_846 VPWR VGND sg13g2_decap_4
X_14133_ _05443_ _05442_ _00125_ VPWR VGND sg13g2_nor2b_1
XFILLER_4_631 VPWR VGND sg13g2_decap_8
X_19990_ VGND VPWR net625 net193 _11031_ _11027_ sg13g2_a21oi_1
X_18941_ _10017_ VPWR _10028_ VGND _09984_ _10015_ sg13g2_o21ai_1
X_14064_ _05373_ _05375_ _05376_ VPWR VGND sg13g2_nor2_1
XFILLER_106_570 VPWR VGND sg13g2_decap_4
X_13015_ _04369_ net746 net895 u_FIR.sum\[1\]\[1\] VPWR VGND sg13g2_and3_1
X_18872_ _09926_ _09925_ _09959_ VPWR VGND sg13g2_xor2_1
X_17823_ VGND VPWR _08954_ _08955_ _08956_ _08884_ sg13g2_a21oi_1
XFILLER_67_649 VPWR VGND sg13g2_decap_8
X_17754_ _08887_ net692 net258 VPWR VGND sg13g2_nand2_1
X_14966_ _06247_ _06237_ _06245_ VPWR VGND sg13g2_xnor2_1
X_23057__1121 VPWR VGND net1120 sg13g2_tiehi
X_16705_ u_LMS.w\[8\]\[23\] u_LMS.w\[8\]\[22\] net716 _07868_ VPWR VGND u_LMS.w\[8\]\[21\]
+ sg13g2_nand4_1
XFILLER_35_513 VPWR VGND sg13g2_fill_1
X_13917_ _05238_ _05190_ _05236_ VPWR VGND sg13g2_xnor2_1
X_17685_ _08769_ _08817_ _08818_ VPWR VGND sg13g2_nor2_1
X_14897_ _06167_ VPWR _06181_ VGND net267 _06165_ sg13g2_o21ai_1
X_19424_ _10479_ VPWR _10488_ VGND _10476_ _10480_ sg13g2_o21ai_1
X_16636_ VGND VPWR u_LMS.w\[5\]\[14\] _07812_ _07818_ _07813_ sg13g2_a21oi_1
X_13848_ _05166_ _05171_ _05172_ VPWR VGND sg13g2_nor2b_1
XFILLER_90_685 VPWR VGND sg13g2_fill_2
X_19355_ net642 net153 net639 _10419_ VPWR VGND net96 sg13g2_nand4_1
Xclkbuf_leaf_29_clkA clknet_4_15_0_clkA clknet_leaf_29_clkA VPWR VGND sg13g2_buf_8
X_16567_ VGND VPWR net485 _07765_ _00236_ _07766_ sg13g2_a21oi_1
XFILLER_62_398 VPWR VGND sg13g2_fill_2
XFILLER_50_538 VPWR VGND sg13g2_decap_4
X_13779_ _05105_ _05104_ _05064_ VPWR VGND sg13g2_nand2b_1
X_18306_ _09416_ _09383_ _09381_ VPWR VGND sg13g2_xnor2_1
X_15518_ _06775_ _06773_ _06774_ VPWR VGND sg13g2_nand2_1
X_19286_ _10349_ _10347_ _10346_ _10350_ VPWR VGND sg13g2_a21o_1
X_16498_ VGND VPWR net482 _07715_ _00217_ _07716_ sg13g2_a21oi_1
X_18237_ _03265_ net90 _09347_ VPWR VGND sg13g2_nor2_1
XFILLER_90_90 VPWR VGND sg13g2_decap_4
X_15449_ _06705_ _06711_ _06712_ VPWR VGND sg13g2_nor2_1
XFILLER_8_970 VPWR VGND sg13g2_fill_1
X_18168_ VGND VPWR _09268_ _09269_ _09278_ _09277_ sg13g2_a21oi_1
XFILLER_116_323 VPWR VGND sg13g2_fill_2
X_17119_ _08273_ _08274_ _08275_ VPWR VGND sg13g2_nor2_1
Xrebuffer2103 _09339_ net2102 VPWR VGND sg13g2_buf_1
X_18099_ _09209_ _09203_ _09208_ VPWR VGND sg13g2_xnor2_1
Xrebuffer2125 _01049_ net2124 VPWR VGND sg13g2_buf_1
XFILLER_104_518 VPWR VGND sg13g2_fill_2
X_20130_ _03241_ net142 _11171_ VPWR VGND sg13g2_nor2_1
Xrebuffer2136 _10725_ net2135 VPWR VGND sg13g2_buf_1
Xrebuffer2147 net2147 net2146 VPWR VGND sg13g2_buf_1
XFILLER_132_838 VPWR VGND sg13g2_decap_8
Xrebuffer2158 net2158 net2157 VPWR VGND sg13g2_buf_1
Xfanout905 net911 net905 VPWR VGND sg13g2_buf_1
Xrebuffer2169 _02760_ net2168 VPWR VGND sg13g2_buf_2
X_23710__1450 VPWR VGND net1449 sg13g2_tiehi
Xfanout916 net918 net916 VPWR VGND sg13g2_buf_1
X_20061_ _11102_ net627 net173 VPWR VGND sg13g2_nand2_1
Xfanout927 net928 net927 VPWR VGND sg13g2_buf_1
XFILLER_112_540 VPWR VGND sg13g2_decap_8
Xfanout938 net939 net938 VPWR VGND sg13g2_buf_1
Xfanout949 net957 net949 VPWR VGND sg13g2_buf_1
X_23717__1404 VPWR VGND net1403 sg13g2_tiehi
X_23425__1074 VPWR VGND net1073 sg13g2_tiehi
XFILLER_72_107 VPWR VGND sg13g2_decap_4
XFILLER_39_885 VPWR VGND sg13g2_decap_8
X_23751_ net1362 VGND VPWR _00813_ u_LMS.x\[2\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
X_20963_ VGND VPWR u_LMS.w\[6\]\[4\] _01593_ _01603_ _01602_ sg13g2_a21oi_1
XFILLER_72_129 VPWR VGND sg13g2_decap_4
X_22702_ u_debug_unit.error_signal_sync\[0\] _07915_ net332 _00688_ VPWR VGND sg13g2_mux2_1
XFILLER_53_332 VPWR VGND sg13g2_fill_2
X_23464__1540 VPWR VGND net1539 sg13g2_tiehi
XFILLER_81_652 VPWR VGND sg13g2_fill_1
XFILLER_0_1041 VPWR VGND sg13g2_decap_8
X_23682_ net1030 VGND VPWR _00744_ u_debug_unit.mon_w6_sync\[6\] clknet_leaf_22_clkA
+ sg13g2_dfrbpq_1
XFILLER_54_877 VPWR VGND sg13g2_decap_8
X_20894_ _01530_ VPWR _01534_ VGND _01400_ _01531_ sg13g2_o21ai_1
XFILLER_80_140 VPWR VGND sg13g2_fill_2
XFILLER_26_579 VPWR VGND sg13g2_decap_4
XFILLER_80_151 VPWR VGND sg13g2_decap_4
X_22633_ net464 coeff_force_packed\[11\] _03062_ _00628_ VPWR VGND sg13g2_mux2_1
XFILLER_41_527 VPWR VGND sg13g2_decap_4
X_22564_ net917 _03040_ _00581_ VPWR VGND sg13g2_nor2_1
XFILLER_16_1049 VPWR VGND sg13g2_decap_8
XFILLER_103_1008 VPWR VGND sg13g2_fill_2
X_21515_ _01925_ VPWR _02132_ VGND _02129_ _02131_ sg13g2_o21ai_1
XFILLER_21_273 VPWR VGND sg13g2_decap_8
X_22495_ net958 VPWR _02997_ VGND net441 net577 sg13g2_o21ai_1
XFILLER_5_406 VPWR VGND sg13g2_decap_8
XFILLER_119_21 VPWR VGND sg13g2_decap_8
XFILLER_108_824 VPWR VGND sg13g2_decap_8
X_21446_ _03223_ net252 _02063_ VPWR VGND sg13g2_nor2_1
XFILLER_5_417 VPWR VGND sg13g2_decap_4
X_21377_ VGND VPWR _01968_ _01990_ _01994_ _01993_ sg13g2_a21oi_1
XFILLER_107_356 VPWR VGND sg13g2_fill_2
XFILLER_107_378 VPWR VGND sg13g2_fill_2
X_23116_ net1615 VGND VPWR _00178_ u_FIR.sum\[7\]\[2\] clknet_leaf_47_clkA sg13g2_dfrbpq_1
X_20328_ _00991_ _00931_ _00933_ VPWR VGND sg13g2_xnor2_1
XFILLER_122_315 VPWR VGND sg13g2_fill_2
X_23047_ net1135 VGND VPWR _00109_ u_FIR.sum\[3\]\[9\] clknet_leaf_33_clkA sg13g2_dfrbpq_1
XFILLER_0_133 VPWR VGND sg13g2_decap_8
X_20259_ _00913_ _00919_ _00922_ VPWR VGND sg13g2_nor2b_1
XFILLER_77_914 VPWR VGND sg13g2_decap_4
XFILLER_62_1025 VPWR VGND sg13g2_fill_2
XFILLER_88_251 VPWR VGND sg13g2_fill_2
XFILLER_131_871 VPWR VGND sg13g2_fill_2
XFILLER_89_796 VPWR VGND sg13g2_decap_8
XFILLER_48_104 VPWR VGND sg13g2_decap_8
X_14820_ _06107_ _06070_ _06105_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_928 VPWR VGND sg13g2_fill_1
XFILLER_45_800 VPWR VGND sg13g2_fill_1
X_14751_ _06040_ _06008_ _06039_ VPWR VGND sg13g2_xnor2_1
X_11963_ VPWR _03384_ net1001 VGND sg13g2_inv_1
XFILLER_72_630 VPWR VGND sg13g2_decap_8
X_13702_ _05030_ _04987_ _05028_ VPWR VGND sg13g2_xnor2_1
X_17470_ _08603_ _08602_ _08597_ VPWR VGND sg13g2_nand2b_1
X_14682_ _05972_ net769 net849 VPWR VGND sg13g2_nand2_1
X_11894_ VPWR _03315_ u_LMS.w\[5\]\[24\] VGND sg13g2_inv_1
XFILLER_44_376 VPWR VGND sg13g2_decap_8
X_16421_ _07649_ net270 _07651_ VPWR VGND sg13g2_xor2_1
XFILLER_44_50 VPWR VGND sg13g2_fill_2
X_13633_ VGND VPWR _04924_ _04953_ _04962_ _04952_ sg13g2_a21oi_1
X_19140_ u_LMS.w\[3\]\[11\] _10185_ _10227_ VPWR VGND sg13g2_nor2_1
X_16352_ _07585_ _07556_ _07558_ _07522_ net794 VPWR VGND sg13g2_a22oi_1
X_13564_ _04895_ net751 net864 VPWR VGND sg13g2_nand2_1
X_15303_ _06557_ VPWR _06571_ VGND _06553_ _06555_ sg13g2_o21ai_1
X_19071_ VGND VPWR _09829_ _09835_ _10158_ _09784_ sg13g2_a21oi_1
X_12515_ _03880_ VPWR _03889_ VGND _03825_ _03881_ sg13g2_o21ai_1
X_16283_ _07504_ VPWR _07518_ VGND _07500_ _07502_ sg13g2_o21ai_1
X_13495_ net880 net755 u_FIR.sum\[2\]\[2\] _04829_ VPWR VGND sg13g2_a21o_1
X_18022_ VGND VPWR _09142_ _09143_ _00314_ net923 sg13g2_a21oi_1
X_15234_ u_FIR.w\[2\]\[2\] net804 _06504_ VPWR VGND sg13g2_and2_1
X_12446_ VGND VPWR _03755_ _03814_ _03822_ _03813_ sg13g2_a21oi_1
XFILLER_126_632 VPWR VGND sg13g2_decap_4
X_15165_ _06437_ u_FIR.sum\[5\]\[7\] net395 VPWR VGND sg13g2_nand2_1
X_12377_ VPWR _03755_ _03754_ VGND sg13g2_inv_1
XFILLER_126_676 VPWR VGND sg13g2_decap_8
XFILLER_125_153 VPWR VGND sg13g2_fill_1
X_14116_ VGND VPWR net766 net825 _05427_ u_FIR.sum\[3\]\[6\] sg13g2_a21oi_1
XFILLER_99_527 VPWR VGND sg13g2_fill_1
X_19973_ _11011_ _11006_ _11014_ VPWR VGND sg13g2_xor2_1
X_15096_ _06334_ _06332_ _06368_ _06370_ VPWR VGND sg13g2_a21o_1
XFILLER_5_995 VPWR VGND sg13g2_decap_8
XFILLER_119_1026 VPWR VGND sg13g2_decap_8
XFILLER_5_77 VPWR VGND sg13g2_decap_8
X_18924_ VGND VPWR _10009_ _10010_ _10011_ _10008_ sg13g2_a21oi_1
X_14047_ _05360_ _05352_ _05359_ VPWR VGND sg13g2_nand2_1
XFILLER_122_882 VPWR VGND sg13g2_fill_2
X_18855_ _09911_ _09941_ _09942_ VPWR VGND sg13g2_and2_1
XFILLER_68_958 VPWR VGND sg13g2_fill_1
XFILLER_95_744 VPWR VGND sg13g2_fill_2
XFILLER_121_381 VPWR VGND sg13g2_decap_4
XFILLER_94_232 VPWR VGND sg13g2_fill_1
X_17806_ _08939_ _08938_ _08910_ VPWR VGND sg13g2_nand2b_1
X_18786_ _09870_ _09872_ _09873_ VPWR VGND sg13g2_nor2_1
X_15998_ _07239_ _07235_ _07236_ VPWR VGND sg13g2_xnor2_1
XFILLER_82_405 VPWR VGND sg13g2_decap_8
XFILLER_94_276 VPWR VGND sg13g2_fill_1
XFILLER_82_416 VPWR VGND sg13g2_fill_2
X_17737_ _08864_ VPWR _08870_ VGND _08832_ _08860_ sg13g2_o21ai_1
X_14949_ _06231_ _06219_ _06230_ VPWR VGND sg13g2_nand2b_1
XFILLER_94_298 VPWR VGND sg13g2_fill_1
XFILLER_75_490 VPWR VGND sg13g2_fill_2
XFILLER_47_181 VPWR VGND sg13g2_fill_2
X_23713__1432 VPWR VGND net1431 sg13g2_tiehi
XFILLER_91_961 VPWR VGND sg13g2_decap_8
X_17668_ _08801_ net693 net223 VPWR VGND sg13g2_nand2_1
X_19407_ _10468_ _10470_ _10471_ VPWR VGND sg13g2_nor2_1
X_16619_ VGND VPWR u_LMS.w\[4\]\[17\] _07793_ _07805_ _07794_ sg13g2_a21oi_1
X_17599_ _08728_ _08723_ _08732_ VPWR VGND sg13g2_xor2_1
XFILLER_93_0 VPWR VGND sg13g2_decap_8
X_19338_ _10402_ net85 net641 net101 net639 VPWR VGND sg13g2_a22oi_1
X_19269_ _10337_ net55 _10336_ VPWR VGND sg13g2_nand2_1
X_21300_ VGND VPWR net93 _01915_ _01917_ _01781_ sg13g2_a21oi_1
X_23270__1354 VPWR VGND net1353 sg13g2_tiehi
XFILLER_15_1060 VPWR VGND sg13g2_fill_1
X_22280_ VGND VPWR _02867_ _02868_ _00469_ net924 sg13g2_a21oi_1
X_21231_ _01848_ _01847_ _01846_ VPWR VGND sg13g2_nand2b_1
XFILLER_85_1003 VPWR VGND sg13g2_fill_2
XFILLER_85_1014 VPWR VGND sg13g2_fill_2
XFILLER_105_816 VPWR VGND sg13g2_fill_2
XFILLER_116_153 VPWR VGND sg13g2_decap_8
XFILLER_104_304 VPWR VGND sg13g2_decap_8
XFILLER_132_613 VPWR VGND sg13g2_fill_2
XFILLER_104_315 VPWR VGND sg13g2_decap_4
X_21162_ _01763_ _01778_ _01779_ VPWR VGND sg13g2_nor2_1
XFILLER_116_186 VPWR VGND sg13g2_decap_8
XFILLER_104_337 VPWR VGND sg13g2_decap_8
X_20113_ _11154_ _11135_ _11136_ VPWR VGND sg13g2_xnor2_1
Xfanout702 u_LMS.x_r\[0\]\[7\] net702 VPWR VGND sg13g2_buf_1
XFILLER_132_668 VPWR VGND sg13g2_decap_8
X_21093_ VGND VPWR _01660_ _01717_ _01718_ net14 sg13g2_a21oi_1
Xfanout713 u_LMS.x_r\[0\]\[1\] net713 VPWR VGND sg13g2_buf_1
Xfanout724 u_FIR.w\[8\]\[2\] net724 VPWR VGND sg13g2_buf_1
Xfanout735 u_FIR.w\[7\]\[1\] net735 VPWR VGND sg13g2_buf_1
XFILLER_59_925 VPWR VGND sg13g2_fill_2
Xfanout746 net747 net746 VPWR VGND sg13g2_buf_1
X_20044_ _11085_ _11083_ _11084_ VPWR VGND sg13g2_nand2_1
XFILLER_59_947 VPWR VGND sg13g2_fill_1
Xfanout757 net759 net757 VPWR VGND sg13g2_buf_1
XFILLER_86_733 VPWR VGND sg13g2_decap_8
Xfanout768 u_FIR.w\[3\]\[5\] net768 VPWR VGND sg13g2_buf_1
XFILLER_112_392 VPWR VGND sg13g2_fill_2
Xfanout779 u_FIR.w\[2\]\[3\] net779 VPWR VGND sg13g2_buf_1
XFILLER_100_543 VPWR VGND sg13g2_decap_8
XFILLER_85_232 VPWR VGND sg13g2_fill_1
XFILLER_105_56 VPWR VGND sg13g2_fill_2
XFILLER_85_243 VPWR VGND sg13g2_fill_2
XFILLER_74_917 VPWR VGND sg13g2_decap_4
XFILLER_65_16 VPWR VGND sg13g2_fill_2
XFILLER_22_1020 VPWR VGND sg13g2_decap_4
XFILLER_100_576 VPWR VGND sg13g2_decap_8
XFILLER_27_811 VPWR VGND sg13g2_fill_1
XFILLER_26_310 VPWR VGND sg13g2_decap_8
X_21995_ _02587_ _02588_ _02589_ VPWR VGND sg13g2_nor2b_1
XFILLER_27_855 VPWR VGND sg13g2_decap_8
XFILLER_82_961 VPWR VGND sg13g2_decap_8
X_20946_ _01586_ u_LMS.w\[6\]\[9\] _01585_ VPWR VGND sg13g2_nand2_1
X_23734_ net996 VGND VPWR _00796_ spi_addr\[0\] clknet_3_4__leaf_spi_sclk sg13g2_dfrbpq_1
XFILLER_82_972 VPWR VGND sg13g2_fill_2
XFILLER_42_825 VPWR VGND sg13g2_fill_2
X_20877_ _01496_ _01516_ _01517_ VPWR VGND sg13g2_nor2b_1
X_23665_ net1019 VGND VPWR _00727_ u_debug_unit.mon_w4_sync\[3\] clknet_leaf_36_clkA
+ sg13g2_dfrbpq_1
XFILLER_41_346 VPWR VGND sg13g2_fill_1
X_22616_ net462 sys_enable_bus\[5\] _03060_ _00613_ VPWR VGND sg13g2_mux2_1
X_23596_ net1012 VGND VPWR _00658_ coeff_force_packed\[37\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
XFILLER_22_560 VPWR VGND sg13g2_decap_8
XFILLER_50_891 VPWR VGND sg13g2_decap_8
X_22547_ u_LMS.count\[16\] _03029_ _03030_ VPWR VGND sg13g2_and2_1
XFILLER_10_755 VPWR VGND sg13g2_fill_2
X_12300_ _03680_ net721 net881 VPWR VGND sg13g2_nand2_1
X_13280_ _04626_ _04597_ _04624_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_726 VPWR VGND sg13g2_decap_4
X_22478_ VGND VPWR net446 _03230_ _00547_ _02988_ sg13g2_a21oi_1
X_12231_ _03614_ _03612_ _03613_ VPWR VGND sg13g2_nand2_1
X_21429_ _02023_ _02045_ _02046_ VPWR VGND sg13g2_and2_1
XFILLER_107_164 VPWR VGND sg13g2_decap_8
X_12162_ _03571_ _03451_ _03570_ _03392_ u_spi_slave.tx_shift\[8\] VPWR VGND sg13g2_a22oi_1
XFILLER_2_943 VPWR VGND sg13g2_decap_8
X_16970_ _08121_ VPWR _08126_ VGND _08122_ _08125_ sg13g2_o21ai_1
X_12093_ _03505_ net285 sys_enable_bus\[3\] net293 coeff_force_packed\[52\] VPWR VGND
+ sg13g2_a22oi_1
XFILLER_104_882 VPWR VGND sg13g2_decap_8
X_15921_ _07166_ u_FIR.sum\[6\]\[15\] net390 VPWR VGND sg13g2_nand2_1
XFILLER_1_497 VPWR VGND sg13g2_decap_4
XFILLER_39_72 VPWR VGND sg13g2_fill_2
X_18640_ _09735_ _09619_ _09620_ VPWR VGND sg13g2_xnor2_1
X_15852_ _07100_ net275 _07098_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_777 VPWR VGND sg13g2_decap_4
X_14803_ _06090_ _06059_ _06062_ VPWR VGND sg13g2_nand2_1
XFILLER_76_287 VPWR VGND sg13g2_decap_8
X_18571_ _09678_ _09680_ _09681_ VPWR VGND sg13g2_and2_2
XFILLER_76_298 VPWR VGND sg13g2_fill_2
XFILLER_64_438 VPWR VGND sg13g2_fill_1
X_15783_ _07032_ net275 _07033_ VPWR VGND sg13g2_xor2_1
XFILLER_29_170 VPWR VGND sg13g2_decap_8
X_12995_ _04334_ _04336_ _04351_ _04352_ VPWR VGND sg13g2_nor3_1
XFILLER_45_630 VPWR VGND sg13g2_fill_2
XFILLER_17_332 VPWR VGND sg13g2_decap_8
X_17522_ net686 net147 net684 _08655_ VPWR VGND net92 sg13g2_nand4_1
X_14734_ _06023_ net823 _06022_ VPWR VGND sg13g2_nand2_1
XFILLER_55_60 VPWR VGND sg13g2_decap_8
X_11946_ VPWR _03367_ u_FIR.w\[3\]\[6\] VGND sg13g2_inv_1
XFILLER_44_162 VPWR VGND sg13g2_decap_8
XFILLER_33_825 VPWR VGND sg13g2_decap_8
XFILLER_33_836 VPWR VGND sg13g2_fill_2
X_17453_ _08583_ _08585_ _08586_ VPWR VGND sg13g2_nor2_1
X_14665_ _05956_ _05951_ _05954_ VPWR VGND sg13g2_xnor2_1
X_11877_ VPWR _03298_ u_LMS.w\[7\]\[10\] VGND sg13g2_inv_1
X_16404_ _07589_ _07634_ _07635_ VPWR VGND sg13g2_nor2_1
X_13616_ _04946_ u_FIR.w\[5\]\[6\] _04945_ VPWR VGND sg13g2_xnor2_1
XFILLER_38_1060 VPWR VGND sg13g2_fill_1
X_17384_ _08530_ _08475_ _08532_ VPWR VGND sg13g2_xor2_1
X_14596_ _05887_ _05888_ _00143_ VPWR VGND sg13g2_nor2_1
XFILLER_125_1030 VPWR VGND sg13g2_decap_8
XFILLER_41_880 VPWR VGND sg13g2_decap_8
X_19123_ VGND VPWR _10199_ _10208_ _10210_ _10209_ sg13g2_a21oi_1
XFILLER_9_520 VPWR VGND sg13g2_decap_4
X_16335_ _07569_ _07534_ _07567_ VPWR VGND sg13g2_xnor2_1
X_13547_ _04878_ _04851_ _04879_ VPWR VGND sg13g2_xor2_1
XFILLER_118_418 VPWR VGND sg13g2_fill_2
X_19054_ VGND VPWR _10012_ _10141_ _10140_ _10013_ sg13g2_a21oi_2
X_16266_ _07502_ u_FIR.sum\[7\]\[10\] net386 VPWR VGND sg13g2_xnor2_1
X_13478_ _04812_ _04813_ _00100_ VPWR VGND sg13g2_nor2_1
X_18005_ net40 VPWR _09130_ VGND net38 _09129_ sg13g2_o21ai_1
X_15217_ _06486_ VPWR _06488_ VGND _06446_ _06448_ sg13g2_o21ai_1
X_12429_ VGND VPWR net827 _03804_ _03806_ _03803_ sg13g2_a21oi_1
X_16197_ _07434_ _07403_ _07435_ VPWR VGND sg13g2_xor2_1
XFILLER_99_302 VPWR VGND sg13g2_decap_4
X_15148_ net875 net776 _06418_ _06420_ VPWR VGND sg13g2_a21o_1
XFILLER_126_495 VPWR VGND sg13g2_decap_4
XFILLER_99_335 VPWR VGND sg13g2_fill_2
XFILLER_114_646 VPWR VGND sg13g2_decap_8
X_19956_ _10996_ _10962_ _10997_ VPWR VGND sg13g2_xor2_1
X_15079_ _06353_ _06352_ _06318_ VPWR VGND sg13g2_nand2b_1
X_18907_ _09992_ _09991_ _09994_ VPWR VGND sg13g2_xor2_1
XFILLER_68_733 VPWR VGND sg13g2_fill_1
X_19887_ _10930_ _10792_ _10794_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_1045 VPWR VGND sg13g2_decap_8
X_18838_ _09925_ _09920_ _09923_ VPWR VGND sg13g2_xnor2_1
XFILLER_55_416 VPWR VGND sg13g2_fill_1
XFILLER_49_980 VPWR VGND sg13g2_decap_8
X_18769_ _03255_ net91 _09856_ VPWR VGND sg13g2_nor2_1
X_20800_ _01415_ VPWR _01440_ VGND _03234_ net141 sg13g2_o21ai_1
X_21780_ _02358_ _02373_ _02374_ VPWR VGND sg13g2_nor2_1
XFILLER_24_825 VPWR VGND sg13g2_decap_8
XFILLER_23_302 VPWR VGND sg13g2_decap_8
XFILLER_63_471 VPWR VGND sg13g2_fill_1
XFILLER_36_696 VPWR VGND sg13g2_fill_2
X_20731_ _01371_ net616 net171 VPWR VGND sg13g2_nand2_1
XFILLER_91_791 VPWR VGND sg13g2_decap_4
XFILLER_24_847 VPWR VGND sg13g2_decap_8
XFILLER_90_290 VPWR VGND sg13g2_fill_1
X_23450_ net1581 VGND VPWR _00512_ u_LMS.x_r\[3\]\[1\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
X_20662_ _01302_ _01271_ _01298_ _01300_ VPWR VGND sg13g2_and3_1
X_22401_ net948 VPWR _02950_ VGND net431 net671 sg13g2_o21ai_1
X_23381_ net1205 VGND VPWR _00443_ u_LMS.w\[7\]\[14\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
X_20593_ _01233_ _01218_ _01231_ VPWR VGND sg13g2_xnor2_1
X_22332_ _02908_ _02909_ _00480_ VPWR VGND sg13g2_nor2_1
X_23191__1497 VPWR VGND net1496 sg13g2_tiehi
XFILLER_118_952 VPWR VGND sg13g2_decap_8
X_22263_ net8 VPWR _02855_ VGND net7 _02854_ sg13g2_o21ai_1
XFILLER_117_451 VPWR VGND sg13g2_fill_2
X_21214_ net427 _03219_ net181 net225 _01831_ VPWR VGND sg13g2_nor4_1
X_22194_ _02784_ VPWR _02788_ VGND _02785_ _02786_ sg13g2_o21ai_1
XFILLER_132_432 VPWR VGND sg13g2_decap_8
XFILLER_104_134 VPWR VGND sg13g2_fill_2
XFILLER_105_668 VPWR VGND sg13g2_fill_1
X_21145_ _01762_ _01755_ _01760_ VPWR VGND sg13g2_xnor2_1
Xfanout510 net511 net510 VPWR VGND sg13g2_buf_1
Xfanout521 net522 net521 VPWR VGND sg13g2_buf_1
XFILLER_132_487 VPWR VGND sg13g2_decap_8
Xfanout532 net535 net532 VPWR VGND sg13g2_buf_1
X_21076_ net17 VPWR _01705_ VGND net15 _01704_ sg13g2_o21ai_1
Xfanout543 net548 net543 VPWR VGND sg13g2_buf_1
Xfanout554 net555 net554 VPWR VGND sg13g2_buf_1
Xfanout565 net566 net565 VPWR VGND sg13g2_buf_1
X_20027_ _11068_ net631 net87 VPWR VGND sg13g2_nand2_1
Xfanout576 net577 net576 VPWR VGND sg13g2_buf_1
Xfanout587 net588 net587 VPWR VGND sg13g2_buf_1
Xfanout598 u_LMS.x_r\[7\]\[3\] net598 VPWR VGND sg13g2_buf_1
XFILLER_46_427 VPWR VGND sg13g2_decap_8
XFILLER_132_21 VPWR VGND sg13g2_decap_8
X_11800_ VPWR _03221_ net596 VGND sg13g2_inv_1
XFILLER_73_268 VPWR VGND sg13g2_fill_1
X_12780_ _04143_ _04135_ _04142_ VPWR VGND sg13g2_xnor2_1
XFILLER_15_814 VPWR VGND sg13g2_decap_8
XFILLER_132_98 VPWR VGND sg13g2_decap_8
X_21978_ _02568_ _02571_ _02572_ VPWR VGND sg13g2_nor2_1
XFILLER_55_994 VPWR VGND sg13g2_decap_4
XFILLER_82_791 VPWR VGND sg13g2_fill_2
XFILLER_42_622 VPWR VGND sg13g2_decap_4
XFILLER_27_696 VPWR VGND sg13g2_decap_8
X_23717_ net1403 VGND VPWR _00779_ u_FIR.x\[6\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
X_20929_ VPWR _01569_ _01568_ VGND sg13g2_inv_1
X_14450_ _05750_ _05744_ _05747_ VPWR VGND sg13g2_nand2_1
XFILLER_25_85 VPWR VGND sg13g2_fill_1
X_23648_ net981 VGND VPWR _00710_ u_debug_unit.mon_w2_sync\[0\] clknet_leaf_52_clkA
+ sg13g2_dfrbpq_1
XFILLER_70_997 VPWR VGND sg13g2_decap_8
XFILLER_30_839 VPWR VGND sg13g2_fill_1
XFILLER_25_96 VPWR VGND sg13g2_fill_1
X_13401_ _03361_ net815 _04743_ VPWR VGND sg13g2_nor2_1
XFILLER_23_891 VPWR VGND sg13g2_decap_8
X_14381_ _05685_ _05678_ _05683_ VPWR VGND sg13g2_xnor2_1
X_23579_ net981 VGND VPWR _00641_ coeff_force_packed\[22\] clknet_leaf_53_clkA sg13g2_dfrbpq_1
X_16120_ _07360_ _07325_ _07358_ VPWR VGND sg13g2_xnor2_1
X_13332_ _04662_ VPWR _04676_ VGND _04658_ _04660_ sg13g2_o21ai_1
XFILLER_6_512 VPWR VGND sg13g2_decap_4
XFILLER_6_523 VPWR VGND sg13g2_fill_1
X_16051_ _07254_ VPWR _07292_ VGND _07249_ _07252_ sg13g2_o21ai_1
X_13263_ u_FIR.w\[6\]\[2\] net813 net742 _04609_ VPWR VGND sg13g2_nand3_1
XFILLER_109_974 VPWR VGND sg13g2_fill_1
XFILLER_6_567 VPWR VGND sg13g2_fill_1
X_15002_ VGND VPWR _06279_ _06278_ _06269_ sg13g2_or2_1
X_12214_ net724 net894 _03598_ VPWR VGND sg13g2_and2_1
XFILLER_124_933 VPWR VGND sg13g2_fill_1
X_23366__1236 VPWR VGND net1235 sg13g2_tiehi
X_13194_ _04542_ u_FIR.sum\[1\]\[7\] net405 VPWR VGND sg13g2_xnor2_1
XFILLER_68_1053 VPWR VGND sg13g2_decap_8
X_19810_ _10851_ VPWR _10870_ VGND _10855_ _10869_ sg13g2_o21ai_1
X_12145_ _00019_ VPWR _03555_ VGND u_spi_slave.tx_shift\[8\] _03386_ sg13g2_o21ai_1
XFILLER_29_1037 VPWR VGND sg13g2_fill_1
XFILLER_29_1059 VPWR VGND sg13g2_fill_2
XFILLER_111_627 VPWR VGND sg13g2_decap_8
X_19741_ _10804_ net2133 _10750_ _10805_ VPWR VGND sg13g2_a21o_1
X_16953_ _08109_ _08072_ _08074_ VPWR VGND sg13g2_xnor2_1
X_12076_ _03489_ net295 coeff_force_packed\[39\] _03412_ u_debug_unit.mon_w6_sync\[4\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_104_690 VPWR VGND sg13g2_fill_1
X_15904_ _07150_ u_FIR.sum\[6\]\[14\] net390 VPWR VGND sg13g2_nand2_1
X_19672_ VGND VPWR _10735_ _10736_ _10733_ _10729_ sg13g2_a21oi_2
XFILLER_2_56 VPWR VGND sg13g2_decap_8
X_16884_ _08040_ _08005_ _08039_ VPWR VGND sg13g2_xnor2_1
XFILLER_37_405 VPWR VGND sg13g2_fill_1
X_23699__1524 VPWR VGND net1523 sg13g2_tiehi
XFILLER_77_574 VPWR VGND sg13g2_fill_1
XFILLER_49_265 VPWR VGND sg13g2_fill_1
X_18623_ _09721_ net34 net35 _09722_ VPWR VGND sg13g2_a21o_1
X_15835_ net1003 VPWR _07084_ VGND net495 u_FIR.sum\[7\]\[11\] sg13g2_o21ai_1
XFILLER_92_555 VPWR VGND sg13g2_fill_2
XFILLER_18_652 VPWR VGND sg13g2_decap_8
X_18554_ _09664_ _09662_ _09663_ VPWR VGND sg13g2_nand2_1
XFILLER_64_268 VPWR VGND sg13g2_decap_8
X_15766_ VGND VPWR _06977_ _07007_ _07016_ _07006_ sg13g2_a21oi_1
X_12978_ _04312_ _04335_ _04336_ VPWR VGND sg13g2_nor2b_1
XFILLER_80_739 VPWR VGND sg13g2_fill_2
XFILLER_61_920 VPWR VGND sg13g2_decap_8
X_17505_ _08638_ net81 net686 net99 net684 VPWR VGND sg13g2_a22oi_1
XFILLER_61_931 VPWR VGND sg13g2_fill_1
XFILLER_45_482 VPWR VGND sg13g2_decap_8
X_14717_ _06005_ _06006_ _00146_ VPWR VGND sg13g2_nor2_1
X_18485_ VGND VPWR _09424_ net1669 _09595_ _09421_ sg13g2_a21oi_1
X_11929_ VPWR _03350_ u_LMS.w\[0\]\[10\] VGND sg13g2_inv_1
X_15697_ _06949_ net790 net803 VPWR VGND sg13g2_nand2_1
X_17436_ net365 VPWR _08573_ VGND u_LMS.w\[0\]\[8\] net383 sg13g2_o21ai_1
XFILLER_33_677 VPWR VGND sg13g2_fill_2
XFILLER_21_817 VPWR VGND sg13g2_fill_2
X_14648_ _05939_ _05933_ _05937_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_305 VPWR VGND sg13g2_decap_8
XFILLER_21_839 VPWR VGND sg13g2_fill_2
XFILLER_14_880 VPWR VGND sg13g2_fill_2
X_17367_ _08471_ _08517_ _08518_ VPWR VGND sg13g2_nor2b_1
XFILLER_32_198 VPWR VGND sg13g2_fill_1
X_14579_ net836 u_FIR.sum\[4\]\[5\] net774 _05872_ VPWR VGND sg13g2_nand3_1
X_19106_ _10193_ _10106_ _10127_ VPWR VGND sg13g2_xnor2_1
X_16318_ _07529_ VPWR _07552_ VGND net272 _07530_ sg13g2_o21ai_1
X_17298_ _08454_ _03350_ _08417_ VPWR VGND sg13g2_nand2_1
XFILLER_9_383 VPWR VGND sg13g2_fill_1
XFILLER_118_226 VPWR VGND sg13g2_fill_1
X_19037_ VGND VPWR _10120_ _10123_ _10124_ _10117_ sg13g2_a21oi_1
XFILLER_12_1041 VPWR VGND sg13g2_decap_8
X_16249_ _07456_ _07484_ _07485_ VPWR VGND sg13g2_nor2_1
XFILLER_127_771 VPWR VGND sg13g2_decap_8
XFILLER_56_0 VPWR VGND sg13g2_decap_8
XFILLER_127_782 VPWR VGND sg13g2_fill_1
XFILLER_127_793 VPWR VGND sg13g2_fill_1
XFILLER_115_966 VPWR VGND sg13g2_decap_8
XFILLER_99_187 VPWR VGND sg13g2_fill_1
X_23176__1523 VPWR VGND net1522 sg13g2_tiehi
XFILLER_99_198 VPWR VGND sg13g2_decap_8
XFILLER_114_498 VPWR VGND sg13g2_fill_1
X_19939_ _10978_ _10979_ _10980_ VPWR VGND sg13g2_nor2b_1
X_23204__1474 VPWR VGND net1473 sg13g2_tiehi
XFILLER_56_703 VPWR VGND sg13g2_fill_2
X_22950_ net464 u_spi_slave.rx_shift\[3\] _03575_ _00807_ VPWR VGND sg13g2_mux2_1
XFILLER_29_928 VPWR VGND sg13g2_fill_2
XFILLER_95_371 VPWR VGND sg13g2_fill_1
XFILLER_68_585 VPWR VGND sg13g2_fill_2
XFILLER_46_18 VPWR VGND sg13g2_fill_1
XFILLER_55_213 VPWR VGND sg13g2_fill_1
X_21901_ _02492_ VPWR _02495_ VGND _02493_ _02494_ sg13g2_o21ai_1
XFILLER_95_382 VPWR VGND sg13g2_decap_8
XFILLER_95_393 VPWR VGND sg13g2_fill_2
X_22881_ _03165_ _03168_ _00770_ VPWR VGND sg13g2_nor2_1
XFILLER_56_769 VPWR VGND sg13g2_fill_2
X_21832_ _02426_ net572 net185 _02425_ VPWR VGND sg13g2_and3_1
XFILLER_102_46 VPWR VGND sg13g2_decap_8
X_21763_ _02348_ _02356_ _02357_ VPWR VGND sg13g2_nor2b_1
X_23073__1097 VPWR VGND net1096 sg13g2_tiehi
X_20714_ _01352_ _01353_ _01354_ VPWR VGND sg13g2_nor2_1
X_23502_ net1405 VGND VPWR _00564_ u_LMS.count\[5\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
XFILLER_52_986 VPWR VGND sg13g2_decap_4
X_21694_ VGND VPWR _02298_ _02299_ _00452_ net932 sg13g2_a21oi_1
X_20645_ _01285_ net111 net614 net136 net612 VPWR VGND sg13g2_a22oi_1
X_23433_ net1049 VGND VPWR _00495_ u_LMS.x_r\[1\]\[0\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
X_23088__1075 VPWR VGND net1074 sg13g2_tiehi
XFILLER_20_850 VPWR VGND sg13g2_fill_1
XFILLER_109_215 VPWR VGND sg13g2_decap_8
X_23364_ net1237 VGND VPWR _00426_ u_LMS.w\[6\]\[20\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
XFILLER_109_226 VPWR VGND sg13g2_fill_2
X_20576_ _01216_ _01196_ _01214_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_883 VPWR VGND sg13g2_fill_2
XFILLER_125_708 VPWR VGND sg13g2_fill_1
XFILLER_109_259 VPWR VGND sg13g2_decap_8
X_22315_ VGND VPWR _02895_ _02896_ _00476_ net924 sg13g2_a21oi_1
X_23295_ net1307 VGND VPWR _00357_ u_LMS.w\[3\]\[20\] clknet_leaf_52_clkA sg13g2_dfrbpq_1
XFILLER_106_922 VPWR VGND sg13g2_decap_8
XFILLER_127_21 VPWR VGND sg13g2_decap_8
X_22246_ _02833_ _02837_ _02834_ _02840_ VPWR VGND _02839_ sg13g2_nand4_1
XFILLER_11_65 VPWR VGND sg13g2_decap_4
XFILLER_105_454 VPWR VGND sg13g2_decap_8
X_22177_ _02771_ _02702_ _02703_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_262 VPWR VGND sg13g2_decap_8
X_21128_ _01744_ _01742_ _01741_ _01745_ VPWR VGND sg13g2_a21o_1
Xfanout340 net345 net340 VPWR VGND sg13g2_buf_1
Xfanout351 net352 net351 VPWR VGND sg13g2_buf_1
Xfanout362 net367 net362 VPWR VGND sg13g2_buf_1
X_21059_ net73 u_LMS.w\[6\]\[20\] _01691_ VPWR VGND sg13g2_xor2_1
Xfanout373 net376 net373 VPWR VGND sg13g2_buf_1
X_13950_ _03380_ net402 _05269_ VPWR VGND sg13g2_and2_1
Xfanout384 net385 net384 VPWR VGND sg13g2_buf_1
XFILLER_101_682 VPWR VGND sg13g2_decap_8
Xfanout395 _06436_ net395 VPWR VGND sg13g2_buf_1
X_12901_ _04261_ _04253_ _04260_ VPWR VGND sg13g2_nand2_1
XFILLER_4_1039 VPWR VGND sg13g2_decap_8
XFILLER_101_693 VPWR VGND sg13g2_fill_2
X_13881_ _05204_ _05184_ _05203_ VPWR VGND sg13g2_xnor2_1
X_15620_ _06874_ _06867_ _06873_ VPWR VGND sg13g2_nand2_1
X_12832_ _04194_ _04190_ _04193_ VPWR VGND sg13g2_xnor2_1
XFILLER_74_577 VPWR VGND sg13g2_fill_2
XFILLER_28_972 VPWR VGND sg13g2_decap_8
XFILLER_28_983 VPWR VGND sg13g2_fill_2
X_15551_ net846 net792 u_FIR.sum\[6\]\[4\] _06807_ VPWR VGND sg13g2_a21o_1
XFILLER_43_942 VPWR VGND sg13g2_decap_8
X_12763_ _04125_ VPWR _04127_ VGND _04084_ _04086_ sg13g2_o21ai_1
X_14502_ _05796_ _05797_ _05798_ VPWR VGND sg13g2_nor2_1
X_18270_ _09378_ net2107 _09380_ VPWR VGND sg13g2_nor2_1
X_15482_ _06743_ _06733_ _06742_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_614 VPWR VGND sg13g2_fill_1
X_12694_ _04059_ _04019_ _04057_ VPWR VGND sg13g2_xnor2_1
XFILLER_70_783 VPWR VGND sg13g2_decap_8
XFILLER_70_794 VPWR VGND sg13g2_fill_2
X_17221_ _08165_ VPWR _08377_ VGND _08376_ _08375_ sg13g2_o21ai_1
XFILLER_30_636 VPWR VGND sg13g2_fill_2
X_14433_ _05734_ u_FIR.sum\[3\]\[16\] net399 VPWR VGND sg13g2_nand2_1
Xclkbuf_leaf_62_clkA clknet_4_0_0_clkA clknet_leaf_62_clkA VPWR VGND sg13g2_buf_8
XFILLER_52_83 VPWR VGND sg13g2_fill_2
X_23487__1459 VPWR VGND net1458 sg13g2_tiehi
XFILLER_122_1022 VPWR VGND sg13g2_decap_8
X_17152_ net710 net246 net709 _08308_ VPWR VGND net263 sg13g2_nand4_1
XFILLER_11_872 VPWR VGND sg13g2_fill_2
X_14364_ VGND VPWR _05637_ _05648_ _05668_ _05655_ sg13g2_a21oi_1
X_16103_ _07343_ _07335_ _07341_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_854 VPWR VGND sg13g2_decap_4
XFILLER_128_557 VPWR VGND sg13g2_decap_4
X_13315_ _04660_ u_FIR.sum\[1\]\[10\] net405 VPWR VGND sg13g2_xnor2_1
X_17083_ _08239_ _08146_ _08147_ VPWR VGND sg13g2_xnor2_1
X_14295_ VGND VPWR _05565_ _05593_ _05601_ _05592_ sg13g2_a21oi_1
XFILLER_7_898 VPWR VGND sg13g2_decap_8
X_16034_ _07247_ _07239_ _07275_ VPWR VGND sg13g2_xor2_1
X_13246_ VGND VPWR _04591_ _04592_ _04593_ net416 sg13g2_a21oi_1
XFILLER_6_386 VPWR VGND sg13g2_decap_4
X_13177_ _04523_ _04524_ _04525_ VPWR VGND sg13g2_and2_1
XFILLER_112_914 VPWR VGND sg13g2_decap_8
XFILLER_123_262 VPWR VGND sg13g2_decap_4
XFILLER_96_113 VPWR VGND sg13g2_decap_8
XFILLER_69_327 VPWR VGND sg13g2_decap_4
XFILLER_111_424 VPWR VGND sg13g2_decap_8
X_12128_ _03538_ u_spi_slave.tx_shift\[9\] _03392_ VPWR VGND sg13g2_nand2_1
X_17985_ _09114_ net303 u_LMS.w\[1\]\[16\] coeff_force_packed\[11\] net557 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_96_146 VPWR VGND sg13g2_decap_8
XFILLER_111_468 VPWR VGND sg13g2_decap_8
X_19724_ _10788_ _10787_ _10762_ VPWR VGND sg13g2_nand2b_1
X_16936_ VGND VPWR _08090_ _08091_ _08092_ _08087_ sg13g2_a21oi_1
X_12059_ _03473_ net296 coeff_force_packed\[12\] _03410_ u_debug_unit.mon_w4_sync\[5\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_77_80 VPWR VGND sg13g2_decap_8
XFILLER_96_179 VPWR VGND sg13g2_decap_8
XFILLER_78_883 VPWR VGND sg13g2_decap_8
X_19655_ _10719_ _10669_ _10670_ VPWR VGND sg13g2_xnor2_1
X_16867_ VPWR _08023_ _08022_ VGND sg13g2_inv_1
XFILLER_38_758 VPWR VGND sg13g2_fill_1
X_18606_ net70 u_LMS.w\[2\]\[20\] _09708_ VPWR VGND sg13g2_xor2_1
X_15818_ _07066_ net275 _07067_ VPWR VGND sg13g2_xor2_1
XFILLER_25_408 VPWR VGND sg13g2_decap_8
XFILLER_19_972 VPWR VGND sg13g2_fill_1
X_19586_ _10650_ _10622_ _10623_ VPWR VGND sg13g2_xnor2_1
X_16798_ net914 net1658 net912 _07954_ VPWR VGND net2065 sg13g2_nand4_1
X_18537_ _09647_ u_LMS.w\[2\]\[13\] net1653 VPWR VGND sg13g2_xnor2_1
XFILLER_52_238 VPWR VGND sg13g2_decap_8
X_15749_ _07000_ u_FIR.sum\[6\]\[9\] net392 VPWR VGND sg13g2_xnor2_1
X_18468_ _09200_ VPWR _09578_ VGND _09243_ _09249_ sg13g2_o21ai_1
XFILLER_33_496 VPWR VGND sg13g2_fill_1
X_17419_ VGND VPWR net58 _08559_ _08560_ net42 sg13g2_a21oi_1
XFILLER_21_647 VPWR VGND sg13g2_fill_1
X_18399_ _09507_ _09505_ _09509_ VPWR VGND sg13g2_xor2_1
X_20430_ VGND VPWR _01087_ _01088_ _00399_ net935 sg13g2_a21oi_1
X_20361_ _00991_ u_LMS.w\[5\]\[9\] _01024_ VPWR VGND sg13g2_xor2_1
X_22100_ VPWR _02694_ _02693_ VGND sg13g2_inv_1
X_23084__1081 VPWR VGND net1080 sg13g2_tiehi
X_23080_ net1086 VGND VPWR _00142_ u_FIR.sum\[5\]\[4\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
X_20292_ _00951_ _00954_ _00955_ VPWR VGND sg13g2_nor2_1
X_22031_ _02616_ _02624_ _02625_ VPWR VGND sg13g2_nor2_1
XFILLER_102_402 VPWR VGND sg13g2_fill_2
XFILLER_0_529 VPWR VGND sg13g2_decap_8
XFILLER_103_969 VPWR VGND sg13g2_fill_2
XFILLER_69_850 VPWR VGND sg13g2_fill_2
XFILLER_75_308 VPWR VGND sg13g2_fill_1
XFILLER_130_799 VPWR VGND sg13g2_fill_2
XFILLER_68_382 VPWR VGND sg13g2_fill_2
X_22933_ VGND VPWR net325 _03196_ _00798_ _03195_ sg13g2_a21oi_1
XFILLER_28_224 VPWR VGND sg13g2_fill_1
XFILLER_84_875 VPWR VGND sg13g2_decap_8
X_22864_ _07930_ _03138_ _03156_ VPWR VGND sg13g2_nor2_1
XFILLER_71_547 VPWR VGND sg13g2_decap_8
X_21815_ _02407_ VPWR _02409_ VGND _03217_ net83 sg13g2_o21ai_1
X_22795_ VGND VPWR _03315_ net346 _00737_ _03115_ sg13g2_a21oi_1
XFILLER_25_975 VPWR VGND sg13g2_fill_2
X_21746_ _02340_ _02339_ _02335_ VPWR VGND sg13g2_nand2b_1
XFILLER_106_1039 VPWR VGND sg13g2_fill_1
XFILLER_8_607 VPWR VGND sg13g2_decap_8
X_21677_ net12 VPWR _02286_ VGND net11 _02285_ sg13g2_o21ai_1
X_23416_ net1100 VGND VPWR _00478_ u_LMS.w\[8\]\[3\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
X_20628_ VPWR _01268_ _01267_ VGND sg13g2_inv_1
X_20559_ VPWR _01199_ _01198_ VGND sg13g2_inv_1
X_23347_ net1254 VGND VPWR _00409_ u_LMS.w\[5\]\[3\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
X_13100_ _04450_ net744 net867 VPWR VGND sg13g2_nand2_1
XFILLER_4_835 VPWR VGND sg13g2_decap_8
X_14080_ _05391_ _05388_ _05392_ VPWR VGND sg13g2_xor2_1
X_23278_ net1337 VGND VPWR _00340_ u_LMS.w\[2\]\[3\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
XFILLER_98_46 VPWR VGND sg13g2_decap_8
X_13031_ _04384_ _04369_ _04381_ _04383_ VPWR VGND sg13g2_and3_1
X_22229_ _02822_ VPWR _02823_ VGND _02821_ _02758_ sg13g2_o21ai_1
XFILLER_79_625 VPWR VGND sg13g2_decap_8
XFILLER_78_102 VPWR VGND sg13g2_fill_1
XFILLER_3_378 VPWR VGND sg13g2_fill_2
XFILLER_121_733 VPWR VGND sg13g2_fill_2
XFILLER_78_146 VPWR VGND sg13g2_fill_2
XFILLER_66_308 VPWR VGND sg13g2_decap_8
X_17770_ _08903_ _08880_ _08881_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_788 VPWR VGND sg13g2_decap_8
X_14982_ net902 net782 u_FIR.sum\[5\]\[0\] _06261_ VPWR VGND sg13g2_a21o_1
XFILLER_93_105 VPWR VGND sg13g2_decap_8
XFILLER_120_265 VPWR VGND sg13g2_decap_8
Xfanout170 net174 net170 VPWR VGND sg13g2_buf_1
Xfanout181 net1661 net181 VPWR VGND sg13g2_buf_1
Xfanout192 net193 net192 VPWR VGND sg13g2_buf_2
X_16721_ net1030 VPWR _07881_ VGND net529 net722 sg13g2_o21ai_1
X_13933_ _05253_ _05252_ net281 VPWR VGND sg13g2_nand2b_1
XFILLER_47_72 VPWR VGND sg13g2_fill_1
X_19440_ _10504_ _10501_ _10503_ VPWR VGND sg13g2_nand2_1
X_16652_ u_LMS.w\[6\]\[20\] u_LMS.w\[6\]\[19\] u_LMS.w\[6\]\[18\] _07829_ VPWR VGND
+ sg13g2_nor3_1
X_13864_ _05187_ _05158_ _05160_ _05123_ net749 VPWR VGND sg13g2_a22oi_1
XFILLER_74_374 VPWR VGND sg13g2_decap_8
X_15603_ _06856_ _06857_ _00181_ VPWR VGND sg13g2_nor2_1
XFILLER_34_227 VPWR VGND sg13g2_decap_8
X_19371_ net424 net225 _10435_ VPWR VGND sg13g2_nor2_1
X_12815_ net857 net729 _04175_ _04177_ VPWR VGND sg13g2_a21o_1
X_16583_ VGND VPWR u_LMS.w\[3\]\[14\] _07773_ _07779_ _07774_ sg13g2_a21oi_1
X_13795_ VGND VPWR _05084_ _05098_ _05120_ _05107_ sg13g2_a21oi_1
X_18322_ _09391_ _09431_ _09432_ VPWR VGND sg13g2_nor2_1
X_15534_ _06791_ _06770_ _06790_ VPWR VGND sg13g2_nand2_1
XFILLER_43_772 VPWR VGND sg13g2_fill_1
X_12746_ _04110_ _04101_ _04108_ VPWR VGND sg13g2_xnor2_1
XFILLER_15_474 VPWR VGND sg13g2_decap_8
XFILLER_72_1027 VPWR VGND sg13g2_decap_8
XFILLER_97_7 VPWR VGND sg13g2_fill_2
XFILLER_15_496 VPWR VGND sg13g2_decap_4
X_18253_ _03265_ _03266_ net98 _09363_ VGND VPWR net90 sg13g2_nor4_2
X_15465_ _06726_ _06722_ _06727_ VPWR VGND sg13g2_xor2_1
X_12677_ _04043_ _04034_ _04041_ VPWR VGND sg13g2_xnor2_1
X_17204_ _08360_ _08355_ _08359_ VPWR VGND sg13g2_xnor2_1
X_14416_ _05716_ net277 _05718_ VPWR VGND sg13g2_xor2_1
XFILLER_128_310 VPWR VGND sg13g2_decap_4
X_18184_ net421 net420 _08068_ net200 _09294_ VPWR VGND sg13g2_nor4_1
XFILLER_129_844 VPWR VGND sg13g2_fill_1
X_15396_ _06660_ _06635_ _06662_ VPWR VGND sg13g2_xor2_1
XFILLER_11_691 VPWR VGND sg13g2_decap_8
X_17135_ _08289_ _08287_ _08291_ VPWR VGND sg13g2_xor2_1
X_14347_ _05651_ net278 _05652_ VPWR VGND sg13g2_xor2_1
XFILLER_7_673 VPWR VGND sg13g2_decap_4
XFILLER_116_516 VPWR VGND sg13g2_fill_2
X_17066_ _03281_ net417 net97 _08222_ VPWR VGND sg13g2_nor3_1
X_14278_ _05585_ u_FIR.sum\[3\]\[10\] net401 VPWR VGND sg13g2_nand2_1
X_23046__1138 VPWR VGND net1137 sg13g2_tiehi
X_16017_ _07258_ net796 net872 VPWR VGND sg13g2_nand2_1
X_13229_ _04558_ _04575_ _04576_ VPWR VGND sg13g2_nor2b_1
XFILLER_98_912 VPWR VGND sg13g2_decap_4
XFILLER_131_519 VPWR VGND sg13g2_decap_8
XFILLER_98_945 VPWR VGND sg13g2_decap_4
X_17968_ VGND VPWR _09099_ _09100_ _00303_ net923 sg13g2_a21oi_1
XFILLER_38_500 VPWR VGND sg13g2_fill_1
XFILLER_112_799 VPWR VGND sg13g2_fill_2
XFILLER_66_820 VPWR VGND sg13g2_decap_8
XFILLER_38_511 VPWR VGND sg13g2_fill_1
X_19707_ u_LMS.w\[4\]\[2\] net256 net651 _10771_ VPWR VGND sg13g2_nand3_1
XFILLER_84_138 VPWR VGND sg13g2_decap_8
XFILLER_19_0 VPWR VGND sg13g2_decap_8
X_16919_ _08071_ VPWR _08075_ VGND _08072_ _08073_ sg13g2_o21ai_1
XFILLER_66_853 VPWR VGND sg13g2_fill_1
X_17899_ _09032_ _09031_ _08996_ VPWR VGND sg13g2_nand2b_1
X_19638_ _10700_ VPWR _10702_ VGND net222 _10701_ sg13g2_o21ai_1
XFILLER_93_694 VPWR VGND sg13g2_fill_2
XFILLER_65_396 VPWR VGND sg13g2_decap_8
XFILLER_129_1028 VPWR VGND sg13g2_decap_8
X_19569_ _10633_ _10628_ _10631_ VPWR VGND sg13g2_xnor2_1
X_21600_ _02217_ _03302_ _02170_ VPWR VGND sg13g2_nand2_1
X_22580_ _03051_ u_LMS.count\[28\] _03050_ VPWR VGND sg13g2_xnor2_1
XFILLER_22_934 VPWR VGND sg13g2_fill_2
XFILLER_21_411 VPWR VGND sg13g2_decap_8
X_21531_ _01816_ _02147_ _01813_ _02148_ VPWR VGND sg13g2_nand3_1
XFILLER_21_433 VPWR VGND sg13g2_fill_1
X_23361__1241 VPWR VGND net1240 sg13g2_tiehi
XFILLER_22_978 VPWR VGND sg13g2_decap_8
X_21462_ _02077_ _02078_ _02079_ VPWR VGND sg13g2_nor2_1
X_20413_ _01076_ net315 u_LMS.w\[5\]\[12\] coeff_force_packed\[35\] net564 VPWR VGND
+ sg13g2_a22oi_1
X_23201_ net1478 VGND VPWR _00263_ u_FIR.w\[6\]\[4\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
X_21393_ _02010_ _01995_ _02009_ VPWR VGND sg13g2_xnor2_1
XFILLER_107_527 VPWR VGND sg13g2_decap_8
X_20344_ _01003_ VPWR _01007_ VGND _01004_ _01005_ sg13g2_o21ai_1
X_23132_ net1591 VGND VPWR _00194_ u_FIR.sum\[7\]\[18\] clknet_leaf_43_clkA sg13g2_dfrbpq_1
XFILLER_49_1018 VPWR VGND sg13g2_fill_1
X_23063_ net1111 VGND VPWR _00125_ u_FIR.sum\[4\]\[6\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
XFILLER_89_912 VPWR VGND sg13g2_decap_8
X_20275_ VPWR _00938_ _00937_ VGND sg13g2_inv_1
XFILLER_115_560 VPWR VGND sg13g2_fill_1
X_22014_ _02608_ _02528_ _02533_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_337 VPWR VGND sg13g2_decap_8
XFILLER_49_809 VPWR VGND sg13g2_fill_2
XFILLER_130_541 VPWR VGND sg13g2_decap_8
XFILLER_76_606 VPWR VGND sg13g2_fill_2
XFILLER_56_352 VPWR VGND sg13g2_fill_1
X_22916_ VGND VPWR net554 _03205_ _00787_ _03186_ sg13g2_a21oi_1
XFILLER_17_20 VPWR VGND sg13g2_fill_2
XFILLER_83_160 VPWR VGND sg13g2_fill_1
XFILLER_17_31 VPWR VGND sg13g2_fill_2
XFILLER_84_694 VPWR VGND sg13g2_decap_4
XFILLER_17_42 VPWR VGND sg13g2_decap_4
XFILLER_83_182 VPWR VGND sg13g2_fill_2
XFILLER_17_64 VPWR VGND sg13g2_fill_2
X_23286__1323 VPWR VGND net1322 sg13g2_tiehi
X_22847_ VGND VPWR net299 _03143_ _00759_ _03144_ sg13g2_a21oi_1
XFILLER_17_97 VPWR VGND sg13g2_fill_1
X_12600_ VGND VPWR net531 _03967_ _00067_ _03968_ sg13g2_a21oi_1
X_13580_ _04911_ _04871_ _04909_ VPWR VGND sg13g2_xnor2_1
XFILLER_71_388 VPWR VGND sg13g2_decap_8
X_22778_ u_debug_unit.mon_w4_sync\[5\] net340 _03107_ VPWR VGND sg13g2_nor2_1
X_12531_ _03905_ _03890_ _03904_ VPWR VGND sg13g2_nand2b_1
X_21729_ _02326_ _02207_ _02209_ VPWR VGND sg13g2_xnor2_1
XFILLER_12_455 VPWR VGND sg13g2_fill_1
XFILLER_12_466 VPWR VGND sg13g2_fill_1
X_15250_ _06512_ _06519_ _06520_ VPWR VGND sg13g2_nor2b_1
XFILLER_71_1060 VPWR VGND sg13g2_fill_1
X_12462_ _03836_ _03837_ _03838_ VPWR VGND sg13g2_and2_1
X_14201_ _05510_ u_FIR.sum\[3\]\[8\] net401 VPWR VGND sg13g2_xnor2_1
XFILLER_8_459 VPWR VGND sg13g2_decap_4
XFILLER_123_0 VPWR VGND sg13g2_decap_8
XFILLER_126_803 VPWR VGND sg13g2_decap_8
X_15181_ VGND VPWR _06434_ _06440_ _06452_ _06439_ sg13g2_a21oi_1
X_12393_ _03767_ VPWR _03771_ VGND _03768_ _03769_ sg13g2_o21ai_1
XFILLER_126_825 VPWR VGND sg13g2_decap_4
X_14132_ net1005 VPWR _05443_ VGND net506 u_FIR.sum\[4\]\[6\] sg13g2_o21ai_1
XFILLER_98_208 VPWR VGND sg13g2_fill_1
X_18940_ _10027_ _03251_ _09997_ VPWR VGND sg13g2_xnor2_1
X_14063_ _05375_ net904 net759 net892 net760 VPWR VGND sg13g2_a22oi_1
XFILLER_113_519 VPWR VGND sg13g2_decap_8
XFILLER_4_687 VPWR VGND sg13g2_fill_1
X_13014_ _04368_ net745 net908 VPWR VGND sg13g2_nand2_1
X_18871_ VGND VPWR _09949_ _09950_ _09958_ _09957_ sg13g2_a21oi_1
XFILLER_121_541 VPWR VGND sg13g2_decap_8
X_23042__1144 VPWR VGND net1143 sg13g2_tiehi
X_17822_ _08955_ _08882_ _08883_ VPWR VGND sg13g2_xnor2_1
XFILLER_67_628 VPWR VGND sg13g2_decap_8
XFILLER_0_893 VPWR VGND sg13g2_decap_4
XFILLER_94_436 VPWR VGND sg13g2_decap_4
XFILLER_48_842 VPWR VGND sg13g2_decap_8
XFILLER_12_7 VPWR VGND sg13g2_decap_8
X_17753_ net701 net187 net699 _08886_ VPWR VGND net223 sg13g2_nand4_1
X_14965_ _06237_ _06245_ _06246_ VPWR VGND sg13g2_nor2b_1
X_16704_ u_LMS.w\[8\]\[19\] u_LMS.w\[8\]\[18\] u_LMS.w\[8\]\[20\] _07867_ VPWR VGND
+ sg13g2_nand3_1
X_13916_ _05190_ _05236_ _05237_ VPWR VGND sg13g2_nor2_1
XFILLER_75_672 VPWR VGND sg13g2_decap_8
X_17684_ _08817_ net82 net700 net109 net698 VPWR VGND sg13g2_a22oi_1
X_14896_ VGND VPWR _06152_ _06172_ _06180_ _06171_ sg13g2_a21oi_1
XFILLER_90_620 VPWR VGND sg13g2_fill_2
XFILLER_74_171 VPWR VGND sg13g2_fill_2
XFILLER_62_311 VPWR VGND sg13g2_decap_8
X_19423_ _10487_ _10484_ _10485_ VPWR VGND sg13g2_xnor2_1
X_16635_ VGND VPWR net518 _07816_ _00253_ _07817_ sg13g2_a21oi_1
X_13847_ _05171_ _05135_ _05169_ VPWR VGND sg13g2_xnor2_1
XFILLER_16_761 VPWR VGND sg13g2_fill_1
X_19354_ _10418_ net642 net153 VPWR VGND sg13g2_nand2_1
X_16566_ net980 VPWR _07766_ VGND net485 net776 sg13g2_o21ai_1
X_13778_ _05104_ _05100_ _05103_ VPWR VGND sg13g2_xnor2_1
X_18305_ _09414_ VPWR _09415_ VGND _09400_ _09401_ sg13g2_o21ai_1
X_15517_ net861 net791 u_FIR.sum\[6\]\[3\] _06774_ VPWR VGND sg13g2_a21o_1
XFILLER_31_742 VPWR VGND sg13g2_fill_1
X_19285_ _10346_ _10348_ _10349_ VPWR VGND sg13g2_nor2_1
X_12729_ _04093_ _04058_ _04060_ VPWR VGND sg13g2_nand2_1
X_16497_ net974 VPWR _07716_ VGND net482 net802 sg13g2_o21ai_1
XFILLER_30_252 VPWR VGND sg13g2_decap_8
X_18236_ net682 net145 net680 _09346_ VPWR VGND net90 sg13g2_nand4_1
X_15448_ _06711_ _06691_ _06710_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_663 VPWR VGND sg13g2_decap_8
X_18167_ _09270_ _09276_ _09277_ VPWR VGND sg13g2_nor2b_1
X_15379_ _06640_ _06642_ _06645_ VPWR VGND sg13g2_nor2_1
XFILLER_128_173 VPWR VGND sg13g2_fill_2
X_17118_ _08274_ _08196_ _08207_ VPWR VGND sg13g2_xnor2_1
X_18098_ _09205_ _09207_ _09208_ VPWR VGND sg13g2_nor2_1
Xrebuffer2104 _09306_ net2103 VPWR VGND sg13g2_buf_1
Xrebuffer2115 net138 net2114 VPWR VGND sg13g2_buf_2
Xrebuffer2126 _00971_ net2125 VPWR VGND sg13g2_buf_2
X_17049_ _08205_ net2202 _08198_ VPWR VGND sg13g2_nand2b_1
Xrebuffer2137 _07967_ net2136 VPWR VGND sg13g2_buf_2
XFILLER_89_219 VPWR VGND sg13g2_decap_8
XFILLER_131_305 VPWR VGND sg13g2_fill_1
Xrebuffer2148 net2148 net2147 VPWR VGND sg13g2_buf_1
Xrebuffer2159 net2159 net2158 VPWR VGND sg13g2_buf_1
X_20060_ _11101_ net630 net172 VPWR VGND sg13g2_nand2_1
Xfanout906 net908 net906 VPWR VGND sg13g2_buf_1
Xfanout917 net918 net917 VPWR VGND sg13g2_buf_1
Xfanout928 net929 net928 VPWR VGND sg13g2_buf_1
Xfanout939 net942 net939 VPWR VGND sg13g2_buf_1
XFILLER_86_926 VPWR VGND sg13g2_decap_4
XFILLER_85_425 VPWR VGND sg13g2_decap_8
XFILLER_112_596 VPWR VGND sg13g2_fill_2
XFILLER_85_436 VPWR VGND sg13g2_fill_1
X_23379__1212 VPWR VGND net1211 sg13g2_tiehi
XFILLER_57_149 VPWR VGND sg13g2_decap_8
X_23750_ net1370 VGND VPWR _00812_ u_LMS.x\[1\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
X_20962_ _01601_ _01600_ _01602_ VPWR VGND sg13g2_nor2b_1
XFILLER_53_300 VPWR VGND sg13g2_fill_1
XFILLER_38_374 VPWR VGND sg13g2_decap_4
XFILLER_0_1020 VPWR VGND sg13g2_decap_8
X_22701_ _03071_ _00022_ _00023_ VPWR VGND sg13g2_nand2b_1
XFILLER_54_867 VPWR VGND sg13g2_fill_1
X_23681_ net1016 VGND VPWR _00743_ u_debug_unit.mon_w6_sync\[5\] clknet_leaf_19_clkA
+ sg13g2_dfrbpq_1
X_20893_ _01527_ _01532_ _01402_ _01533_ VPWR VGND sg13g2_nand3_1
XFILLER_13_208 VPWR VGND sg13g2_fill_1
X_22632_ net466 coeff_force_packed\[10\] _03062_ _00627_ VPWR VGND sg13g2_mux2_1
XFILLER_22_720 VPWR VGND sg13g2_decap_8
X_22563_ _03040_ u_LMS.count\[22\] _03039_ VPWR VGND sg13g2_xnor2_1
XFILLER_10_915 VPWR VGND sg13g2_fill_2
XFILLER_70_39 VPWR VGND sg13g2_fill_1
X_21514_ VPWR _02131_ _02130_ VGND sg13g2_inv_1
X_22494_ VGND VPWR net441 _03221_ _00555_ _02996_ sg13g2_a21oi_1
XFILLER_6_919 VPWR VGND sg13g2_decap_4
XFILLER_119_140 VPWR VGND sg13g2_fill_2
X_21445_ _02062_ _02040_ _02061_ VPWR VGND sg13g2_nand2_1
XFILLER_119_33 VPWR VGND sg13g2_decap_4
X_21376_ _01991_ _01992_ _01993_ VPWR VGND sg13g2_nor2b_1
X_20327_ _03311_ _00989_ _00990_ VPWR VGND sg13g2_nor2_1
X_23115_ net1616 VGND VPWR _00177_ u_FIR.sum\[7\]\[1\] clknet_leaf_47_clkA sg13g2_dfrbpq_1
XFILLER_0_112 VPWR VGND sg13g2_decap_8
X_20258_ _00921_ net198 _00920_ VPWR VGND sg13g2_nand2_1
X_23046_ net1137 VGND VPWR _00108_ u_FIR.sum\[3\]\[8\] clknet_leaf_33_clkA sg13g2_dfrbpq_1
XFILLER_88_230 VPWR VGND sg13g2_decap_8
XFILLER_103_541 VPWR VGND sg13g2_fill_2
XFILLER_103_563 VPWR VGND sg13g2_fill_1
XFILLER_103_585 VPWR VGND sg13g2_decap_4
X_20189_ _00852_ _00849_ _00851_ VPWR VGND sg13g2_nand2_1
XFILLER_77_948 VPWR VGND sg13g2_decap_8
XFILLER_62_1059 VPWR VGND sg13g2_fill_2
XFILLER_130_382 VPWR VGND sg13g2_decap_8
XFILLER_130_393 VPWR VGND sg13g2_fill_1
XFILLER_28_52 VPWR VGND sg13g2_fill_1
X_14750_ _06039_ _06009_ _06037_ VPWR VGND sg13g2_xnor2_1
XFILLER_63_119 VPWR VGND sg13g2_decap_8
XFILLER_29_363 VPWR VGND sg13g2_fill_2
X_11962_ VPWR _03383_ u_spi_slave.tx_shift\[14\] VGND sg13g2_inv_1
XFILLER_45_834 VPWR VGND sg13g2_fill_1
XFILLER_28_96 VPWR VGND sg13g2_fill_1
XFILLER_17_536 VPWR VGND sg13g2_fill_2
X_13701_ _05029_ _05028_ _04987_ VPWR VGND sg13g2_nand2b_1
X_14681_ _05971_ _05935_ _05938_ VPWR VGND sg13g2_nand2_1
X_11893_ VPWR _03314_ u_LMS.w\[5\]\[5\] VGND sg13g2_inv_1
X_16420_ net270 _07649_ _07650_ VPWR VGND sg13g2_nor2_1
X_13632_ _04955_ _04958_ _04961_ VPWR VGND sg13g2_nor2_1
XFILLER_72_686 VPWR VGND sg13g2_decap_4
X_16351_ _07560_ VPWR _07584_ VGND net272 _07562_ sg13g2_o21ai_1
XFILLER_44_84 VPWR VGND sg13g2_decap_4
X_13563_ _04894_ net753 net851 VPWR VGND sg13g2_nand2_1
XFILLER_13_764 VPWR VGND sg13g2_decap_8
X_15302_ VGND VPWR _06533_ _06562_ _06570_ _06561_ sg13g2_a21oi_1
XFILLER_8_201 VPWR VGND sg13g2_decap_8
X_19070_ VGND VPWR _10153_ _10156_ _10157_ _10155_ sg13g2_a21oi_1
X_12514_ _03887_ _03888_ _00061_ VPWR VGND sg13g2_nor2_1
XFILLER_9_735 VPWR VGND sg13g2_fill_1
X_16282_ VGND VPWR _07481_ _07509_ _07517_ _07508_ sg13g2_a21oi_1
X_13494_ VPWR _04828_ _04827_ VGND sg13g2_inv_1
XFILLER_100_90 VPWR VGND sg13g2_fill_1
X_18021_ VGND VPWR u_LMS.w\[1\]\[23\] net303 _09143_ _09122_ sg13g2_a21oi_1
X_15233_ _06503_ _06495_ _06502_ VPWR VGND sg13g2_xnor2_1
X_12445_ _03820_ _03821_ _00059_ VPWR VGND sg13g2_nor2_1
XFILLER_60_72 VPWR VGND sg13g2_decap_4
X_15164_ u_FIR.w\[2\]\[0\] net804 _06436_ VPWR VGND sg13g2_and2_1
X_12376_ _03754_ _03716_ _03753_ VPWR VGND sg13g2_nand2_1
X_14115_ _05426_ net766 net825 u_FIR.sum\[3\]\[6\] VPWR VGND sg13g2_and3_1
XFILLER_113_305 VPWR VGND sg13g2_fill_2
X_19972_ _11006_ _11011_ _11013_ VPWR VGND sg13g2_nor2_1
X_15095_ _06334_ _06368_ _06332_ _06369_ VPWR VGND sg13g2_nand3_1
XFILLER_5_56 VPWR VGND sg13g2_decap_8
XFILLER_113_316 VPWR VGND sg13g2_decap_4
XFILLER_107_880 VPWR VGND sg13g2_decap_8
XFILLER_99_539 VPWR VGND sg13g2_fill_1
X_18923_ _10007_ _10006_ _10010_ VPWR VGND sg13g2_xor2_1
X_14046_ _05359_ _05321_ _05357_ VPWR VGND sg13g2_xnor2_1
XFILLER_95_701 VPWR VGND sg13g2_fill_1
XFILLER_79_263 VPWR VGND sg13g2_decap_4
X_18854_ _09939_ VPWR _09941_ VGND _09935_ _09940_ sg13g2_o21ai_1
XFILLER_67_414 VPWR VGND sg13g2_decap_4
XFILLER_39_127 VPWR VGND sg13g2_fill_2
XFILLER_94_222 VPWR VGND sg13g2_fill_2
X_17805_ _08938_ _08914_ _08937_ VPWR VGND sg13g2_xnor2_1
XFILLER_39_138 VPWR VGND sg13g2_decap_8
XFILLER_95_767 VPWR VGND sg13g2_decap_4
XFILLER_39_149 VPWR VGND sg13g2_fill_1
X_18785_ _09865_ _09871_ _09872_ VPWR VGND sg13g2_nor2b_1
X_15997_ _07237_ VPWR _07238_ VGND _07230_ _07234_ sg13g2_o21ai_1
XFILLER_83_929 VPWR VGND sg13g2_fill_1
XFILLER_54_108 VPWR VGND sg13g2_decap_8
X_17736_ net700 net186 net698 _08869_ VPWR VGND net168 sg13g2_nand4_1
X_14948_ _06230_ _06220_ _06228_ VPWR VGND sg13g2_xnor2_1
XFILLER_54_119 VPWR VGND sg13g2_fill_1
XFILLER_63_631 VPWR VGND sg13g2_decap_8
X_17667_ _08800_ net696 net168 VPWR VGND sg13g2_nand2_1
X_14879_ _06164_ u_FIR.sum\[4\]\[13\] net396 VPWR VGND sg13g2_nand2_1
X_19406_ _10470_ net199 net639 net225 net642 VPWR VGND sg13g2_a22oi_1
XFILLER_91_995 VPWR VGND sg13g2_decap_8
X_16618_ VGND VPWR net516 _07803_ _00249_ _07804_ sg13g2_a21oi_1
XFILLER_50_314 VPWR VGND sg13g2_fill_2
X_17598_ _08731_ _08700_ _08730_ VPWR VGND sg13g2_nand2_1
XFILLER_51_848 VPWR VGND sg13g2_fill_1
X_19337_ _03243_ _03244_ net114 net96 _10401_ VPWR VGND sg13g2_nor4_1
X_16549_ u_LMS.w\[2\]\[24\] _07753_ _07754_ VPWR VGND sg13g2_nor2_1
XFILLER_50_369 VPWR VGND sg13g2_decap_8
XFILLER_86_0 VPWR VGND sg13g2_decap_8
X_19268_ _10336_ _10217_ _10219_ VPWR VGND sg13g2_xnor2_1
X_18219_ _09326_ VPWR _09329_ VGND net420 net195 sg13g2_o21ai_1
X_19199_ _10239_ _10281_ _10282_ VPWR VGND sg13g2_nor2b_1
XFILLER_117_622 VPWR VGND sg13g2_fill_2
X_21230_ _01847_ _01753_ _01762_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_493 VPWR VGND sg13g2_fill_1
X_21161_ _01778_ _01766_ _01777_ VPWR VGND sg13g2_xnor2_1
XFILLER_131_102 VPWR VGND sg13g2_decap_8
XFILLER_85_1059 VPWR VGND sg13g2_fill_2
X_20112_ _11153_ _11132_ _11152_ VPWR VGND sg13g2_xnor2_1
XFILLER_49_18 VPWR VGND sg13g2_fill_2
X_21092_ _01717_ _01600_ _01601_ VPWR VGND sg13g2_xnor2_1
Xfanout703 net704 net703 VPWR VGND sg13g2_buf_1
Xfanout714 net715 net714 VPWR VGND sg13g2_buf_1
XFILLER_59_904 VPWR VGND sg13g2_fill_1
XFILLER_131_157 VPWR VGND sg13g2_decap_8
Xfanout725 u_FIR.w\[8\]\[1\] net725 VPWR VGND sg13g2_buf_1
X_20043_ _11050_ _11049_ _11084_ VPWR VGND sg13g2_xor2_1
Xfanout736 net737 net736 VPWR VGND sg13g2_buf_1
XFILLER_113_872 VPWR VGND sg13g2_fill_1
Xfanout747 u_FIR.w\[6\]\[0\] net747 VPWR VGND sg13g2_buf_1
XFILLER_98_583 VPWR VGND sg13g2_fill_1
Xfanout758 net759 net758 VPWR VGND sg13g2_buf_1
XFILLER_58_425 VPWR VGND sg13g2_fill_1
Xfanout769 u_FIR.w\[3\]\[4\] net769 VPWR VGND sg13g2_buf_1
XFILLER_86_778 VPWR VGND sg13g2_fill_2
XFILLER_67_970 VPWR VGND sg13g2_decap_4
XFILLER_65_28 VPWR VGND sg13g2_decap_8
X_21994_ _02588_ _02563_ _02585_ VPWR VGND sg13g2_xnor2_1
X_23000__1207 VPWR VGND net1206 sg13g2_tiehi
X_23162__1547 VPWR VGND net1546 sg13g2_tiehi
XFILLER_82_940 VPWR VGND sg13g2_fill_1
X_23733_ net998 VGND VPWR _00795_ u_spi_slave.rd_toggle_q net1639 sg13g2_dfrbpq_1
XFILLER_38_193 VPWR VGND sg13g2_decap_8
X_20945_ _01585_ _01519_ _01521_ VPWR VGND sg13g2_xnor2_1
XFILLER_82_995 VPWR VGND sg13g2_decap_4
X_23664_ net1011 VGND VPWR _00726_ u_debug_unit.mon_w4_sync\[2\] clknet_leaf_38_clkA
+ sg13g2_dfrbpq_1
XFILLER_42_848 VPWR VGND sg13g2_decap_8
X_20876_ _01506_ VPWR _01516_ VGND _01514_ _01515_ sg13g2_o21ai_1
XFILLER_53_196 VPWR VGND sg13g2_fill_1
X_22615_ net464 sys_enable_bus\[4\] _03060_ _00612_ VPWR VGND sg13g2_mux2_1
X_23595_ net1017 VGND VPWR _00657_ coeff_force_packed\[36\] clknet_leaf_20_clkA sg13g2_dfrbpq_1
XFILLER_14_32 VPWR VGND sg13g2_decap_8
XFILLER_10_701 VPWR VGND sg13g2_fill_1
X_22546_ net916 _03028_ _03029_ _00574_ VPWR VGND sg13g2_nor3_1
XFILLER_14_76 VPWR VGND sg13g2_fill_1
X_22477_ net960 VPWR _02988_ VGND net446 net597 sg13g2_o21ai_1
X_12230_ net907 net722 _03598_ _03613_ VPWR VGND sg13g2_a21o_1
X_21428_ _02022_ VPWR _02045_ VGND _03226_ net160 sg13g2_o21ai_1
XFILLER_107_132 VPWR VGND sg13g2_decap_8
XFILLER_107_143 VPWR VGND sg13g2_fill_2
XFILLER_108_677 VPWR VGND sg13g2_fill_1
XFILLER_107_154 VPWR VGND sg13g2_fill_2
X_12161_ _03567_ _03568_ _03566_ _03570_ VPWR VGND _03569_ sg13g2_nand4_1
XFILLER_123_614 VPWR VGND sg13g2_fill_2
X_21359_ _01899_ _01897_ _01976_ VPWR VGND sg13g2_xor2_1
XFILLER_123_636 VPWR VGND sg13g2_decap_8
X_12092_ coeff_force_packed\[31\] net287 _03504_ VPWR VGND sg13g2_and2_1
XFILLER_123_669 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_19_clkA clknet_4_9_0_clkA clknet_leaf_19_clkA VPWR VGND sg13g2_buf_8
X_23029_ net1162 VGND VPWR _00091_ u_FIR.sum\[2\]\[10\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
X_15920_ VGND VPWR _07148_ _07158_ _07165_ _07157_ sg13g2_a21oi_1
XFILLER_2_999 VPWR VGND sg13g2_decap_8
XFILLER_76_211 VPWR VGND sg13g2_decap_4
X_15851_ VPWR _07099_ _07098_ VGND sg13g2_inv_1
XFILLER_7_1059 VPWR VGND sg13g2_fill_2
XFILLER_77_767 VPWR VGND sg13g2_fill_1
XFILLER_92_715 VPWR VGND sg13g2_fill_2
X_14802_ _06064_ VPWR _06089_ VGND net269 _06065_ sg13g2_o21ai_1
X_18570_ u_LMS.w\[2\]\[24\] net69 _09675_ _09680_ VPWR VGND sg13g2_or3_1
X_15782_ _07032_ _07023_ _07030_ VPWR VGND sg13g2_xnor2_1
X_12994_ _04350_ _04339_ _04351_ VPWR VGND sg13g2_xor2_1
X_17521_ _08654_ net686 net147 VPWR VGND sg13g2_nand2_1
X_14733_ VPWR _06022_ _06021_ VGND sg13g2_inv_1
X_11945_ VPWR _03366_ net761 VGND sg13g2_inv_1
XFILLER_44_141 VPWR VGND sg13g2_decap_8
XFILLER_33_804 VPWR VGND sg13g2_decap_8
XFILLER_60_601 VPWR VGND sg13g2_decap_8
X_17452_ _08585_ net166 net687 net177 net684 VPWR VGND sg13g2_a22oi_1
X_14664_ _05954_ _05951_ _05955_ VPWR VGND sg13g2_nor2b_1
X_11876_ VPWR _03297_ u_LMS.w\[8\]\[12\] VGND sg13g2_inv_1
X_16403_ _07634_ _07612_ _07632_ VPWR VGND sg13g2_xnor2_1
XFILLER_44_196 VPWR VGND sg13g2_fill_2
X_13615_ _04943_ _04944_ _04945_ VPWR VGND sg13g2_nor2_1
X_17383_ _08531_ _08475_ _08530_ VPWR VGND sg13g2_nand2_1
X_14595_ net993 VPWR _05888_ VGND net491 u_FIR.sum\[5\]\[5\] sg13g2_o21ai_1
XFILLER_9_510 VPWR VGND sg13g2_decap_4
XFILLER_13_561 VPWR VGND sg13g2_fill_1
X_19122_ _10209_ _03332_ _10196_ VPWR VGND sg13g2_xnor2_1
X_16334_ _07568_ _07567_ _07534_ VPWR VGND sg13g2_nand2b_1
X_13546_ _04878_ _04869_ _04876_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_909 VPWR VGND sg13g2_fill_1
XFILLER_71_82 VPWR VGND sg13g2_fill_1
XFILLER_71_93 VPWR VGND sg13g2_decap_8
X_19053_ _10039_ VPWR _10140_ VGND _10138_ _10137_ sg13g2_o21ai_1
X_16265_ _07501_ u_FIR.sum\[7\]\[10\] net386 VPWR VGND sg13g2_nand2_1
X_13477_ net1022 VPWR _04813_ VGND net516 u_FIR.sum\[3\]\[0\] sg13g2_o21ai_1
X_18004_ _09129_ _09073_ _09128_ VPWR VGND sg13g2_xnor2_1
X_15216_ _06446_ _06448_ _06486_ _06487_ VPWR VGND sg13g2_or3_1
X_12428_ _03805_ net827 _03804_ VPWR VGND sg13g2_nand2_1
X_16196_ _07432_ _07404_ _07434_ VPWR VGND sg13g2_xor2_1
XFILLER_126_441 VPWR VGND sg13g2_decap_4
X_15147_ net875 _06418_ net776 _06419_ VPWR VGND sg13g2_nand3_1
X_12359_ _03738_ _03731_ _03736_ VPWR VGND sg13g2_xnor2_1
XFILLER_114_625 VPWR VGND sg13g2_fill_1
XFILLER_102_809 VPWR VGND sg13g2_decap_8
X_19955_ _10996_ _10988_ _10994_ VPWR VGND sg13g2_xnor2_1
X_15078_ _06350_ _06343_ _06352_ VPWR VGND sg13g2_xor2_1
XFILLER_99_358 VPWR VGND sg13g2_decap_8
XFILLER_99_369 VPWR VGND sg13g2_fill_2
X_18906_ _09991_ _09992_ _09993_ VPWR VGND sg13g2_nor2_1
X_14029_ VGND VPWR _05311_ _05325_ _05342_ _05324_ sg13g2_a21oi_1
X_19886_ _10928_ _10929_ _00392_ VPWR VGND sg13g2_nor2_1
X_23273__1348 VPWR VGND net1347 sg13g2_tiehi
XFILLER_95_520 VPWR VGND sg13g2_fill_1
XFILLER_122_680 VPWR VGND sg13g2_decap_8
XFILLER_132_1024 VPWR VGND sg13g2_decap_8
XFILLER_56_907 VPWR VGND sg13g2_decap_4
X_18837_ _09924_ _09920_ _09923_ VPWR VGND sg13g2_nand2_1
XFILLER_56_929 VPWR VGND sg13g2_decap_8
XFILLER_110_886 VPWR VGND sg13g2_decap_8
XFILLER_82_203 VPWR VGND sg13g2_decap_4
X_18768_ _03254_ net98 _09855_ VPWR VGND sg13g2_nor2_1
X_17719_ VGND VPWR _08844_ _08845_ _08852_ _08847_ sg13g2_a21oi_1
X_18699_ _09768_ VPWR _09786_ VGND _09765_ _09766_ sg13g2_o21ai_1
XFILLER_35_152 VPWR VGND sg13g2_fill_2
X_20730_ _01370_ _01367_ _01369_ VPWR VGND sg13g2_xnor2_1
XFILLER_50_111 VPWR VGND sg13g2_decap_8
XFILLER_23_358 VPWR VGND sg13g2_fill_2
X_20661_ VGND VPWR _01298_ _01300_ _01301_ _01271_ sg13g2_a21oi_1
XFILLER_52_1003 VPWR VGND sg13g2_fill_2
X_22400_ VGND VPWR net431 _03269_ _00508_ _02949_ sg13g2_a21oi_1
X_20592_ _01232_ _01218_ _01231_ VPWR VGND sg13g2_nand2_1
X_23380_ net1208 VGND VPWR _00442_ u_LMS.w\[7\]\[13\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
XFILLER_109_419 VPWR VGND sg13g2_fill_1
X_22331_ net357 VPWR _02909_ VGND u_LMS.w\[8\]\[5\] net374 sg13g2_o21ai_1
X_22262_ _02854_ _02816_ _02818_ VPWR VGND sg13g2_xnor2_1
X_21213_ net427 net225 _01830_ VPWR VGND sg13g2_nor2_1
X_22193_ _02783_ u_LMS.w\[8\]\[3\] _02787_ VPWR VGND sg13g2_xor2_1
XFILLER_2_229 VPWR VGND sg13g2_decap_4
XFILLER_105_647 VPWR VGND sg13g2_decap_4
X_21144_ _01761_ _01760_ _01755_ VPWR VGND sg13g2_nand2b_1
Xfanout500 net501 net500 VPWR VGND sg13g2_buf_1
Xfanout511 net514 net511 VPWR VGND sg13g2_buf_1
XFILLER_116_45 VPWR VGND sg13g2_decap_4
Xfanout522 net523 net522 VPWR VGND sg13g2_buf_1
X_21075_ _01704_ _01652_ _01703_ VPWR VGND sg13g2_xnor2_1
Xfanout533 net535 net533 VPWR VGND sg13g2_buf_1
Xfanout544 net547 net544 VPWR VGND sg13g2_buf_1
XFILLER_58_211 VPWR VGND sg13g2_decap_8
Xfanout555 net556 net555 VPWR VGND sg13g2_buf_1
X_20026_ _11067_ _11064_ _11065_ VPWR VGND sg13g2_xnor2_1
Xfanout566 net567 net566 VPWR VGND sg13g2_buf_1
XFILLER_100_330 VPWR VGND sg13g2_decap_4
Xfanout577 u_LMS.x_r\[8\]\[5\] net577 VPWR VGND sg13g2_buf_1
XFILLER_86_553 VPWR VGND sg13g2_decap_8
Xfanout588 u_LMS.x_r\[8\]\[0\] net588 VPWR VGND sg13g2_buf_1
XFILLER_19_609 VPWR VGND sg13g2_fill_1
X_23249__1394 VPWR VGND net1393 sg13g2_tiehi
XFILLER_47_929 VPWR VGND sg13g2_decap_8
Xfanout599 u_LMS.x_r\[7\]\[3\] net599 VPWR VGND sg13g2_buf_1
XFILLER_100_363 VPWR VGND sg13g2_fill_1
XFILLER_132_77 VPWR VGND sg13g2_decap_8
X_21977_ _02571_ _02569_ _02570_ VPWR VGND sg13g2_xnor2_1
XFILLER_27_664 VPWR VGND sg13g2_fill_1
XFILLER_26_141 VPWR VGND sg13g2_fill_1
XFILLER_55_984 VPWR VGND sg13g2_fill_2
XFILLER_42_601 VPWR VGND sg13g2_decap_8
XFILLER_70_921 VPWR VGND sg13g2_fill_1
X_23716_ net1410 VGND VPWR _00778_ u_FIR.x\[5\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
XFILLER_109_1004 VPWR VGND sg13g2_decap_8
X_20928_ u_LMS.w\[6\]\[16\] net2063 _01568_ VPWR VGND sg13g2_and2_1
XFILLER_26_174 VPWR VGND sg13g2_decap_8
XFILLER_15_859 VPWR VGND sg13g2_decap_8
X_23647_ net984 VGND VPWR _00709_ u_debug_unit.mon_w1_sync\[6\] clknet_leaf_51_clkA
+ sg13g2_dfrbpq_1
X_20859_ _01478_ _01498_ _01499_ VPWR VGND sg13g2_nor2_1
X_13400_ _04742_ _04715_ _04717_ _04680_ net740 VPWR VGND sg13g2_a22oi_1
X_14380_ _05678_ _05683_ _05684_ VPWR VGND sg13g2_nor2b_1
X_23578_ net953 VGND VPWR _00640_ coeff_force_packed\[21\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
X_13331_ VGND VPWR _04636_ _04667_ _04675_ _04666_ sg13g2_a21oi_1
X_22529_ u_LMS.count\[9\] _03017_ _03019_ VPWR VGND sg13g2_and2_1
X_16050_ _07269_ _07238_ _07268_ _07291_ VPWR VGND sg13g2_a21o_1
XFILLER_109_953 VPWR VGND sg13g2_decap_4
X_13262_ _04608_ net829 net742 net813 u_FIR.w\[6\]\[2\] VPWR VGND sg13g2_a22oi_1
XFILLER_124_901 VPWR VGND sg13g2_fill_2
X_15001_ _06278_ net780 net888 VPWR VGND sg13g2_nand2_1
X_12213_ net940 _03597_ _00051_ VPWR VGND sg13g2_nor2_1
X_13193_ _04541_ u_FIR.sum\[1\]\[7\] net405 VPWR VGND sg13g2_nand2_1
XFILLER_108_496 VPWR VGND sg13g2_fill_2
X_23392__1173 VPWR VGND net1172 sg13g2_tiehi
X_12144_ _03546_ _03553_ _03554_ VPWR VGND sg13g2_nor2_1
XFILLER_97_807 VPWR VGND sg13g2_fill_1
XFILLER_111_617 VPWR VGND sg13g2_decap_4
X_23409__1122 VPWR VGND net1121 sg13g2_tiehi
X_19740_ _10804_ _10749_ u_LMS.w\[4\]\[14\] VPWR VGND sg13g2_xnor2_1
XFILLER_96_328 VPWR VGND sg13g2_fill_1
X_16952_ _08108_ _08107_ _08103_ VPWR VGND sg13g2_nand2b_1
X_12075_ _03488_ _03416_ u_debug_unit.mon_w8_sync\[4\] _03410_ u_debug_unit.mon_w4_sync\[4\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_2_35 VPWR VGND sg13g2_decap_8
XFILLER_1_295 VPWR VGND sg13g2_decap_8
X_15903_ VGND VPWR _07121_ _07129_ _07149_ _07136_ sg13g2_a21oi_1
X_19671_ _10735_ _10498_ _10734_ VPWR VGND sg13g2_nand2_1
XFILLER_49_244 VPWR VGND sg13g2_fill_2
XFILLER_38_918 VPWR VGND sg13g2_decap_4
X_16883_ _08039_ _08031_ _08037_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_704 VPWR VGND sg13g2_decap_4
XFILLER_65_715 VPWR VGND sg13g2_fill_1
X_18622_ _09720_ _09673_ _09721_ VPWR VGND sg13g2_xor2_1
XFILLER_92_512 VPWR VGND sg13g2_fill_1
XFILLER_64_203 VPWR VGND sg13g2_fill_2
X_15834_ _07081_ _07052_ _07083_ VPWR VGND sg13g2_xor2_1
XFILLER_64_225 VPWR VGND sg13g2_fill_2
XFILLER_49_299 VPWR VGND sg13g2_fill_1
X_23466__1533 VPWR VGND net1532 sg13g2_tiehi
X_18553_ net70 VPWR _09663_ VGND u_LMS.w\[2\]\[19\] u_LMS.w\[2\]\[18\] sg13g2_o21ai_1
X_15765_ _07009_ _07012_ _07015_ VPWR VGND sg13g2_nor2_1
X_12977_ _04333_ _04313_ _04335_ VPWR VGND sg13g2_xor2_1
XFILLER_18_686 VPWR VGND sg13g2_fill_1
X_17504_ net419 _03268_ net109 net92 _08637_ VPWR VGND sg13g2_nor4_1
XFILLER_45_472 VPWR VGND sg13g2_fill_1
X_14716_ net1005 VPWR _06006_ VGND net505 u_FIR.sum\[5\]\[8\] sg13g2_o21ai_1
X_11928_ VPWR _03349_ u_LMS.w\[1\]\[12\] VGND sg13g2_inv_1
X_18484_ u_LMS.w\[2\]\[14\] _09593_ _09594_ VPWR VGND sg13g2_and2_1
X_15696_ _06948_ _06940_ _06947_ VPWR VGND sg13g2_xnor2_1
XFILLER_60_420 VPWR VGND sg13g2_fill_2
XFILLER_33_634 VPWR VGND sg13g2_fill_2
XFILLER_32_111 VPWR VGND sg13g2_fill_1
XFILLER_17_196 VPWR VGND sg13g2_decap_4
XFILLER_75_1058 VPWR VGND sg13g2_fill_2
X_17435_ VGND VPWR net59 _08571_ _08572_ _08550_ sg13g2_a21oi_1
X_14647_ _05938_ _05937_ _05933_ VPWR VGND sg13g2_nand2b_1
X_11859_ VPWR _03280_ net711 VGND sg13g2_inv_1
XFILLER_32_155 VPWR VGND sg13g2_fill_2
X_17366_ _08469_ _08470_ _08403_ _08517_ VPWR VGND sg13g2_nand3_1
X_14578_ _05830_ _05832_ _05871_ VPWR VGND sg13g2_and2_1
X_19105_ _03330_ _10191_ _10192_ VPWR VGND sg13g2_nor2_1
X_16317_ VGND VPWR _07520_ _07531_ _07551_ _07539_ sg13g2_a21oi_1
X_13529_ _04861_ net753 net863 VPWR VGND sg13g2_nand2_1
X_17297_ _08420_ VPWR _08453_ VGND _08450_ _08451_ sg13g2_o21ai_1
X_19036_ _10123_ _10122_ _10092_ VPWR VGND sg13g2_nand2b_1
X_16248_ net805 VPWR _07484_ VGND u_FIR.w\[0\]\[3\] net798 sg13g2_o21ai_1
X_16179_ _07417_ net832 net796 net817 net798 VPWR VGND sg13g2_a22oi_1
XFILLER_49_0 VPWR VGND sg13g2_decap_8
XFILLER_88_818 VPWR VGND sg13g2_fill_1
XFILLER_102_606 VPWR VGND sg13g2_fill_2
XFILLER_87_306 VPWR VGND sg13g2_decap_8
XFILLER_101_105 VPWR VGND sg13g2_fill_1
XFILLER_130_937 VPWR VGND sg13g2_fill_2
X_19938_ _10956_ _10976_ _10954_ _10979_ VPWR VGND sg13g2_nand3_1
XFILLER_68_531 VPWR VGND sg13g2_decap_4
XFILLER_101_149 VPWR VGND sg13g2_fill_2
XFILLER_68_553 VPWR VGND sg13g2_decap_8
X_19869_ net358 VPWR _10917_ VGND u_LMS.w\[4\]\[5\] net373 sg13g2_o21ai_1
XFILLER_68_564 VPWR VGND sg13g2_fill_1
XFILLER_96_884 VPWR VGND sg13g2_fill_1
XFILLER_110_672 VPWR VGND sg13g2_decap_8
X_21900_ _02494_ _02490_ _02491_ VPWR VGND sg13g2_xnor2_1
X_22880_ _03168_ u_p2s_output.reg_cnt\[2\] _03167_ VPWR VGND sg13g2_xnor2_1
X_21831_ _03217_ net222 _02425_ VPWR VGND sg13g2_nor2_1
XFILLER_55_258 VPWR VGND sg13g2_decap_8
XFILLER_36_450 VPWR VGND sg13g2_fill_1
X_21762_ _02356_ _02349_ _02354_ VPWR VGND sg13g2_xnor2_1
XFILLER_63_280 VPWR VGND sg13g2_decap_8
XFILLER_36_494 VPWR VGND sg13g2_fill_1
XFILLER_24_645 VPWR VGND sg13g2_fill_1
X_23501_ net1408 VGND VPWR _00563_ u_LMS.count\[4\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
X_20713_ _01353_ _01349_ _01350_ VPWR VGND sg13g2_xnor2_1
X_21693_ VGND VPWR u_LMS.w\[7\]\[23\] net313 _02299_ _02276_ sg13g2_a21oi_1
XFILLER_24_689 VPWR VGND sg13g2_decap_4
X_23432_ net1052 VGND VPWR _00494_ u_LMS.x_r\[0\]\[7\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
X_20644_ _01284_ _01247_ _01282_ VPWR VGND sg13g2_nand2_1
X_23363_ net1238 VGND VPWR _00425_ u_LMS.w\[6\]\[19\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
XFILLER_20_862 VPWR VGND sg13g2_decap_8
X_20575_ _01215_ _01214_ _01196_ VPWR VGND sg13g2_nand2b_1
XFILLER_127_7 VPWR VGND sg13g2_decap_8
XFILLER_109_249 VPWR VGND sg13g2_fill_1
X_22314_ VGND VPWR net716 net307 _02896_ _02871_ sg13g2_a21oi_1
X_23294_ net1309 VGND VPWR _00356_ u_LMS.w\[3\]\[19\] clknet_leaf_52_clkA sg13g2_dfrbpq_1
XFILLER_118_761 VPWR VGND sg13g2_fill_1
XFILLER_105_400 VPWR VGND sg13g2_decap_4
X_22245_ net60 u_LMS.w\[8\]\[23\] _02839_ VPWR VGND sg13g2_xor2_1
XFILLER_106_945 VPWR VGND sg13g2_fill_1
XFILLER_3_538 VPWR VGND sg13g2_fill_1
XFILLER_105_433 VPWR VGND sg13g2_fill_1
XFILLER_106_978 VPWR VGND sg13g2_decap_8
X_22176_ _02770_ u_LMS.w\[8\]\[11\] _02769_ VPWR VGND sg13g2_nand2_1
XFILLER_132_241 VPWR VGND sg13g2_decap_8
XFILLER_127_77 VPWR VGND sg13g2_decap_8
XFILLER_121_904 VPWR VGND sg13g2_decap_4
XFILLER_78_306 VPWR VGND sg13g2_decap_8
XFILLER_87_48 VPWR VGND sg13g2_decap_4
XFILLER_121_937 VPWR VGND sg13g2_decap_4
X_21127_ _01741_ _01743_ _01744_ VPWR VGND sg13g2_nor2_1
XFILLER_78_328 VPWR VGND sg13g2_decap_4
Xfanout330 net331 net330 VPWR VGND sg13g2_buf_1
XFILLER_59_520 VPWR VGND sg13g2_decap_8
XFILLER_28_1060 VPWR VGND sg13g2_fill_1
Xfanout341 net343 net341 VPWR VGND sg13g2_buf_1
XFILLER_59_531 VPWR VGND sg13g2_fill_1
Xfanout352 net353 net352 VPWR VGND sg13g2_buf_1
XFILLER_101_650 VPWR VGND sg13g2_decap_4
X_21058_ VGND VPWR _01689_ _01690_ _00425_ net936 sg13g2_a21oi_1
Xfanout363 net365 net363 VPWR VGND sg13g2_buf_1
Xfanout374 net376 net374 VPWR VGND sg13g2_buf_1
XFILLER_87_873 VPWR VGND sg13g2_fill_1
Xfanout385 _08491_ net385 VPWR VGND sg13g2_buf_1
XFILLER_4_1018 VPWR VGND sg13g2_decap_8
Xfanout396 net397 net396 VPWR VGND sg13g2_buf_1
X_12900_ _04260_ _04255_ _04259_ VPWR VGND sg13g2_xnor2_1
XFILLER_74_512 VPWR VGND sg13g2_fill_2
X_20009_ _11044_ _11043_ _11050_ VPWR VGND sg13g2_xor2_1
XFILLER_47_737 VPWR VGND sg13g2_fill_1
X_13880_ _05203_ _05185_ _05201_ VPWR VGND sg13g2_xnor2_1
XFILLER_100_171 VPWR VGND sg13g2_decap_4
XFILLER_47_759 VPWR VGND sg13g2_decap_8
XFILLER_98_1058 VPWR VGND sg13g2_fill_2
XFILLER_28_951 VPWR VGND sg13g2_decap_8
X_12831_ _04193_ u_FIR.sum\[0\]\[9\] net407 VPWR VGND sg13g2_xnor2_1
XFILLER_15_601 VPWR VGND sg13g2_fill_2
XFILLER_43_921 VPWR VGND sg13g2_fill_2
X_15550_ net846 u_FIR.sum\[6\]\[4\] net792 _06806_ VPWR VGND sg13g2_nand3_1
X_12762_ _04084_ _04086_ _04125_ _04126_ VPWR VGND sg13g2_or3_1
XFILLER_27_483 VPWR VGND sg13g2_decap_8
X_14501_ _05797_ net902 net771 net890 net772 VPWR VGND sg13g2_a22oi_1
X_23480__1484 VPWR VGND net1483 sg13g2_tiehi
X_15481_ _06742_ _06736_ _06741_ VPWR VGND sg13g2_xnor2_1
XFILLER_70_762 VPWR VGND sg13g2_decap_8
X_12693_ _04058_ _04057_ _04019_ VPWR VGND sg13g2_nand2b_1
X_17220_ _08376_ _08164_ _08131_ VPWR VGND sg13g2_nand2b_1
X_14432_ VGND VPWR net512 _05732_ _00134_ _05733_ sg13g2_a21oi_1
XFILLER_52_62 VPWR VGND sg13g2_decap_4
X_17151_ VPWR _08307_ _08306_ VGND sg13g2_inv_1
X_14363_ _05653_ VPWR _05667_ VGND net278 _05651_ sg13g2_o21ai_1
XFILLER_128_536 VPWR VGND sg13g2_decap_8
XFILLER_11_884 VPWR VGND sg13g2_fill_1
X_16102_ _07342_ _07335_ _07341_ VPWR VGND sg13g2_nand2_1
X_13314_ _04659_ u_FIR.sum\[1\]\[10\] net405 VPWR VGND sg13g2_nand2_1
X_17082_ VGND VPWR _08214_ _08215_ _08238_ _08217_ sg13g2_a21oi_1
XFILLER_10_394 VPWR VGND sg13g2_decap_4
X_14294_ _05595_ _05597_ _05600_ VPWR VGND sg13g2_nor2_1
XFILLER_7_877 VPWR VGND sg13g2_decap_4
X_16033_ net801 net886 u_FIR.sum\[7\]\[1\] _07272_ _07274_ VPWR VGND sg13g2_and4_1
X_13245_ _04590_ VPWR _04592_ VGND _04550_ _04552_ sg13g2_o21ai_1
X_23315__1287 VPWR VGND net1286 sg13g2_tiehi
XFILLER_124_731 VPWR VGND sg13g2_fill_1
X_13176_ net884 net740 _04522_ _04524_ VPWR VGND sg13g2_a21o_1
XFILLER_97_615 VPWR VGND sg13g2_fill_2
X_12127_ _03520_ VPWR _00042_ VGND _03536_ _03537_ sg13g2_o21ai_1
XFILLER_123_285 VPWR VGND sg13g2_fill_2
XFILLER_111_436 VPWR VGND sg13g2_decap_4
X_17984_ _09113_ net40 _09112_ VPWR VGND sg13g2_nand2b_1
XFILLER_81_1040 VPWR VGND sg13g2_fill_1
X_19723_ _10787_ _03323_ _10761_ VPWR VGND sg13g2_nand2_1
XFILLER_42_1013 VPWR VGND sg13g2_fill_2
X_16935_ _08086_ _08085_ _08091_ VPWR VGND sg13g2_xor2_1
X_12058_ _03472_ net294 debug_load_bus\[5\] _03404_ u_debug_unit.mon_w7_sync\[5\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_42_1057 VPWR VGND sg13g2_decap_4
X_19654_ _10670_ _10669_ _10718_ VPWR VGND sg13g2_nor2b_1
XFILLER_77_383 VPWR VGND sg13g2_fill_1
X_23172__1530 VPWR VGND net1529 sg13g2_tiehi
X_16866_ _08022_ _08021_ _08020_ VPWR VGND sg13g2_nand2b_1
XFILLER_65_534 VPWR VGND sg13g2_fill_1
X_23200__1481 VPWR VGND net1480 sg13g2_tiehi
XFILLER_37_236 VPWR VGND sg13g2_fill_2
X_18605_ VGND VPWR _09706_ _09707_ _00333_ net919 sg13g2_a21oi_1
X_15817_ _07066_ _07057_ _07064_ VPWR VGND sg13g2_xnor2_1
X_19585_ VGND VPWR _10646_ _10648_ _10649_ _10645_ sg13g2_a21oi_1
XFILLER_65_578 VPWR VGND sg13g2_decap_8
X_16797_ _07908_ _07950_ net912 _07953_ VPWR VGND sg13g2_nand3_1
XFILLER_80_526 VPWR VGND sg13g2_decap_8
X_18536_ VGND VPWR net1663 _09644_ _09646_ _09599_ sg13g2_a21oi_1
X_15748_ _06999_ u_FIR.sum\[6\]\[9\] net392 VPWR VGND sg13g2_nand2_1
XFILLER_93_91 VPWR VGND sg13g2_fill_1
XFILLER_45_280 VPWR VGND sg13g2_decap_4
XFILLER_34_954 VPWR VGND sg13g2_decap_8
XFILLER_34_965 VPWR VGND sg13g2_fill_1
XFILLER_33_431 VPWR VGND sg13g2_decap_8
X_18467_ VGND VPWR _09243_ _09249_ _09577_ _09200_ sg13g2_a21oi_1
XFILLER_21_604 VPWR VGND sg13g2_decap_4
X_15679_ _06930_ _06897_ _06932_ VPWR VGND sg13g2_xor2_1
XFILLER_21_626 VPWR VGND sg13g2_fill_1
XFILLER_20_103 VPWR VGND sg13g2_fill_1
X_17418_ _08559_ _08435_ _08436_ VPWR VGND sg13g2_xnor2_1
X_18398_ _09505_ _09506_ _09480_ _09508_ VPWR VGND sg13g2_nand3_1
XFILLER_119_503 VPWR VGND sg13g2_fill_2
XFILLER_119_514 VPWR VGND sg13g2_decap_8
X_17349_ net45 VPWR _08504_ VGND net43 _08503_ sg13g2_o21ai_1
XFILLER_119_547 VPWR VGND sg13g2_decap_4
X_20360_ u_LMS.w\[5\]\[9\] _00991_ _01023_ VPWR VGND sg13g2_nor2_1
XFILLER_9_192 VPWR VGND sg13g2_fill_2
X_19019_ _10106_ _10103_ _10105_ VPWR VGND sg13g2_xnor2_1
X_20291_ VGND VPWR _00953_ _00954_ _00946_ _00945_ sg13g2_a21oi_2
X_22030_ _02624_ net2204 _02623_ VPWR VGND sg13g2_xnor2_1
XFILLER_115_786 VPWR VGND sg13g2_decap_4
XFILLER_87_103 VPWR VGND sg13g2_decap_8
XFILLER_57_18 VPWR VGND sg13g2_fill_1
XFILLER_69_895 VPWR VGND sg13g2_fill_2
X_22932_ _03196_ _03574_ u_spi_slave.rx_shift\[1\] u_spi_slave.rx_shift\[9\] u_spi_slave.bit_cnt\[3\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_95_191 VPWR VGND sg13g2_decap_8
XFILLER_83_342 VPWR VGND sg13g2_decap_8
XFILLER_113_46 VPWR VGND sg13g2_fill_1
XFILLER_83_353 VPWR VGND sg13g2_fill_1
X_22863_ VGND VPWR net300 _03154_ _00765_ _03155_ sg13g2_a21oi_1
XFILLER_56_589 VPWR VGND sg13g2_decap_4
XFILLER_113_68 VPWR VGND sg13g2_fill_1
X_21814_ net574 net149 net571 _02408_ VPWR VGND net93 sg13g2_nand4_1
XFILLER_37_792 VPWR VGND sg13g2_decap_8
X_22794_ u_debug_unit.mon_w5_sync\[6\] net346 _03115_ VPWR VGND sg13g2_nor2_1
X_21745_ _02339_ _02338_ _02336_ VPWR VGND sg13g2_nand2b_1
XFILLER_11_114 VPWR VGND sg13g2_fill_2
X_21676_ _02283_ _02234_ _02285_ VPWR VGND sg13g2_xor2_1
XFILLER_12_659 VPWR VGND sg13g2_decap_8
X_23415_ net1103 VGND VPWR _00477_ u_LMS.w\[8\]\[2\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
X_20627_ _01267_ _01191_ _01216_ VPWR VGND sg13g2_xnor2_1
XFILLER_22_32 VPWR VGND sg13g2_fill_2
XFILLER_7_129 VPWR VGND sg13g2_fill_2
X_23346_ net1255 VGND VPWR _00408_ u_LMS.w\[5\]\[2\] clknet_leaf_10_clkA sg13g2_dfrbpq_1
X_23511__1373 VPWR VGND net1372 sg13g2_tiehi
X_20558_ net117 _01197_ _01198_ VPWR VGND sg13g2_nor2b_1
X_23277_ net1339 VGND VPWR _00339_ u_LMS.w\[2\]\[2\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
X_20489_ _01133_ _01134_ _00412_ VPWR VGND sg13g2_nor2_1
X_13030_ net882 net746 u_FIR.sum\[1\]\[2\] _04383_ VPWR VGND sg13g2_a21o_1
X_22228_ _02822_ u_LMS.w\[8\]\[17\] _02755_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_1013 VPWR VGND sg13g2_fill_1
XFILLER_65_1024 VPWR VGND sg13g2_decap_8
X_22159_ _02753_ u_LMS.w\[8\]\[19\] net61 VPWR VGND sg13g2_xnor2_1
XFILLER_79_648 VPWR VGND sg13g2_fill_2
Xfanout160 net160 net162 VPWR VGND sg13g2_buf_4
X_14981_ net902 u_FIR.sum\[5\]\[0\] net782 _06260_ VPWR VGND sg13g2_nand3_1
Xfanout171 net174 net171 VPWR VGND sg13g2_buf_1
XFILLER_47_501 VPWR VGND sg13g2_fill_2
Xfanout182 net184 net182 VPWR VGND sg13g2_buf_2
X_16720_ VGND VPWR u_LMS.w\[8\]\[15\] _07872_ _07880_ _07873_ sg13g2_a21oi_1
XFILLER_93_128 VPWR VGND sg13g2_decap_4
XFILLER_120_288 VPWR VGND sg13g2_fill_2
Xfanout193 net194 net193 VPWR VGND sg13g2_buf_2
X_13932_ _05252_ u_FIR.sum\[2\]\[16\] net402 VPWR VGND sg13g2_nand2_1
XFILLER_101_491 VPWR VGND sg13g2_fill_1
XFILLER_47_62 VPWR VGND sg13g2_fill_2
XFILLER_90_802 VPWR VGND sg13g2_fill_2
XFILLER_35_707 VPWR VGND sg13g2_fill_2
X_16651_ u_LMS.w\[6\]\[23\] u_LMS.w\[6\]\[22\] u_LMS.w\[6\]\[24\] _07828_ VPWR VGND
+ u_LMS.w\[6\]\[21\] sg13g2_nand4_1
X_13863_ _05162_ VPWR _05186_ VGND net282 _05164_ sg13g2_o21ai_1
XFILLER_90_824 VPWR VGND sg13g2_decap_8
XFILLER_16_910 VPWR VGND sg13g2_fill_2
XFILLER_90_835 VPWR VGND sg13g2_fill_1
X_15602_ net979 VPWR _06857_ VGND net483 u_FIR.sum\[7\]\[5\] sg13g2_o21ai_1
X_12814_ net857 _04175_ net729 _04176_ VPWR VGND sg13g2_nand3_1
X_19370_ _10434_ _10432_ _10433_ VPWR VGND sg13g2_nand2_1
XFILLER_34_239 VPWR VGND sg13g2_decap_8
X_16582_ VGND VPWR net490 _07777_ _00239_ _07778_ sg13g2_a21oi_1
X_13794_ _05105_ VPWR _05119_ VGND _05101_ _05103_ sg13g2_o21ai_1
X_18321_ _09431_ net254 net670 net238 net672 VPWR VGND sg13g2_a22oi_1
X_15533_ _06790_ _06787_ _06788_ VPWR VGND sg13g2_xnor2_1
X_12745_ _04101_ _04108_ _04109_ VPWR VGND sg13g2_nor2b_1
XFILLER_31_913 VPWR VGND sg13g2_fill_1
XFILLER_42_272 VPWR VGND sg13g2_decap_4
XFILLER_31_946 VPWR VGND sg13g2_fill_1
X_18252_ _09362_ _09214_ _09347_ VPWR VGND sg13g2_xnor2_1
X_15464_ _06726_ _06706_ _06725_ VPWR VGND sg13g2_xnor2_1
X_12676_ _04042_ _04034_ _04041_ VPWR VGND sg13g2_nand2_1
X_17203_ _08359_ _08356_ _08357_ VPWR VGND sg13g2_xnor2_1
X_14415_ VGND VPWR _05717_ _05716_ net277 sg13g2_or2_1
X_18183_ _09293_ _09292_ _09291_ VPWR VGND sg13g2_nand2b_1
X_15395_ _06635_ _06660_ _06661_ VPWR VGND sg13g2_nor2b_1
XFILLER_8_56 VPWR VGND sg13g2_decap_8
X_17134_ _08287_ _08288_ _08265_ _08290_ VPWR VGND sg13g2_nand3_1
X_14346_ _05651_ u_FIR.sum\[3\]\[12\] net400 VPWR VGND sg13g2_xnor2_1
XFILLER_116_506 VPWR VGND sg13g2_fill_2
XFILLER_116_528 VPWR VGND sg13g2_decap_4
X_17065_ VGND VPWR _08199_ _08200_ _08221_ _08202_ sg13g2_a21oi_1
X_14277_ VPWR _05584_ _05583_ VGND sg13g2_inv_1
X_16016_ _07257_ net799 net858 VPWR VGND sg13g2_nand2_1
XFILLER_6_195 VPWR VGND sg13g2_decap_8
X_13228_ _04575_ _04567_ _04573_ VPWR VGND sg13g2_xnor2_1
XFILLER_98_902 VPWR VGND sg13g2_fill_1
X_13159_ _04508_ _04478_ _04507_ VPWR VGND sg13g2_xnor2_1
XFILLER_112_745 VPWR VGND sg13g2_fill_1
XFILLER_100_907 VPWR VGND sg13g2_decap_8
XFILLER_97_467 VPWR VGND sg13g2_fill_1
X_17967_ _09100_ net307 u_LMS.w\[1\]\[12\] coeff_force_packed\[7\] net557 VPWR VGND
+ sg13g2_a22oi_1
X_19706_ _10770_ u_LMS.w\[4\]\[3\] _10769_ VPWR VGND sg13g2_nand2_1
XFILLER_84_128 VPWR VGND sg13g2_fill_1
X_16918_ _08070_ _08073_ _08074_ VPWR VGND sg13g2_nor2_1
XFILLER_65_320 VPWR VGND sg13g2_decap_8
X_17898_ _09031_ _03343_ _08995_ VPWR VGND sg13g2_nand2_1
XFILLER_65_331 VPWR VGND sg13g2_fill_1
XFILLER_66_865 VPWR VGND sg13g2_fill_1
X_19637_ net651 net241 net649 _10701_ VPWR VGND net204 sg13g2_nand4_1
X_16849_ VPWR _08005_ _08004_ VGND sg13g2_inv_1
XFILLER_92_150 VPWR VGND sg13g2_decap_8
XFILLER_66_887 VPWR VGND sg13g2_decap_8
XFILLER_80_301 VPWR VGND sg13g2_fill_2
XFILLER_25_228 VPWR VGND sg13g2_decap_8
XFILLER_19_781 VPWR VGND sg13g2_fill_1
XFILLER_129_1007 VPWR VGND sg13g2_decap_8
X_19568_ _10632_ _10631_ _10628_ VPWR VGND sg13g2_nand2b_1
XFILLER_53_548 VPWR VGND sg13g2_decap_8
X_18519_ _09629_ _03338_ _09608_ VPWR VGND sg13g2_xnor2_1
XFILLER_34_762 VPWR VGND sg13g2_fill_2
XFILLER_40_209 VPWR VGND sg13g2_decap_8
X_19499_ _10562_ _10561_ _10563_ VPWR VGND sg13g2_nor2b_1
X_21530_ _01812_ _02146_ _01794_ _02147_ VPWR VGND sg13g2_nand3_1
XFILLER_61_592 VPWR VGND sg13g2_fill_1
X_21461_ _02078_ _02054_ _02055_ VPWR VGND sg13g2_xnor2_1
X_23200_ net1480 VGND VPWR _00262_ u_FIR.w\[6\]\[3\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
X_20412_ net22 VPWR _01075_ VGND net20 _01074_ sg13g2_o21ai_1
X_21392_ _02009_ _01996_ _02007_ VPWR VGND sg13g2_xnor2_1
X_23007__1196 VPWR VGND net1195 sg13g2_tiehi
X_23422__1083 VPWR VGND net1082 sg13g2_tiehi
X_23131_ net1592 VGND VPWR _00193_ u_FIR.sum\[7\]\[17\] clknet_leaf_43_clkA sg13g2_dfrbpq_1
X_20343_ _01002_ u_LMS.w\[5\]\[3\] _01006_ VPWR VGND sg13g2_xor2_1
XFILLER_104_9 VPWR VGND sg13g2_fill_1
X_23062_ net1113 VGND VPWR _00124_ u_FIR.sum\[4\]\[5\] clknet_leaf_40_clkA sg13g2_dfrbpq_1
X_20274_ _00837_ _00836_ _00937_ VPWR VGND sg13g2_xor2_1
XFILLER_89_924 VPWR VGND sg13g2_decap_8
X_22013_ VGND VPWR _02607_ _02606_ _02590_ sg13g2_or2_1
XFILLER_68_39 VPWR VGND sg13g2_decap_8
XFILLER_89_957 VPWR VGND sg13g2_decap_4
XFILLER_130_520 VPWR VGND sg13g2_decap_8
XFILLER_103_767 VPWR VGND sg13g2_decap_4
XFILLER_48_309 VPWR VGND sg13g2_fill_2
XFILLER_88_489 VPWR VGND sg13g2_decap_8
XFILLER_75_106 VPWR VGND sg13g2_fill_1
Xclkbuf_leaf_52_clkA clknet_4_6_0_clkA clknet_leaf_52_clkA VPWR VGND sg13g2_buf_8
XFILLER_69_670 VPWR VGND sg13g2_decap_4
XFILLER_25_1052 VPWR VGND sg13g2_decap_8
XFILLER_130_597 VPWR VGND sg13g2_decap_8
XFILLER_84_27 VPWR VGND sg13g2_decap_4
XFILLER_68_180 VPWR VGND sg13g2_decap_8
XFILLER_84_651 VPWR VGND sg13g2_fill_2
X_22915_ net1027 VPWR _03186_ VGND net554 u_s2p_input.reg_sh\[6\] sg13g2_o21ai_1
XFILLER_17_707 VPWR VGND sg13g2_fill_1
XFILLER_17_718 VPWR VGND sg13g2_fill_1
XFILLER_57_898 VPWR VGND sg13g2_decap_8
XFILLER_56_375 VPWR VGND sg13g2_fill_2
X_22846_ net971 VPWR _03144_ VGND net5 net299 sg13g2_o21ai_1
XFILLER_71_345 VPWR VGND sg13g2_fill_1
XFILLER_71_367 VPWR VGND sg13g2_fill_1
XFILLER_71_378 VPWR VGND sg13g2_fill_2
X_22777_ VGND VPWR _07803_ net341 _00728_ _03106_ sg13g2_a21oi_1
Xclkbuf_4_6_0_clkA clknet_0_clkA clknet_4_6_0_clkA VPWR VGND sg13g2_buf_8
X_12530_ _03904_ _03862_ _03903_ VPWR VGND sg13g2_xnor2_1
X_21728_ _02324_ _02325_ _00460_ VPWR VGND sg13g2_nor2_1
XFILLER_40_776 VPWR VGND sg13g2_decap_8
X_12461_ net841 net719 _03835_ _03837_ VPWR VGND sg13g2_a21o_1
X_21659_ _02271_ net13 _02270_ VPWR VGND sg13g2_nand2_1
X_14200_ _05509_ u_FIR.sum\[3\]\[8\] net401 VPWR VGND sg13g2_nand2_1
X_15180_ VGND VPWR _06414_ _06442_ _06451_ _06444_ sg13g2_a21oi_1
X_12392_ _03767_ _03768_ _03769_ _03770_ VPWR VGND sg13g2_nor3_1
X_14131_ net506 VPWR _05442_ VGND _05440_ _05441_ sg13g2_o21ai_1
XFILLER_4_600 VPWR VGND sg13g2_decap_4
XFILLER_116_0 VPWR VGND sg13g2_decap_8
X_23329_ net1272 VGND VPWR _00391_ u_LMS.w\[4\]\[8\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
XFILLER_125_347 VPWR VGND sg13g2_decap_4
X_14062_ VGND VPWR _05374_ _05372_ _05343_ sg13g2_or2_1
XFILLER_113_509 VPWR VGND sg13g2_decap_4
XFILLER_79_401 VPWR VGND sg13g2_fill_1
X_13013_ _04366_ _04367_ _00081_ VPWR VGND sg13g2_nor2_1
X_18870_ _09955_ _09956_ _09957_ VPWR VGND sg13g2_nor2_1
XFILLER_121_531 VPWR VGND sg13g2_fill_1
X_17821_ _08904_ VPWR _08954_ VGND _08951_ _08952_ sg13g2_o21ai_1
XFILLER_0_872 VPWR VGND sg13g2_decap_4
XFILLER_58_83 VPWR VGND sg13g2_fill_1
XFILLER_48_821 VPWR VGND sg13g2_fill_2
X_17752_ _08885_ net700 net223 VPWR VGND sg13g2_nand2_1
X_14964_ _06245_ _06236_ _06244_ VPWR VGND sg13g2_xnor2_1
XFILLER_47_320 VPWR VGND sg13g2_fill_1
XFILLER_47_342 VPWR VGND sg13g2_decap_8
X_16703_ VGND VPWR _03301_ net520 _00272_ _07866_ sg13g2_a21oi_1
XFILLER_47_353 VPWR VGND sg13g2_fill_1
X_13915_ _05235_ _05214_ _05236_ VPWR VGND sg13g2_xor2_1
X_17683_ VGND VPWR _08812_ _08813_ _08816_ _08815_ sg13g2_a21oi_1
X_14895_ _06174_ _06176_ _06179_ VPWR VGND sg13g2_nor2_1
X_19422_ _10486_ _10484_ _10485_ VPWR VGND sg13g2_nand2_1
XFILLER_47_397 VPWR VGND sg13g2_decap_8
X_16634_ net1023 VPWR _07817_ VGND net518 net753 sg13g2_o21ai_1
X_13846_ _05170_ _05169_ _05135_ VPWR VGND sg13g2_nand2b_1
X_19353_ VGND VPWR _10417_ _10403_ _10401_ sg13g2_or2_1
X_16565_ VGND VPWR u_LMS.w\[2\]\[17\] _07753_ _07765_ _07754_ sg13g2_a21oi_1
X_13777_ _05103_ u_FIR.sum\[2\]\[10\] net403 VPWR VGND sg13g2_xnor2_1
XFILLER_128_1040 VPWR VGND sg13g2_decap_8
X_18304_ _09414_ _09402_ _09413_ VPWR VGND sg13g2_nand2_1
X_15516_ net859 u_FIR.sum\[6\]\[3\] net792 _06773_ VPWR VGND sg13g2_nand3_1
X_19284_ _10348_ net169 net641 net181 net639 VPWR VGND sg13g2_a22oi_1
X_12728_ _04068_ VPWR _04092_ VGND _04021_ _04061_ sg13g2_o21ai_1
X_16496_ VGND VPWR u_LMS.w\[0\]\[12\] _07713_ _07715_ _07714_ sg13g2_a21oi_1
XFILLER_31_765 VPWR VGND sg13g2_decap_4
X_18235_ _09338_ VPWR _09345_ VGND _09304_ _09336_ sg13g2_o21ai_1
X_15447_ _06710_ _06685_ _06708_ VPWR VGND sg13g2_xnor2_1
X_12659_ _04025_ net732 net869 VPWR VGND sg13g2_nand2_1
XFILLER_30_275 VPWR VGND sg13g2_decap_8
XFILLER_30_286 VPWR VGND sg13g2_fill_1
X_18166_ _09275_ _09188_ _09276_ VPWR VGND sg13g2_xor2_1
X_15378_ net250 _06642_ _06644_ VPWR VGND sg13g2_and2_1
XFILLER_128_152 VPWR VGND sg13g2_decap_8
XFILLER_8_983 VPWR VGND sg13g2_fill_2
XFILLER_128_163 VPWR VGND sg13g2_fill_1
X_17117_ VGND VPWR _08253_ _08261_ _08273_ _08272_ sg13g2_a21oi_1
X_14329_ VGND VPWR _05602_ _05626_ _05634_ _05625_ sg13g2_a21oi_1
XFILLER_116_325 VPWR VGND sg13g2_fill_1
X_18097_ VGND VPWR net671 net106 _09207_ _09204_ sg13g2_a21oi_1
Xrebuffer2105 _09585_ net2104 VPWR VGND sg13g2_buf_1
Xrebuffer2116 _09542_ net2115 VPWR VGND sg13g2_buf_1
Xrebuffer2127 _01047_ net2126 VPWR VGND sg13g2_buf_1
X_17048_ net2202 _08198_ _08204_ VPWR VGND sg13g2_nor2b_1
Xrebuffer2138 _08459_ net2137 VPWR VGND sg13g2_buf_1
Xrebuffer2149 net2154 net2148 VPWR VGND sg13g2_buf_1
XFILLER_98_732 VPWR VGND sg13g2_decap_8
Xfanout907 net908 net907 VPWR VGND sg13g2_buf_1
Xfanout918 net920 net918 VPWR VGND sg13g2_buf_1
XFILLER_31_0 VPWR VGND sg13g2_decap_8
Xfanout929 net942 net929 VPWR VGND sg13g2_buf_1
XFILLER_86_905 VPWR VGND sg13g2_decap_8
XFILLER_58_629 VPWR VGND sg13g2_decap_8
X_18999_ VGND VPWR _10086_ _10085_ _10084_ sg13g2_or2_1
X_23018__1180 VPWR VGND net1179 sg13g2_tiehi
XFILLER_57_128 VPWR VGND sg13g2_decap_8
XFILLER_97_297 VPWR VGND sg13g2_fill_1
X_23397__1158 VPWR VGND net1157 sg13g2_tiehi
XFILLER_94_971 VPWR VGND sg13g2_fill_1
XFILLER_54_802 VPWR VGND sg13g2_fill_1
X_20961_ _01601_ u_LMS.w\[6\]\[4\] _01593_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_150 VPWR VGND sg13g2_fill_2
X_22700_ _00023_ _00022_ _03070_ VPWR VGND sg13g2_nor2b_1
XFILLER_38_397 VPWR VGND sg13g2_decap_8
X_23680_ net1017 VGND VPWR _00742_ u_debug_unit.mon_w6_sync\[4\] clknet_leaf_20_clkA
+ sg13g2_dfrbpq_1
X_20892_ _01532_ _01528_ _01529_ VPWR VGND sg13g2_xnor2_1
XFILLER_80_142 VPWR VGND sg13g2_fill_1
X_22631_ net469 coeff_force_packed\[9\] _03062_ _00626_ VPWR VGND sg13g2_mux2_1
XFILLER_80_175 VPWR VGND sg13g2_fill_1
X_22562_ net917 _03038_ _03039_ _00580_ VPWR VGND sg13g2_nor3_1
X_23282__1330 VPWR VGND net1329 sg13g2_tiehi
X_23310__1292 VPWR VGND net1291 sg13g2_tiehi
XFILLER_22_765 VPWR VGND sg13g2_fill_2
X_21513_ _01924_ _01894_ _02130_ VPWR VGND sg13g2_xor2_1
X_22493_ net958 VPWR _02996_ VGND net441 net579 sg13g2_o21ai_1
XFILLER_108_804 VPWR VGND sg13g2_decap_4
X_21444_ _02060_ VPWR _02061_ VGND _03226_ net179 sg13g2_o21ai_1
X_23289__1317 VPWR VGND net1316 sg13g2_tiehi
XFILLER_119_185 VPWR VGND sg13g2_fill_1
X_21375_ _01992_ _01967_ _01990_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_78 VPWR VGND sg13g2_decap_8
Xclkbuf_4_14_0_clkA clknet_0_clkA clknet_4_14_0_clkA VPWR VGND sg13g2_buf_8
X_23114_ net1618 VGND VPWR _00176_ u_FIR.sum\[7\]\[0\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
X_20326_ _00989_ _00934_ _00935_ VPWR VGND sg13g2_xnor2_1
XFILLER_122_317 VPWR VGND sg13g2_fill_1
X_23045_ net1138 VGND VPWR _00107_ u_FIR.sum\[3\]\[7\] clknet_leaf_33_clkA sg13g2_dfrbpq_1
X_20257_ _00913_ _00919_ _00920_ VPWR VGND sg13g2_nor2_1
XFILLER_131_840 VPWR VGND sg13g2_fill_2
XFILLER_62_1016 VPWR VGND sg13g2_decap_4
XFILLER_62_1027 VPWR VGND sg13g2_fill_1
XFILLER_88_264 VPWR VGND sg13g2_decap_8
XFILLER_131_873 VPWR VGND sg13g2_fill_1
XFILLER_0_168 VPWR VGND sg13g2_decap_8
X_20188_ _00824_ _00850_ _00851_ VPWR VGND sg13g2_and2_1
XFILLER_95_37 VPWR VGND sg13g2_fill_1
XFILLER_130_361 VPWR VGND sg13g2_decap_8
XFILLER_57_651 VPWR VGND sg13g2_decap_8
XFILLER_28_64 VPWR VGND sg13g2_decap_4
X_11961_ VPWR _03382_ u_LMS.mu\[2\] VGND sg13g2_inv_1
XFILLER_91_418 VPWR VGND sg13g2_decap_8
XFILLER_45_813 VPWR VGND sg13g2_decap_8
XFILLER_91_429 VPWR VGND sg13g2_fill_2
XFILLER_44_312 VPWR VGND sg13g2_fill_2
X_13700_ _05028_ _05024_ _05027_ VPWR VGND sg13g2_xnor2_1
XFILLER_84_492 VPWR VGND sg13g2_fill_1
X_23189__1500 VPWR VGND net1499 sg13g2_tiehi
X_14680_ VGND VPWR _05932_ _05939_ _05970_ _05946_ sg13g2_a21oi_1
X_23217__1451 VPWR VGND net1450 sg13g2_tiehi
X_11892_ VPWR _03313_ u_LMS.w\[5\]\[6\] VGND sg13g2_inv_1
XFILLER_45_879 VPWR VGND sg13g2_fill_1
X_13631_ VGND VPWR net532 _04959_ _00106_ _04960_ sg13g2_a21oi_1
XFILLER_32_507 VPWR VGND sg13g2_decap_8
X_22829_ VGND VPWR _07878_ net345 _00754_ _03132_ sg13g2_a21oi_1
XFILLER_44_63 VPWR VGND sg13g2_fill_1
X_16350_ VGND VPWR _07552_ _07563_ _07583_ _07570_ sg13g2_a21oi_1
X_13562_ _04890_ _04892_ _04893_ VPWR VGND sg13g2_nor2_1
XFILLER_12_220 VPWR VGND sg13g2_fill_2
XFILLER_40_540 VPWR VGND sg13g2_fill_2
X_15301_ _06564_ _06566_ _06569_ VPWR VGND sg13g2_nor2_1
X_12513_ net1038 VPWR _03888_ VGND net542 u_FIR.sum\[0\]\[11\] sg13g2_o21ai_1
XFILLER_13_776 VPWR VGND sg13g2_decap_4
X_16281_ _07513_ VPWR _07516_ VGND _07480_ _07510_ sg13g2_o21ai_1
X_13493_ net880 u_FIR.sum\[2\]\[2\] net755 _04827_ VPWR VGND sg13g2_nand3_1
XFILLER_8_224 VPWR VGND sg13g2_decap_4
X_18020_ net40 VPWR _09142_ VGND net38 _09141_ sg13g2_o21ai_1
X_15232_ _06502_ _06496_ _06500_ VPWR VGND sg13g2_xnor2_1
X_12444_ net1038 VPWR _03821_ VGND net543 u_FIR.sum\[0\]\[9\] sg13g2_o21ai_1
X_15163_ _06386_ VPWR _06435_ VGND _06383_ _06387_ sg13g2_o21ai_1
X_12375_ _03735_ VPWR _03753_ VGND _03688_ _03733_ sg13g2_o21ai_1
X_14114_ _05380_ _05382_ _05425_ VPWR VGND sg13g2_and2_1
XFILLER_5_35 VPWR VGND sg13g2_decap_8
XFILLER_125_144 VPWR VGND sg13g2_decap_8
X_19971_ _11012_ _11006_ _11011_ VPWR VGND sg13g2_nand2_1
X_15094_ _06366_ _06337_ _06368_ VPWR VGND sg13g2_xor2_1
XFILLER_99_518 VPWR VGND sg13g2_decap_8
X_18922_ _10003_ VPWR _10009_ VGND _09999_ _10004_ sg13g2_o21ai_1
X_14045_ _05358_ _05357_ _05321_ VPWR VGND sg13g2_nand2b_1
XFILLER_106_380 VPWR VGND sg13g2_decap_8
X_23127__1599 VPWR VGND net1598 sg13g2_tiehi
XFILLER_69_82 VPWR VGND sg13g2_fill_2
X_18853_ _09940_ _09937_ _09938_ VPWR VGND sg13g2_xnor2_1
XFILLER_68_938 VPWR VGND sg13g2_fill_1
XFILLER_121_361 VPWR VGND sg13g2_fill_2
XFILLER_0_680 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_4_clkA clknet_4_3_0_clkA clknet_leaf_4_clkA VPWR VGND sg13g2_buf_8
X_17804_ _08930_ _08936_ _08937_ VPWR VGND sg13g2_nor2b_1
XFILLER_95_746 VPWR VGND sg13g2_fill_1
X_18784_ _09871_ _09868_ _09869_ VPWR VGND sg13g2_xnor2_1
X_15996_ _07237_ _07236_ _07235_ VPWR VGND sg13g2_nand2b_1
X_17735_ _08868_ net698 net186 VPWR VGND sg13g2_nand2_1
X_14947_ _06220_ _06228_ _06229_ VPWR VGND sg13g2_nor2_1
XFILLER_78_1001 VPWR VGND sg13g2_fill_2
XFILLER_85_92 VPWR VGND sg13g2_fill_1
XFILLER_75_470 VPWR VGND sg13g2_decap_4
XFILLER_63_621 VPWR VGND sg13g2_fill_1
X_17666_ _08799_ _08796_ _08798_ VPWR VGND sg13g2_xnor2_1
X_14878_ _06163_ _06154_ _06162_ VPWR VGND sg13g2_xnor2_1
XFILLER_78_1056 VPWR VGND sg13g2_decap_4
XFILLER_91_974 VPWR VGND sg13g2_decap_8
XFILLER_39_1018 VPWR VGND sg13g2_decap_8
X_19405_ _10469_ net643 net188 VPWR VGND sg13g2_nand2_1
XFILLER_39_1029 VPWR VGND sg13g2_fill_1
XFILLER_23_507 VPWR VGND sg13g2_decap_8
X_16617_ net1022 VPWR _07804_ VGND net515 net760 sg13g2_o21ai_1
XFILLER_62_153 VPWR VGND sg13g2_fill_1
X_13829_ VGND VPWR _05121_ _05132_ _05153_ _05140_ sg13g2_a21oi_1
X_17597_ _08729_ _08723_ _08727_ _08730_ VPWR VGND sg13g2_a21o_1
XFILLER_51_838 VPWR VGND sg13g2_fill_2
XFILLER_16_581 VPWR VGND sg13g2_decap_4
X_19336_ _10400_ net643 net153 VPWR VGND sg13g2_nand2_1
X_16548_ _07752_ VPWR _07753_ VGND _07748_ _07749_ sg13g2_o21ai_1
XFILLER_31_551 VPWR VGND sg13g2_decap_8
X_19267_ VGND VPWR net27 _10334_ _00367_ _10335_ sg13g2_a21oi_1
XFILLER_31_573 VPWR VGND sg13g2_decap_8
X_16479_ VGND VPWR _07700_ _07701_ _00213_ net940 sg13g2_a21oi_1
XFILLER_31_584 VPWR VGND sg13g2_fill_2
X_23513__1365 VPWR VGND net1364 sg13g2_tiehi
X_18218_ _09328_ net672 net217 VPWR VGND sg13g2_nand2_1
XFILLER_79_0 VPWR VGND sg13g2_decap_4
X_19198_ _10176_ VPWR _10281_ VGND _10178_ net2086 sg13g2_o21ai_1
X_18149_ _09240_ _09257_ _09259_ VPWR VGND sg13g2_nor2_1
XFILLER_8_791 VPWR VGND sg13g2_decap_4
XFILLER_85_1005 VPWR VGND sg13g2_fill_1
XFILLER_105_818 VPWR VGND sg13g2_fill_1
X_21160_ _01775_ _01768_ _01777_ VPWR VGND sg13g2_xor2_1
X_20111_ _11152_ _11149_ _11150_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_637 VPWR VGND sg13g2_decap_8
X_21091_ _01715_ _01716_ _00432_ VPWR VGND sg13g2_nor2_1
Xfanout704 u_LMS.x_r\[0\]\[6\] net704 VPWR VGND sg13g2_buf_1
Xfanout715 u_LMS.x_r\[0\]\[0\] net715 VPWR VGND sg13g2_buf_1
Xfanout726 u_FIR.w\[8\]\[1\] net726 VPWR VGND sg13g2_buf_1
X_20042_ _11078_ VPWR _11083_ VGND _11081_ _11082_ sg13g2_o21ai_1
Xfanout737 net738 net737 VPWR VGND sg13g2_buf_1
XFILLER_86_713 VPWR VGND sg13g2_decap_8
Xfanout748 net749 net748 VPWR VGND sg13g2_buf_1
XFILLER_86_724 VPWR VGND sg13g2_fill_1
Xfanout759 u_FIR.w\[4\]\[5\] net759 VPWR VGND sg13g2_buf_1
XFILLER_112_394 VPWR VGND sg13g2_fill_1
XFILLER_86_757 VPWR VGND sg13g2_decap_8
XFILLER_58_448 VPWR VGND sg13g2_fill_1
X_23328__1274 VPWR VGND net1273 sg13g2_tiehi
XFILLER_85_245 VPWR VGND sg13g2_fill_1
X_21993_ _02559_ _02561_ _02587_ VPWR VGND sg13g2_nor2_1
XFILLER_82_930 VPWR VGND sg13g2_fill_1
X_23732_ net998 VGND VPWR _00794_ u_spi_slave.tx_cnt\[2\] net1638 sg13g2_dfrbpq_1
X_20944_ _03303_ _01583_ _01584_ VPWR VGND sg13g2_nor2_1
X_23663_ net1020 VGND VPWR _00725_ u_debug_unit.mon_w4_sync\[1\] clknet_leaf_36_clkA
+ sg13g2_dfrbpq_1
X_20875_ _01505_ _01497_ _01515_ VPWR VGND sg13g2_xor2_1
XFILLER_121_68 VPWR VGND sg13g2_decap_8
XFILLER_81_28 VPWR VGND sg13g2_decap_4
X_22614_ net466 sys_enable_bus\[3\] _03060_ _00611_ VPWR VGND sg13g2_mux2_1
X_23594_ net1017 VGND VPWR _00656_ coeff_force_packed\[35\] clknet_leaf_20_clkA sg13g2_dfrbpq_1
X_22988__1225 VPWR VGND net1224 sg13g2_tiehi
X_22545_ _03029_ u_LMS.count\[15\] u_LMS.count\[14\] _03025_ VPWR VGND sg13g2_and3_1
X_22476_ VGND VPWR net447 _03231_ _00546_ _02987_ sg13g2_a21oi_1
X_21427_ _02043_ VPWR _02044_ VGND _02014_ _02041_ sg13g2_o21ai_1
XFILLER_107_111 VPWR VGND sg13g2_fill_2
XFILLER_107_122 VPWR VGND sg13g2_fill_2
X_12160_ _03569_ net292 coeff_force_packed\[14\] net295 coeff_force_packed\[35\] VPWR
+ VGND sg13g2_a22oi_1
XFILLER_30_65 VPWR VGND sg13g2_fill_1
X_21358_ _01942_ VPWR _01975_ VGND _01933_ _01940_ sg13g2_o21ai_1
XFILLER_122_103 VPWR VGND sg13g2_fill_1
XFILLER_30_98 VPWR VGND sg13g2_decap_4
X_20309_ _00972_ u_LMS.w\[5\]\[19\] net75 VPWR VGND sg13g2_xnor2_1
X_12091_ _03503_ _03438_ u_debug_unit.error_signal_sync\[3\] _03407_ u_debug_unit.mon_w1_sync\[3\]
+ VPWR VGND sg13g2_a22oi_1
X_21289_ _01906_ _01872_ _01905_ VPWR VGND sg13g2_xnor2_1
XFILLER_2_978 VPWR VGND sg13g2_decap_8
X_23028_ net1164 VGND VPWR _00090_ u_FIR.sum\[2\]\[9\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
XFILLER_77_724 VPWR VGND sg13g2_fill_2
XFILLER_39_52 VPWR VGND sg13g2_decap_8
XFILLER_131_681 VPWR VGND sg13g2_fill_2
XFILLER_7_1038 VPWR VGND sg13g2_decap_8
X_15850_ _07098_ _07090_ _07096_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_256 VPWR VGND sg13g2_decap_8
X_14801_ VGND VPWR _06051_ _06066_ _06088_ _06075_ sg13g2_a21oi_1
XFILLER_36_109 VPWR VGND sg13g2_fill_2
X_15781_ _07031_ _07023_ _07030_ VPWR VGND sg13g2_nand2_1
XFILLER_64_429 VPWR VGND sg13g2_decap_4
X_12993_ _04350_ _04341_ _04349_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_749 VPWR VGND sg13g2_fill_1
X_17520_ VGND VPWR _08653_ _08639_ _08637_ sg13g2_or2_1
X_14732_ u_FIR.w\[3\]\[2\] net806 u_FIR.w\[3\]\[3\] _06021_ VPWR VGND sg13g2_nand3_1
XFILLER_73_952 VPWR VGND sg13g2_decap_4
X_11944_ VPWR _03365_ u_FIR.w\[4\]\[6\] VGND sg13g2_inv_1
XFILLER_73_963 VPWR VGND sg13g2_decap_8
X_23138__1583 VPWR VGND net1582 sg13g2_tiehi
XFILLER_17_367 VPWR VGND sg13g2_fill_1
X_17451_ _03269_ net139 _08584_ VPWR VGND sg13g2_nor2_1
XFILLER_60_613 VPWR VGND sg13g2_fill_2
X_14663_ _05954_ u_FIR.sum\[4\]\[7\] net398 VPWR VGND sg13g2_xnor2_1
X_11875_ VPWR _03296_ net716 VGND sg13g2_inv_1
XFILLER_44_175 VPWR VGND sg13g2_fill_2
XFILLER_33_849 VPWR VGND sg13g2_decap_8
X_16402_ _07633_ _07632_ _07612_ VPWR VGND sg13g2_nand2b_1
X_13614_ VGND VPWR net756 net826 _04944_ u_FIR.sum\[2\]\[6\] sg13g2_a21oi_1
X_17382_ net72 u_LMS.w\[0\]\[20\] _08530_ VPWR VGND sg13g2_xor2_1
X_14594_ VGND VPWR _05885_ _05886_ _05887_ net412 sg13g2_a21oi_1
X_19121_ _10208_ _10206_ _10207_ VPWR VGND sg13g2_nand2b_1
X_16333_ _07566_ net271 _07567_ VPWR VGND sg13g2_xor2_1
X_13545_ _04877_ _04869_ _04876_ VPWR VGND sg13g2_nand2_1
X_19052_ _10038_ _10037_ _10139_ VPWR VGND sg13g2_xor2_1
X_16264_ VPWR _07500_ _07499_ VGND sg13g2_inv_1
X_13476_ VGND VPWR _04810_ _04811_ _04812_ net416 sg13g2_a21oi_1
XFILLER_127_910 VPWR VGND sg13g2_decap_8
X_18003_ _09075_ _09079_ _09128_ VPWR VGND sg13g2_nor2_1
X_15215_ _06486_ _06451_ _06484_ VPWR VGND sg13g2_xnor2_1
X_12427_ _03804_ net723 u_FIR.w\[8\]\[2\] net812 VPWR VGND sg13g2_and3_1
X_16195_ _07433_ _07404_ _07432_ VPWR VGND sg13g2_nand2b_1
X_15146_ _03370_ net889 _06418_ VPWR VGND sg13g2_nor2_1
X_12358_ _03731_ _03736_ _03737_ VPWR VGND sg13g2_nor2b_1
XFILLER_5_772 VPWR VGND sg13g2_decap_8
XFILLER_5_794 VPWR VGND sg13g2_decap_8
X_19954_ _10995_ _10988_ _10994_ VPWR VGND sg13g2_nand2_1
X_15077_ _06351_ _06343_ _06350_ VPWR VGND sg13g2_nand2_1
X_12289_ _03670_ _03637_ _03668_ VPWR VGND sg13g2_xnor2_1
X_18905_ _09992_ _09955_ _09956_ VPWR VGND sg13g2_xnor2_1
X_14028_ VGND VPWR net493 _05340_ _00122_ _05341_ sg13g2_a21oi_1
X_19885_ net359 VPWR _10929_ VGND u_LMS.w\[4\]\[9\] net376 sg13g2_o21ai_1
XFILLER_132_1003 VPWR VGND sg13g2_decap_8
XFILLER_110_832 VPWR VGND sg13g2_decap_8
XFILLER_68_746 VPWR VGND sg13g2_fill_1
XFILLER_67_223 VPWR VGND sg13g2_fill_2
X_18836_ _09923_ _09889_ _09922_ VPWR VGND sg13g2_xnor2_1
XFILLER_67_278 VPWR VGND sg13g2_fill_1
X_18767_ _09854_ _09852_ _09853_ VPWR VGND sg13g2_xnor2_1
X_15979_ _07187_ VPWR _07221_ VGND u_FIR.sum\[6\]\[17\] _07186_ sg13g2_o21ai_1
X_17718_ _08849_ _08850_ _08851_ VPWR VGND sg13g2_nor2_1
X_18698_ VPWR _09785_ _09784_ VGND sg13g2_inv_1
XFILLER_36_654 VPWR VGND sg13g2_fill_2
X_17649_ _08782_ _08778_ _08779_ VPWR VGND sg13g2_xnor2_1
XFILLER_23_337 VPWR VGND sg13g2_decap_8
X_20660_ VGND VPWR _01300_ _01299_ _01294_ sg13g2_or2_1
X_19319_ _10381_ _10374_ _10383_ VPWR VGND sg13g2_xor2_1
XFILLER_52_1026 VPWR VGND sg13g2_decap_4
X_20591_ _01230_ _01200_ _01231_ VPWR VGND sg13g2_xor2_1
X_22330_ VGND VPWR net47 _02907_ _02908_ net6 sg13g2_a21oi_1
XFILLER_52_1059 VPWR VGND sg13g2_fill_2
X_22261_ VGND VPWR _02852_ _02853_ _00465_ net924 sg13g2_a21oi_1
X_21212_ _01809_ _01827_ _01829_ VPWR VGND sg13g2_nor2_1
XFILLER_117_453 VPWR VGND sg13g2_fill_1
XFILLER_105_615 VPWR VGND sg13g2_fill_2
X_22192_ u_LMS.w\[8\]\[3\] _02783_ _02786_ VPWR VGND sg13g2_nor2_1
XFILLER_132_412 VPWR VGND sg13g2_decap_8
X_21143_ _01757_ _01759_ _01760_ VPWR VGND sg13g2_nor2_1
XFILLER_132_456 VPWR VGND sg13g2_decap_8
Xfanout501 net502 net501 VPWR VGND sg13g2_buf_1
Xfanout512 net513 net512 VPWR VGND sg13g2_buf_1
X_21074_ _01650_ VPWR _01703_ VGND _01649_ _01651_ sg13g2_o21ai_1
Xfanout523 net549 net523 VPWR VGND sg13g2_buf_1
Xfanout534 net535 net534 VPWR VGND sg13g2_buf_1
XFILLER_98_370 VPWR VGND sg13g2_fill_1
XFILLER_116_68 VPWR VGND sg13g2_decap_8
Xfanout545 net547 net545 VPWR VGND sg13g2_buf_1
Xfanout556 sys_enable net556 VPWR VGND sg13g2_buf_1
X_20025_ _11066_ _11064_ _11065_ VPWR VGND sg13g2_nand2_1
XFILLER_76_39 VPWR VGND sg13g2_fill_2
XFILLER_58_223 VPWR VGND sg13g2_decap_8
XFILLER_101_854 VPWR VGND sg13g2_decap_8
Xfanout567 net568 net567 VPWR VGND sg13g2_buf_1
XFILLER_112_191 VPWR VGND sg13g2_fill_1
Xfanout578 u_LMS.x_r\[8\]\[4\] net578 VPWR VGND sg13g2_buf_1
XFILLER_59_768 VPWR VGND sg13g2_decap_4
Xfanout589 net590 net589 VPWR VGND sg13g2_buf_1
XFILLER_58_267 VPWR VGND sg13g2_decap_4
XFILLER_73_204 VPWR VGND sg13g2_decap_4
XFILLER_6_1060 VPWR VGND sg13g2_fill_1
XFILLER_58_278 VPWR VGND sg13g2_decap_8
XFILLER_100_386 VPWR VGND sg13g2_fill_2
XFILLER_73_226 VPWR VGND sg13g2_fill_2
XFILLER_132_56 VPWR VGND sg13g2_decap_8
XFILLER_27_643 VPWR VGND sg13g2_fill_1
X_21976_ _02494_ _02493_ _02570_ VPWR VGND sg13g2_xor2_1
XFILLER_73_259 VPWR VGND sg13g2_decap_8
XFILLER_70_911 VPWR VGND sg13g2_decap_4
X_20927_ _01567_ _01563_ _01542_ VPWR VGND sg13g2_xnor2_1
X_23715_ net1417 VGND VPWR _00777_ u_FIR.x\[4\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
XFILLER_82_793 VPWR VGND sg13g2_fill_1
XFILLER_41_101 VPWR VGND sg13g2_decap_8
XFILLER_41_112 VPWR VGND sg13g2_fill_2
X_20858_ _01498_ net261 net615 net245 net617 VPWR VGND sg13g2_a22oi_1
X_23646_ net974 VGND VPWR _00708_ u_debug_unit.mon_w1_sync\[5\] clknet_leaf_49_clkA
+ sg13g2_dfrbpq_1
XFILLER_14_359 VPWR VGND sg13g2_fill_2
XFILLER_109_1049 VPWR VGND sg13g2_decap_8
XFILLER_30_819 VPWR VGND sg13g2_fill_2
X_23577_ net964 VGND VPWR _00639_ u_debug_unit.force_w2\[7\] clknet_leaf_17_clkA sg13g2_dfrbpq_1
X_20789_ VGND VPWR _01429_ _01428_ _01427_ sg13g2_or2_1
X_13330_ _04669_ _04671_ _04674_ VPWR VGND sg13g2_nor2_1
X_22528_ u_LMS.count\[9\] _03017_ _03018_ VPWR VGND sg13g2_nor2_1
XFILLER_128_729 VPWR VGND sg13g2_decap_8
XFILLER_109_932 VPWR VGND sg13g2_decap_8
X_13261_ _04607_ _04599_ _04606_ VPWR VGND sg13g2_xnor2_1
X_22459_ net961 VPWR _02979_ VGND net450 net615 sg13g2_o21ai_1
XFILLER_68_1000 VPWR VGND sg13g2_fill_1
X_15000_ _06275_ _06276_ _06277_ VPWR VGND sg13g2_nor2_1
X_12212_ _03597_ _03594_ _03596_ u_FIR.sum\[0\]\[1\] net413 VPWR VGND sg13g2_a22oi_1
X_13192_ u_FIR.w\[6\]\[0\] net813 _04540_ VPWR VGND sg13g2_and2_1
XFILLER_124_924 VPWR VGND sg13g2_fill_1
X_12143_ _03547_ _03548_ _03539_ _03553_ VPWR VGND _03552_ sg13g2_nand4_1
XFILLER_9_0 VPWR VGND sg13g2_decap_8
X_16951_ _08107_ _08106_ _08104_ VPWR VGND sg13g2_nand2b_1
X_12074_ _03487_ net289 coeff_force_packed\[25\] net290 coeff_force_packed\[4\] VPWR
+ VGND sg13g2_a22oi_1
XFILLER_2_775 VPWR VGND sg13g2_fill_1
XFILLER_104_681 VPWR VGND sg13g2_fill_1
X_23427__1068 VPWR VGND net1067 sg13g2_tiehi
XFILLER_1_274 VPWR VGND sg13g2_decap_8
XFILLER_89_381 VPWR VGND sg13g2_fill_1
XFILLER_49_212 VPWR VGND sg13g2_decap_4
XFILLER_2_14 VPWR VGND sg13g2_decap_8
X_15902_ _07134_ VPWR _07148_ VGND net274 _07132_ sg13g2_o21ai_1
X_19670_ _10734_ _10530_ _10497_ VPWR VGND sg13g2_nand2b_1
XFILLER_103_191 VPWR VGND sg13g2_decap_8
X_16882_ _08038_ _08031_ _08037_ VPWR VGND sg13g2_nand2_1
X_18621_ VGND VPWR _09670_ _09672_ _09720_ _09671_ sg13g2_a21oi_1
X_15833_ _07052_ _07081_ _07082_ VPWR VGND sg13g2_nor2b_1
XFILLER_37_418 VPWR VGND sg13g2_fill_1
XFILLER_18_610 VPWR VGND sg13g2_decap_4
XFILLER_18_621 VPWR VGND sg13g2_decap_8
XFILLER_92_546 VPWR VGND sg13g2_fill_2
XFILLER_18_632 VPWR VGND sg13g2_fill_1
X_18552_ _09662_ net2091 _09661_ VPWR VGND sg13g2_nand2_1
XFILLER_66_94 VPWR VGND sg13g2_fill_2
X_15764_ net929 _07014_ _00185_ VPWR VGND sg13g2_nor2_1
X_12976_ _04313_ _04333_ _04334_ VPWR VGND sg13g2_nor2_1
XFILLER_45_440 VPWR VGND sg13g2_fill_1
XFILLER_17_142 VPWR VGND sg13g2_decap_8
X_17503_ _08636_ net689 net147 VPWR VGND sg13g2_nand2_1
XFILLER_17_153 VPWR VGND sg13g2_fill_2
X_14715_ VGND VPWR _06003_ _06004_ _06005_ net412 sg13g2_a21oi_1
X_18483_ _09593_ _09560_ _09562_ VPWR VGND sg13g2_xnor2_1
X_11927_ VPWR _03348_ u_LMS.w\[1\]\[14\] VGND sg13g2_inv_1
X_15695_ _06947_ _06941_ _06945_ VPWR VGND sg13g2_xnor2_1
XFILLER_17_175 VPWR VGND sg13g2_decap_8
XFILLER_17_186 VPWR VGND sg13g2_fill_1
X_17434_ _08571_ _08447_ _08449_ VPWR VGND sg13g2_xnor2_1
XFILLER_33_657 VPWR VGND sg13g2_decap_4
X_14646_ _05935_ _05936_ _05937_ VPWR VGND sg13g2_and2_1
XFILLER_21_808 VPWR VGND sg13g2_fill_2
X_11858_ VPWR _03279_ net708 VGND sg13g2_inv_1
X_17365_ VGND VPWR _08515_ _08516_ _00284_ net934 sg13g2_a21oi_1
XFILLER_14_882 VPWR VGND sg13g2_fill_1
X_14577_ _05870_ _05834_ _05868_ VPWR VGND sg13g2_xnor2_1
X_11789_ VPWR _03210_ u_s2p_input.reg_sh\[0\] VGND sg13g2_inv_1
XFILLER_32_189 VPWR VGND sg13g2_decap_8
XFILLER_41_690 VPWR VGND sg13g2_fill_1
X_19104_ _10191_ _10128_ _10130_ VPWR VGND sg13g2_xnor2_1
X_16316_ _07537_ VPWR _07550_ VGND net271 _07535_ sg13g2_o21ai_1
X_13528_ _04860_ net750 net904 VPWR VGND sg13g2_nand2_1
X_17296_ _08419_ u_LMS.w\[0\]\[9\] _08452_ VPWR VGND sg13g2_xor2_1
X_19035_ _10122_ _10096_ _10121_ VPWR VGND sg13g2_xnor2_1
X_16247_ _07453_ _07446_ _07460_ _07483_ VPWR VGND sg13g2_a21o_1
X_13459_ _04777_ _04780_ _04798_ _04799_ VPWR VGND sg13g2_or3_1
XFILLER_127_762 VPWR VGND sg13g2_decap_4
X_16178_ _03376_ net410 _07376_ _07416_ VPWR VGND sg13g2_nor3_1
XFILLER_115_935 VPWR VGND sg13g2_decap_8
X_15129_ _06375_ _06401_ _06402_ VPWR VGND sg13g2_nor2_1
XFILLER_99_134 VPWR VGND sg13g2_fill_2
XFILLER_114_456 VPWR VGND sg13g2_decap_8
X_19937_ VGND VPWR _10954_ _10956_ _10978_ _10976_ sg13g2_a21oi_1
X_19868_ VGND VPWR net53 _10915_ _10916_ net24 sg13g2_a21oi_1
XFILLER_68_587 VPWR VGND sg13g2_fill_1
X_18819_ _09904_ _09905_ _09906_ VPWR VGND sg13g2_and2_1
XFILLER_110_695 VPWR VGND sg13g2_decap_8
X_19799_ _10861_ net2133 _10804_ VPWR VGND sg13g2_xnor2_1
X_21830_ VPWR _02424_ _02423_ VGND sg13g2_inv_1
XFILLER_71_708 VPWR VGND sg13g2_fill_1
XFILLER_70_207 VPWR VGND sg13g2_fill_2
XFILLER_64_771 VPWR VGND sg13g2_decap_4
X_21761_ _02355_ _02354_ _02349_ VPWR VGND sg13g2_nand2b_1
X_20712_ _01352_ _01337_ _01351_ VPWR VGND sg13g2_nand2_1
X_23500_ net1412 VGND VPWR _00562_ u_LMS.count\[3\] clknet_leaf_62_clkA sg13g2_dfrbpq_1
XFILLER_23_123 VPWR VGND sg13g2_decap_4
X_21692_ net13 VPWR _02298_ VGND _02252_ _02297_ sg13g2_o21ai_1
XFILLER_24_679 VPWR VGND sg13g2_decap_4
XFILLER_12_819 VPWR VGND sg13g2_fill_1
XFILLER_11_307 VPWR VGND sg13g2_decap_8
X_23431_ net1055 VGND VPWR _00493_ u_LMS.x_r\[0\]\[6\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
X_20643_ _01283_ net614 net136 VPWR VGND sg13g2_nand2_1
XFILLER_108_1060 VPWR VGND sg13g2_fill_1
XFILLER_20_841 VPWR VGND sg13g2_fill_1
X_23362_ net1239 VGND VPWR _00424_ u_LMS.w\[6\]\[18\] clknet_leaf_14_clkA sg13g2_dfrbpq_1
X_20574_ _01214_ _01200_ _01212_ VPWR VGND sg13g2_xnor2_1
X_22313_ _02894_ VPWR _02895_ VGND net716 net61 sg13g2_o21ai_1
XFILLER_20_885 VPWR VGND sg13g2_fill_1
XFILLER_20_896 VPWR VGND sg13g2_decap_4
X_23293_ net1310 VGND VPWR _00355_ u_LMS.w\[3\]\[18\] clknet_leaf_52_clkA sg13g2_dfrbpq_1
X_22244_ VPWR _02838_ _02837_ VGND sg13g2_inv_1
XFILLER_118_795 VPWR VGND sg13g2_decap_4
XFILLER_132_220 VPWR VGND sg13g2_decap_8
XFILLER_127_56 VPWR VGND sg13g2_decap_8
X_22175_ _02769_ _02704_ _02705_ VPWR VGND sg13g2_xnor2_1
XFILLER_87_27 VPWR VGND sg13g2_decap_4
XFILLER_2_7 VPWR VGND sg13g2_decap_8
X_21126_ _01743_ net169 net591 net181 net589 VPWR VGND sg13g2_a22oi_1
XFILLER_120_404 VPWR VGND sg13g2_fill_1
Xfanout320 _08500_ net320 VPWR VGND sg13g2_buf_1
XFILLER_121_949 VPWR VGND sg13g2_fill_2
Xfanout331 net332 net331 VPWR VGND sg13g2_buf_1
XFILLER_132_297 VPWR VGND sg13g2_decap_8
XFILLER_120_437 VPWR VGND sg13g2_decap_8
Xfanout342 net343 net342 VPWR VGND sg13g2_buf_1
XFILLER_120_448 VPWR VGND sg13g2_fill_1
X_21057_ _01690_ net314 u_LMS.w\[6\]\[19\] coeff_force_packed\[48\] net567 VPWR VGND
+ sg13g2_a22oi_1
Xfanout353 _03070_ net353 VPWR VGND sg13g2_buf_1
Xfanout364 net365 net364 VPWR VGND sg13g2_buf_1
Xfanout375 net376 net375 VPWR VGND sg13g2_buf_1
X_20008_ _11049_ _10976_ _11046_ VPWR VGND sg13g2_xnor2_1
Xfanout386 net389 net386 VPWR VGND sg13g2_buf_1
XFILLER_19_418 VPWR VGND sg13g2_decap_8
Xfanout397 _05952_ net397 VPWR VGND sg13g2_buf_1
XFILLER_46_215 VPWR VGND sg13g2_decap_8
XFILLER_19_429 VPWR VGND sg13g2_fill_1
XFILLER_46_226 VPWR VGND sg13g2_fill_2
X_12830_ _04192_ u_FIR.sum\[0\]\[9\] net407 VPWR VGND sg13g2_nand2_1
XFILLER_46_248 VPWR VGND sg13g2_decap_8
XFILLER_36_31 VPWR VGND sg13g2_decap_4
XFILLER_74_579 VPWR VGND sg13g2_fill_1
XFILLER_61_207 VPWR VGND sg13g2_fill_2
X_12761_ _04124_ _04089_ _04125_ VPWR VGND sg13g2_xor2_1
X_21959_ _02527_ VPWR _02553_ VGND _02522_ _02523_ sg13g2_o21ai_1
XFILLER_36_86 VPWR VGND sg13g2_decap_4
X_23436__1626 VPWR VGND net1625 sg13g2_tiehi
X_14500_ VPWR _05796_ _05795_ VGND sg13g2_inv_1
X_15480_ _06741_ _06739_ _06740_ VPWR VGND sg13g2_xnor2_1
X_12692_ _03360_ net910 _04057_ VPWR VGND sg13g2_nor2_1
XFILLER_43_988 VPWR VGND sg13g2_decap_8
XFILLER_30_605 VPWR VGND sg13g2_fill_2
X_23515__1357 VPWR VGND net1356 sg13g2_tiehi
X_14431_ net1006 VPWR _05733_ VGND net512 u_FIR.sum\[4\]\[15\] sg13g2_o21ai_1
XFILLER_30_627 VPWR VGND sg13g2_decap_4
XFILLER_14_178 VPWR VGND sg13g2_fill_1
X_23629_ net974 VGND VPWR _00691_ u_debug_unit.error_signal_sync\[3\] clknet_leaf_48_clkA
+ sg13g2_dfrbpq_1
X_23495__1430 VPWR VGND net1429 sg13g2_tiehi
XFILLER_11_841 VPWR VGND sg13g2_decap_8
X_17150_ _08306_ net710 net263 VPWR VGND sg13g2_nand2_1
X_14362_ VGND VPWR _05635_ _05658_ _05666_ _05657_ sg13g2_a21oi_1
XFILLER_11_863 VPWR VGND sg13g2_decap_4
XFILLER_11_874 VPWR VGND sg13g2_fill_1
X_16101_ _07340_ _07336_ _07341_ VPWR VGND sg13g2_xor2_1
X_13313_ VPWR _04658_ _04657_ VGND sg13g2_inv_1
XFILLER_122_1057 VPWR VGND sg13g2_decap_4
X_17081_ VGND VPWR _08220_ net2193 _08237_ _08219_ sg13g2_a21oi_1
X_14293_ VGND VPWR net507 _05598_ _00129_ _05599_ sg13g2_a21oi_1
XFILLER_10_384 VPWR VGND sg13g2_fill_2
XFILLER_6_355 VPWR VGND sg13g2_decap_8
X_16032_ net886 u_FIR.sum\[7\]\[1\] net801 _07273_ VPWR VGND sg13g2_nand3_1
X_13244_ _04550_ _04552_ _04590_ _04591_ VPWR VGND sg13g2_or3_1
X_13175_ net884 _04522_ net740 _04523_ VPWR VGND sg13g2_nand3_1
XFILLER_124_754 VPWR VGND sg13g2_fill_2
X_12126_ _00019_ VPWR _03537_ VGND u_spi_slave.tx_shift\[9\] _03386_ sg13g2_o21ai_1
X_17983_ VPWR VGND _09046_ _09092_ _09111_ _09089_ _09112_ _09095_ sg13g2_a221oi_1
X_19722_ _10763_ u_LMS.w\[4\]\[7\] _10785_ _10786_ VPWR VGND sg13g2_a21o_1
XFILLER_42_1003 VPWR VGND sg13g2_fill_1
X_16934_ _08090_ net122 _08088_ VPWR VGND sg13g2_xnor2_1
X_12057_ _03471_ net289 coeff_force_packed\[26\] _03418_ u_debug_unit.mon_w2_sync\[5\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_78_863 VPWR VGND sg13g2_fill_2
X_19653_ VGND VPWR _10715_ _10716_ _10717_ _10692_ sg13g2_a21oi_1
X_16865_ _07998_ net122 _07995_ _08021_ VPWR VGND sg13g2_nand3_1
XFILLER_92_310 VPWR VGND sg13g2_decap_8
XFILLER_38_749 VPWR VGND sg13g2_decap_8
X_18604_ VGND VPWR u_LMS.w\[2\]\[19\] net302 _09707_ _09702_ sg13g2_a21oi_1
X_15816_ _07065_ _07057_ _07064_ VPWR VGND sg13g2_nand2_1
X_19584_ _10640_ _10636_ _10647_ _10648_ VPWR VGND sg13g2_a21o_1
XFILLER_37_259 VPWR VGND sg13g2_decap_8
X_16796_ net912 net2065 _07952_ VPWR VGND sg13g2_and2_1
XFILLER_34_911 VPWR VGND sg13g2_fill_1
X_18535_ _09645_ _09644_ _09599_ VPWR VGND sg13g2_nand2b_1
XFILLER_93_70 VPWR VGND sg13g2_decap_8
X_15747_ VPWR _06998_ _06997_ VGND sg13g2_inv_1
X_12959_ _04317_ u_FIR.w\[7\]\[6\] net815 VPWR VGND sg13g2_nand2b_1
XFILLER_45_270 VPWR VGND sg13g2_fill_2
XFILLER_33_421 VPWR VGND sg13g2_fill_1
X_23179__1518 VPWR VGND net1517 sg13g2_tiehi
X_23207__1469 VPWR VGND net1468 sg13g2_tiehi
X_18466_ _09575_ VPWR _09576_ VGND net420 _09226_ sg13g2_o21ai_1
X_15678_ _06897_ _06930_ _06931_ VPWR VGND sg13g2_nor2_1
XFILLER_33_454 VPWR VGND sg13g2_fill_1
X_17417_ _08557_ _08558_ _00294_ VPWR VGND sg13g2_nor2_1
XFILLER_33_487 VPWR VGND sg13g2_decap_8
X_14629_ _05889_ _05920_ _05921_ VPWR VGND sg13g2_nor2_1
X_18397_ _09507_ _09480_ _09506_ VPWR VGND sg13g2_nand2_1
XFILLER_60_284 VPWR VGND sg13g2_fill_2
X_17348_ _08463_ _08462_ _08503_ VPWR VGND sg13g2_xor2_1
X_17279_ _08431_ VPWR _08435_ VGND _08432_ _08433_ sg13g2_o21ai_1
XFILLER_61_0 VPWR VGND sg13g2_decap_8
XFILLER_106_209 VPWR VGND sg13g2_decap_4
X_19018_ _10104_ VPWR _10105_ VGND _10095_ _10097_ sg13g2_o21ai_1
X_20290_ _11090_ _00948_ _00953_ VPWR VGND _11089_ sg13g2_nand3b_1
XFILLER_115_765 VPWR VGND sg13g2_fill_2
XFILLER_130_702 VPWR VGND sg13g2_fill_2
XFILLER_102_426 VPWR VGND sg13g2_decap_8
XFILLER_102_437 VPWR VGND sg13g2_fill_2
XFILLER_111_993 VPWR VGND sg13g2_decap_4
X_22931_ spi_addr\[2\] net325 _03195_ VPWR VGND sg13g2_nor2_1
XFILLER_113_25 VPWR VGND sg13g2_decap_8
XFILLER_28_237 VPWR VGND sg13g2_decap_8
XFILLER_44_708 VPWR VGND sg13g2_fill_2
X_22862_ net950 VPWR _03155_ VGND u_p2s_output.reg_sh\[4\] net300 sg13g2_o21ai_1
X_21813_ _02407_ net574 net149 VPWR VGND sg13g2_nand2_1
X_22793_ VGND VPWR _07824_ net350 _00736_ _03114_ sg13g2_a21oi_1
XFILLER_36_270 VPWR VGND sg13g2_fill_1
XFILLER_64_590 VPWR VGND sg13g2_decap_4
X_23365__1237 VPWR VGND net1236 sg13g2_tiehi
X_21744_ _02335_ _02337_ _02338_ VPWR VGND sg13g2_nor2_1
XFILLER_25_988 VPWR VGND sg13g2_decap_8
XFILLER_19_1049 VPWR VGND sg13g2_decap_8
X_21675_ _02284_ _02234_ _02283_ VPWR VGND sg13g2_nand2_1
XFILLER_51_295 VPWR VGND sg13g2_decap_4
XFILLER_11_126 VPWR VGND sg13g2_fill_2
X_20626_ VPWR _01266_ _01265_ VGND sg13g2_inv_1
X_23414_ net1106 VGND VPWR _00476_ u_LMS.w\[8\]\[24\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
X_23345_ net1256 VGND VPWR _00407_ u_LMS.w\[5\]\[24\] clknet_leaf_23_clkA sg13g2_dfrbpq_1
X_20557_ _01165_ VPWR _01197_ VGND _03232_ _01173_ sg13g2_o21ai_1
X_23242__1407 VPWR VGND net1406 sg13g2_tiehi
XFILLER_20_693 VPWR VGND sg13g2_decap_8
X_23276_ net1341 VGND VPWR _00338_ u_LMS.w\[2\]\[24\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
X_20488_ net363 VPWR _01134_ VGND u_LMS.w\[5\]\[6\] net381 sg13g2_o21ai_1
XFILLER_118_581 VPWR VGND sg13g2_decap_8
X_22227_ _02759_ _02761_ _02820_ _02821_ VPWR VGND sg13g2_nor3_2
XFILLER_105_242 VPWR VGND sg13g2_decap_8
XFILLER_106_787 VPWR VGND sg13g2_fill_2
XFILLER_106_798 VPWR VGND sg13g2_fill_1
X_22158_ _02736_ _02751_ _02752_ VPWR VGND sg13g2_xor2_1
XFILLER_121_724 VPWR VGND sg13g2_decap_4
X_21109_ VGND VPWR _01657_ _01729_ _01730_ net14 sg13g2_a21oi_1
XFILLER_78_148 VPWR VGND sg13g2_fill_1
X_22089_ net586 net240 net584 _02683_ VPWR VGND net203 sg13g2_nand4_1
X_14980_ VGND VPWR net510 _06258_ _00156_ _06259_ sg13g2_a21oi_1
Xfanout150 net152 net150 VPWR VGND sg13g2_buf_1
XFILLER_120_256 VPWR VGND sg13g2_decap_4
Xfanout161 net162 net161 VPWR VGND sg13g2_buf_1
Xfanout172 net173 net172 VPWR VGND sg13g2_buf_2
Xfanout183 net184 net183 VPWR VGND sg13g2_buf_1
X_13931_ u_FIR.sum\[2\]\[16\] net402 _05251_ VPWR VGND sg13g2_nor2_1
Xfanout194 net1654 net194 VPWR VGND sg13g2_buf_2
X_16650_ u_LMS.w\[6\]\[19\] u_LMS.w\[6\]\[18\] u_LMS.w\[6\]\[20\] _07827_ VPWR VGND
+ sg13g2_nand3_1
X_13862_ VGND VPWR _05154_ _05165_ _05185_ _05172_ sg13g2_a21oi_1
X_15601_ VGND VPWR _06854_ _06855_ _06856_ net411 sg13g2_a21oi_1
X_12813_ _03360_ net869 _04175_ VPWR VGND sg13g2_nor2_1
X_16581_ net991 VPWR _07778_ VGND net490 net772 sg13g2_o21ai_1
X_13793_ VGND VPWR _05082_ _05110_ _05118_ _05109_ sg13g2_a21oi_1
X_18320_ _09430_ _09425_ _09428_ VPWR VGND sg13g2_xnor2_1
X_15532_ _06787_ _06788_ _06789_ VPWR VGND sg13g2_nor2b_1
X_12744_ _04108_ _04102_ _04107_ VPWR VGND sg13g2_xnor2_1
XFILLER_63_51 VPWR VGND sg13g2_fill_2
X_18251_ _09360_ VPWR _09361_ VGND _09335_ _09358_ sg13g2_o21ai_1
XFILLER_31_936 VPWR VGND sg13g2_decap_4
X_15463_ _06725_ net276 _06724_ VPWR VGND sg13g2_xnor2_1
X_12675_ _04041_ _04002_ _04039_ VPWR VGND sg13g2_xnor2_1
X_17202_ _08356_ _08357_ _08358_ VPWR VGND sg13g2_nor2b_1
X_14414_ _05716_ u_FIR.sum\[3\]\[15\] net399 VPWR VGND sg13g2_xnor2_1
XFILLER_8_35 VPWR VGND sg13g2_decap_8
X_18182_ _09288_ _09290_ _09261_ _09292_ VPWR VGND sg13g2_nand3_1
X_15394_ _06658_ _06636_ _06660_ VPWR VGND sg13g2_xor2_1
X_17133_ _08289_ _08265_ _08288_ VPWR VGND sg13g2_nand2_1
XFILLER_8_79 VPWR VGND sg13g2_decap_8
X_14345_ _05650_ u_FIR.sum\[3\]\[12\] net400 VPWR VGND sg13g2_nand2_1
XFILLER_116_518 VPWR VGND sg13g2_fill_1
X_17064_ _08218_ _08209_ _08220_ VPWR VGND sg13g2_xor2_1
X_14276_ _05539_ VPWR _05583_ VGND _05497_ _05537_ sg13g2_o21ai_1
XFILLER_109_581 VPWR VGND sg13g2_fill_1
XFILLER_7_697 VPWR VGND sg13g2_fill_2
X_16015_ _07256_ net795 net900 VPWR VGND sg13g2_nand2_1
X_13227_ _04567_ _04573_ _04574_ VPWR VGND sg13g2_nor2b_1
XFILLER_112_702 VPWR VGND sg13g2_fill_2
XFILLER_112_724 VPWR VGND sg13g2_decap_8
X_13158_ _04505_ _04479_ _04507_ VPWR VGND sg13g2_xor2_1
XFILLER_3_881 VPWR VGND sg13g2_decap_8
XFILLER_112_735 VPWR VGND sg13g2_fill_2
XFILLER_97_435 VPWR VGND sg13g2_fill_1
XFILLER_112_768 VPWR VGND sg13g2_fill_2
X_12109_ _03520_ u_spi_slave.tx_shift\[10\] _03392_ VPWR VGND sg13g2_nand2_1
X_17966_ net41 VPWR _09099_ VGND net38 _09098_ sg13g2_o21ai_1
X_13089_ net1025 VPWR _04440_ VGND net522 u_FIR.sum\[2\]\[4\] sg13g2_o21ai_1
X_19705_ _10709_ _10768_ _10769_ VPWR VGND sg13g2_nor2_1
X_16917_ VGND VPWR net704 net193 _08073_ _08069_ sg13g2_a21oi_1
X_23087__1076 VPWR VGND net1075 sg13g2_tiehi
X_17897_ _08998_ VPWR _09030_ VGND _09027_ _09028_ sg13g2_o21ai_1
XFILLER_93_652 VPWR VGND sg13g2_fill_1
X_19636_ _10700_ _10695_ _10699_ VPWR VGND sg13g2_nand2_1
X_16848_ _08002_ _07988_ _08004_ VPWR VGND sg13g2_xor2_1
XFILLER_65_354 VPWR VGND sg13g2_decap_8
XFILLER_93_674 VPWR VGND sg13g2_decap_8
XFILLER_93_696 VPWR VGND sg13g2_fill_1
XFILLER_53_527 VPWR VGND sg13g2_decap_4
XFILLER_25_218 VPWR VGND sg13g2_fill_2
X_19567_ _10630_ _10601_ _10631_ VPWR VGND sg13g2_xor2_1
XFILLER_92_173 VPWR VGND sg13g2_fill_1
X_16779_ _07935_ net913 _07933_ VPWR VGND sg13g2_nand2b_1
XFILLER_92_184 VPWR VGND sg13g2_decap_8
XFILLER_18_270 VPWR VGND sg13g2_fill_2
XFILLER_46_590 VPWR VGND sg13g2_decap_8
X_18518_ _09627_ VPWR _09628_ VGND _03339_ _09609_ sg13g2_o21ai_1
X_19498_ _10528_ _10523_ _10562_ VPWR VGND sg13g2_xor2_1
XFILLER_22_936 VPWR VGND sg13g2_fill_1
X_18449_ _09559_ _09555_ _09558_ VPWR VGND sg13g2_nand2_1
XFILLER_18_1060 VPWR VGND sg13g2_fill_1
X_21460_ VGND VPWR _02074_ _02076_ _02077_ _02073_ sg13g2_a21oi_1
XFILLER_119_301 VPWR VGND sg13g2_fill_2
XFILLER_105_1041 VPWR VGND sg13g2_fill_2
X_20411_ _01074_ net1666 _01033_ VPWR VGND sg13g2_xnor2_1
X_21391_ _02007_ _01996_ _02008_ VPWR VGND sg13g2_nor2b_1
X_23130_ net1594 VGND VPWR _00192_ u_FIR.sum\[7\]\[16\] clknet_leaf_43_clkA sg13g2_dfrbpq_1
X_23714__1425 VPWR VGND net1424 sg13g2_tiehi
X_20342_ u_LMS.w\[5\]\[3\] _01002_ _01005_ VPWR VGND sg13g2_nor2_1
X_23376__1221 VPWR VGND net1220 sg13g2_tiehi
X_23061_ net1114 VGND VPWR _00123_ u_FIR.sum\[4\]\[4\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
X_20273_ VGND VPWR _00865_ _00936_ _00935_ _00934_ sg13g2_a21oi_2
XFILLER_115_540 VPWR VGND sg13g2_decap_4
X_22012_ _02606_ _02591_ _02605_ VPWR VGND sg13g2_xnor2_1
XFILLER_57_800 VPWR VGND sg13g2_fill_2
XFILLER_130_576 VPWR VGND sg13g2_decap_8
XFILLER_124_35 VPWR VGND sg13g2_decap_8
XFILLER_97_991 VPWR VGND sg13g2_decap_4
X_23468__1526 VPWR VGND net1525 sg13g2_tiehi
XFILLER_84_39 VPWR VGND sg13g2_decap_4
X_22914_ VGND VPWR net554 _03206_ _00786_ _03185_ sg13g2_a21oi_1
XFILLER_17_22 VPWR VGND sg13g2_fill_1
XFILLER_17_33 VPWR VGND sg13g2_fill_1
XFILLER_72_836 VPWR VGND sg13g2_fill_1
X_22845_ net922 _03142_ _00760_ VPWR VGND sg13g2_nor2_1
XFILLER_83_184 VPWR VGND sg13g2_fill_1
XFILLER_72_869 VPWR VGND sg13g2_fill_2
X_22776_ u_debug_unit.mon_w4_sync\[4\] net341 _03106_ VPWR VGND sg13g2_nor2_1
X_21727_ net366 VPWR _02325_ VGND u_LMS.w\[7\]\[8\] net377 sg13g2_o21ai_1
XFILLER_13_958 VPWR VGND sg13g2_decap_8
X_21658_ net2143 VPWR _02270_ VGND _02229_ _02269_ sg13g2_o21ai_1
X_12460_ net841 _03835_ net719 _03836_ VPWR VGND sg13g2_nand3_1
XFILLER_33_76 VPWR VGND sg13g2_fill_2
XFILLER_32_1024 VPWR VGND sg13g2_fill_2
X_20609_ _01249_ _01247_ _01248_ VPWR VGND sg13g2_nand2_1
X_12391_ _03769_ net841 net723 net827 net724 VPWR VGND sg13g2_a22oi_1
X_21589_ _02206_ _02205_ _02179_ VPWR VGND sg13g2_nand2b_1
X_14130_ VGND VPWR _05400_ _05403_ _05441_ _05439_ sg13g2_a21oi_1
X_23328_ net1273 VGND VPWR _00390_ u_LMS.w\[4\]\[7\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
XFILLER_109_0 VPWR VGND sg13g2_decap_8
X_14061_ _05343_ _05372_ _05373_ VPWR VGND sg13g2_nor2_1
XFILLER_4_656 VPWR VGND sg13g2_fill_1
X_23259_ net1375 VGND VPWR _00321_ u_LMS.w\[1\]\[7\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
XFILLER_3_133 VPWR VGND sg13g2_fill_1
XFILLER_3_155 VPWR VGND sg13g2_decap_8
X_13012_ net1025 VPWR _04367_ VGND net522 u_FIR.sum\[2\]\[0\] sg13g2_o21ai_1
X_17820_ _08903_ _08902_ _08953_ VPWR VGND sg13g2_xor2_1
XFILLER_58_40 VPWR VGND sg13g2_fill_1
XFILLER_0_851 VPWR VGND sg13g2_decap_8
XFILLER_121_565 VPWR VGND sg13g2_fill_2
X_17751_ _08882_ _08883_ _08884_ VPWR VGND sg13g2_nor2b_1
X_14963_ _06242_ _06238_ _06244_ VPWR VGND sg13g2_xor2_1
XFILLER_66_129 VPWR VGND sg13g2_fill_2
XFILLER_87_490 VPWR VGND sg13g2_decap_8
X_16702_ net1024 VPWR _07866_ VGND net520 u_FIR.w\[7\]\[6\] sg13g2_o21ai_1
X_13914_ _05233_ net281 _05235_ VPWR VGND sg13g2_xor2_1
X_17682_ _03267_ _08814_ _08815_ VPWR VGND sg13g2_nor2_1
XFILLER_48_877 VPWR VGND sg13g2_fill_1
X_14894_ VGND VPWR net509 _06177_ _00151_ _06178_ sg13g2_a21oi_1
X_19421_ _10485_ _10445_ _10450_ VPWR VGND sg13g2_xnor2_1
X_16633_ VGND VPWR u_LMS.w\[5\]\[13\] _07812_ _07816_ _07813_ sg13g2_a21oi_1
X_13845_ _05168_ net280 _05169_ VPWR VGND sg13g2_xor2_1
XFILLER_63_847 VPWR VGND sg13g2_decap_4
XFILLER_35_538 VPWR VGND sg13g2_decap_8
X_23083__1082 VPWR VGND net1081 sg13g2_tiehi
XFILLER_90_655 VPWR VGND sg13g2_decap_8
XFILLER_62_346 VPWR VGND sg13g2_decap_8
X_19352_ _10406_ VPWR _10416_ VGND _10373_ _10407_ sg13g2_o21ai_1
X_16564_ VGND VPWR net485 _07763_ _00235_ _07764_ sg13g2_a21oi_1
X_13776_ _05102_ u_FIR.sum\[2\]\[10\] net403 VPWR VGND sg13g2_nand2_1
XFILLER_43_560 VPWR VGND sg13g2_fill_2
X_18303_ _09412_ _09407_ _09413_ VPWR VGND sg13g2_xor2_1
X_15515_ VGND VPWR net477 _06771_ _00178_ _06772_ sg13g2_a21oi_1
X_19283_ _03245_ net143 _10347_ VPWR VGND sg13g2_nor2_1
X_12727_ _04079_ VPWR _04091_ VGND _04031_ _04069_ sg13g2_o21ai_1
X_16495_ u_LMS.w\[0\]\[24\] _07713_ _07714_ VPWR VGND sg13g2_nor2_1
X_23098__1060 VPWR VGND net1059 sg13g2_tiehi
X_18234_ _09344_ _09341_ _09342_ VPWR VGND sg13g2_xnor2_1
X_15446_ _06685_ _06708_ _06709_ VPWR VGND sg13g2_nor2b_1
X_12658_ _04024_ net735 net856 VPWR VGND sg13g2_nand2_1
X_18165_ _09275_ _09272_ _09273_ VPWR VGND sg13g2_xnor2_1
X_15377_ net250 _06640_ _06643_ VPWR VGND sg13g2_and2_1
X_12589_ VPWR _03958_ _03957_ VGND sg13g2_inv_1
X_17116_ _08262_ _08271_ _08272_ VPWR VGND sg13g2_nor2_1
X_14328_ _05628_ _05630_ _05633_ VPWR VGND sg13g2_nor2_1
X_18096_ net106 _09204_ net671 _09206_ VPWR VGND sg13g2_nand3_1
Xrebuffer2106 _09589_ net2105 VPWR VGND sg13g2_buf_2
X_17047_ _08203_ _08201_ _03275_ VPWR VGND sg13g2_xnor2_1
Xrebuffer2117 _09495_ net2116 VPWR VGND sg13g2_buf_1
X_14259_ VGND VPWR _05527_ _05543_ _05566_ _05552_ sg13g2_a21oi_1
Xrebuffer2128 _07938_ net2127 VPWR VGND sg13g2_buf_2
Xrebuffer2139 _01956_ net2138 VPWR VGND sg13g2_buf_1
XFILLER_125_871 VPWR VGND sg13g2_decap_8
XFILLER_98_711 VPWR VGND sg13g2_decap_8
XFILLER_48_1053 VPWR VGND sg13g2_decap_8
Xfanout908 net910 net908 VPWR VGND sg13g2_buf_1
Xfanout919 net920 net919 VPWR VGND sg13g2_buf_1
XFILLER_98_755 VPWR VGND sg13g2_decap_4
XFILLER_97_232 VPWR VGND sg13g2_fill_2
XFILLER_58_619 VPWR VGND sg13g2_fill_1
X_18998_ _10085_ _10062_ _10063_ VPWR VGND sg13g2_xnor2_1
XFILLER_57_107 VPWR VGND sg13g2_decap_8
XFILLER_100_727 VPWR VGND sg13g2_fill_2
XFILLER_97_276 VPWR VGND sg13g2_decap_4
XFILLER_24_0 VPWR VGND sg13g2_decap_8
XFILLER_112_598 VPWR VGND sg13g2_fill_1
X_17949_ _09082_ u_LMS.w\[1\]\[22\] net78 VPWR VGND sg13g2_nand2_1
XFILLER_38_343 VPWR VGND sg13g2_decap_4
X_20960_ _01596_ VPWR _01600_ VGND _01597_ _01598_ sg13g2_o21ai_1
XFILLER_39_899 VPWR VGND sg13g2_decap_8
XFILLER_93_482 VPWR VGND sg13g2_fill_2
XFILLER_65_173 VPWR VGND sg13g2_fill_2
X_19619_ _10682_ _10680_ _10683_ VPWR VGND sg13g2_xor2_1
XFILLER_81_633 VPWR VGND sg13g2_fill_1
X_20891_ _01528_ _01529_ _01531_ VPWR VGND sg13g2_nor2b_1
X_23438__1618 VPWR VGND net1617 sg13g2_tiehi
XFILLER_80_110 VPWR VGND sg13g2_decap_8
XFILLER_54_858 VPWR VGND sg13g2_decap_8
XFILLER_65_195 VPWR VGND sg13g2_fill_2
X_23482__1477 VPWR VGND net1476 sg13g2_tiehi
XFILLER_0_1055 VPWR VGND sg13g2_decap_4
XFILLER_0_91 VPWR VGND sg13g2_decap_8
X_22630_ net470 coeff_force_packed\[8\] _03062_ _00625_ VPWR VGND sg13g2_mux2_1
XFILLER_55_1002 VPWR VGND sg13g2_decap_8
X_23517__1349 VPWR VGND net1348 sg13g2_tiehi
XFILLER_22_700 VPWR VGND sg13g2_fill_2
XFILLER_110_37 VPWR VGND sg13g2_fill_1
X_22561_ _03039_ u_LMS.count\[21\] u_LMS.count\[20\] _03035_ VPWR VGND sg13g2_and3_1
XFILLER_110_59 VPWR VGND sg13g2_fill_2
XFILLER_22_755 VPWR VGND sg13g2_decap_4
XFILLER_10_906 VPWR VGND sg13g2_decap_4
X_21512_ _02127_ _02128_ _02129_ VPWR VGND sg13g2_and2_1
XFILLER_10_917 VPWR VGND sg13g2_fill_1
X_22492_ VGND VPWR net442 _03222_ _00554_ _02995_ sg13g2_a21oi_1
X_21443_ _02060_ net602 net229 VPWR VGND sg13g2_nand2_1
XFILLER_119_131 VPWR VGND sg13g2_fill_1
XFILLER_119_142 VPWR VGND sg13g2_fill_1
XFILLER_119_164 VPWR VGND sg13g2_decap_8
XFILLER_107_315 VPWR VGND sg13g2_decap_4
X_21374_ _01963_ _01965_ _01991_ VPWR VGND sg13g2_nor2_1
X_20325_ _00988_ u_LMS.w\[5\]\[11\] _00987_ VPWR VGND sg13g2_nand2_1
X_23113_ net1619 VGND VPWR _00175_ u_FIR.sum\[6\]\[18\] clknet_leaf_43_clkA sg13g2_dfrbpq_1
XFILLER_89_700 VPWR VGND sg13g2_fill_2
XFILLER_89_711 VPWR VGND sg13g2_decap_4
X_23044_ net1140 VGND VPWR _00106_ u_FIR.sum\[3\]\[6\] clknet_leaf_33_clkA sg13g2_dfrbpq_1
X_20256_ _00919_ net636 net264 VPWR VGND sg13g2_nand2_1
XFILLER_88_210 VPWR VGND sg13g2_decap_8
XFILLER_1_648 VPWR VGND sg13g2_fill_2
XFILLER_77_906 VPWR VGND sg13g2_fill_2
XFILLER_1_659 VPWR VGND sg13g2_fill_1
XFILLER_0_147 VPWR VGND sg13g2_decap_8
X_20187_ _00823_ VPWR _00850_ VGND _03242_ net142 sg13g2_o21ai_1
XFILLER_95_49 VPWR VGND sg13g2_fill_1
XFILLER_85_950 VPWR VGND sg13g2_decap_8
X_11960_ VPWR _03381_ u_FIR.sum\[2\]\[16\] VGND sg13g2_inv_1
XFILLER_56_140 VPWR VGND sg13g2_fill_2
XFILLER_29_365 VPWR VGND sg13g2_fill_1
XFILLER_17_505 VPWR VGND sg13g2_fill_2
XFILLER_85_994 VPWR VGND sg13g2_fill_1
XFILLER_44_302 VPWR VGND sg13g2_fill_1
XFILLER_28_87 VPWR VGND sg13g2_decap_8
XFILLER_56_173 VPWR VGND sg13g2_fill_1
X_11891_ VPWR _03312_ u_LMS.w\[5\]\[8\] VGND sg13g2_inv_1
XFILLER_44_335 VPWR VGND sg13g2_decap_4
XFILLER_72_655 VPWR VGND sg13g2_fill_2
X_13630_ net1033 VPWR _04960_ VGND net532 u_FIR.sum\[3\]\[6\] sg13g2_o21ai_1
X_22828_ u_debug_unit.mon_w8_sync\[2\] net345 _03132_ VPWR VGND sg13g2_nor2_1
XFILLER_44_31 VPWR VGND sg13g2_fill_2
X_23045__1139 VPWR VGND net1138 sg13g2_tiehi
XFILLER_53_880 VPWR VGND sg13g2_fill_1
X_13561_ _04892_ net904 net749 net893 net750 VPWR VGND sg13g2_a22oi_1
X_22759_ VGND VPWR _07779_ net334 _00719_ _03097_ sg13g2_a21oi_1
XFILLER_13_744 VPWR VGND sg13g2_decap_4
X_15300_ VGND VPWR net504 _06567_ _00167_ _06568_ sg13g2_a21oi_1
X_12512_ VGND VPWR _03885_ _03886_ _03887_ net414 sg13g2_a21oi_1
X_16280_ VGND VPWR net476 _07514_ _00200_ _07515_ sg13g2_a21oi_1
XFILLER_9_726 VPWR VGND sg13g2_decap_8
X_13492_ _04824_ _04825_ _04826_ VPWR VGND sg13g2_nor2_1
XFILLER_12_276 VPWR VGND sg13g2_decap_4
X_15231_ _06501_ _06500_ _06496_ VPWR VGND sg13g2_nand2b_1
X_12443_ VGND VPWR _03818_ _03819_ _03820_ net414 sg13g2_a21oi_1
X_15162_ _06395_ u_FIR.w\[2\]\[6\] _06393_ _06434_ VPWR VGND sg13g2_a21o_1
XFILLER_60_85 VPWR VGND sg13g2_fill_2
X_12374_ _03739_ VPWR _03752_ VGND _03721_ _03740_ sg13g2_o21ai_1
XFILLER_60_96 VPWR VGND sg13g2_decap_8
XFILLER_5_14 VPWR VGND sg13g2_decap_8
X_14113_ _05423_ _05384_ _05424_ VPWR VGND sg13g2_xor2_1
XFILLER_4_431 VPWR VGND sg13g2_decap_8
X_19970_ _11011_ _10990_ _11010_ VPWR VGND sg13g2_xnor2_1
X_15093_ _06367_ _06337_ _06366_ VPWR VGND sg13g2_nand2b_1
XFILLER_107_860 VPWR VGND sg13g2_decap_8
XFILLER_113_307 VPWR VGND sg13g2_fill_1
XFILLER_109_90 VPWR VGND sg13g2_fill_2
X_18921_ _10006_ _10007_ _10008_ VPWR VGND sg13g2_nor2_1
X_14044_ _05356_ _05353_ _05357_ VPWR VGND sg13g2_xor2_1
XFILLER_69_72 VPWR VGND sg13g2_decap_4
XFILLER_69_94 VPWR VGND sg13g2_decap_8
XFILLER_68_917 VPWR VGND sg13g2_fill_2
X_18852_ _09939_ _09937_ _09938_ VPWR VGND sg13g2_nand2_1
XFILLER_122_896 VPWR VGND sg13g2_decap_8
X_17803_ _08936_ net701 net258 VPWR VGND sg13g2_nand2_1
X_23360__1242 VPWR VGND net1241 sg13g2_tiehi
X_18783_ _09868_ _09869_ _09870_ VPWR VGND sg13g2_nor2b_1
XFILLER_39_129 VPWR VGND sg13g2_fill_1
X_15995_ _07236_ _07231_ _07234_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_395 VPWR VGND sg13g2_fill_1
X_17734_ _08867_ _08858_ _08866_ VPWR VGND sg13g2_xnor2_1
X_14946_ _06228_ _06205_ _06227_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_972 VPWR VGND sg13g2_decap_4
XFILLER_91_931 VPWR VGND sg13g2_fill_2
X_17665_ _08798_ _08775_ _08776_ VPWR VGND sg13g2_xnor2_1
X_14877_ _06162_ _06055_ _06160_ VPWR VGND sg13g2_xnor2_1
X_19404_ net424 _03244_ _08068_ net208 _10468_ VPWR VGND sg13g2_nor4_1
X_16616_ VGND VPWR u_LMS.w\[4\]\[16\] _07793_ _07803_ _07794_ sg13g2_a21oi_1
XFILLER_51_806 VPWR VGND sg13g2_fill_1
X_13828_ _05138_ VPWR _05152_ VGND net280 _05136_ sg13g2_o21ai_1
XFILLER_35_368 VPWR VGND sg13g2_decap_8
X_17596_ VPWR _08729_ _08728_ VGND sg13g2_inv_1
XFILLER_50_316 VPWR VGND sg13g2_fill_1
XFILLER_62_187 VPWR VGND sg13g2_decap_8
X_19335_ _10378_ VPWR _10399_ VGND _10375_ _10379_ sg13g2_o21ai_1
X_16547_ _07752_ _07750_ _07751_ VPWR VGND sg13g2_nand2_1
X_13759_ net809 VPWR _05085_ VGND u_FIR.w\[5\]\[3\] u_FIR.w\[5\]\[2\] sg13g2_o21ai_1
X_19266_ net355 VPWR _10335_ VGND u_LMS.w\[3\]\[7\] net371 sg13g2_o21ai_1
X_16478_ _07701_ net413 net854 VPWR VGND sg13g2_nand2_1
X_18217_ net670 net235 net669 _09327_ VPWR VGND net200 sg13g2_nand4_1
XFILLER_31_596 VPWR VGND sg13g2_decap_8
X_15429_ _06692_ VPWR _06693_ VGND _06643_ _06673_ sg13g2_o21ai_1
Xclkbuf_leaf_42_clkA clknet_4_5_0_clkA clknet_leaf_42_clkA VPWR VGND sg13g2_buf_8
X_19197_ VGND VPWR _10279_ _10280_ _00352_ net927 sg13g2_a21oi_1
XFILLER_117_602 VPWR VGND sg13g2_fill_2
XFILLER_117_613 VPWR VGND sg13g2_decap_4
X_18148_ _09258_ _09240_ _09257_ VPWR VGND sg13g2_nand2_1
XFILLER_102_1055 VPWR VGND sg13g2_decap_4
X_18079_ _09189_ net676 net144 VPWR VGND sg13g2_nand2_1
XFILLER_116_167 VPWR VGND sg13g2_decap_8
X_20110_ _11149_ _11150_ _11151_ VPWR VGND sg13g2_nor2b_1
X_23285__1324 VPWR VGND net1323 sg13g2_tiehi
X_21090_ net361 VPWR _01716_ VGND u_LMS.w\[6\]\[3\] net378 sg13g2_o21ai_1
Xfanout705 u_LMS.x_r\[0\]\[5\] net705 VPWR VGND sg13g2_buf_1
X_20041_ _11082_ _11076_ _11077_ VPWR VGND sg13g2_xnor2_1
Xfanout716 u_LMS.w\[8\]\[24\] net716 VPWR VGND sg13g2_buf_1
Xfanout727 u_FIR.w\[8\]\[0\] net727 VPWR VGND sg13g2_buf_1
Xfanout738 u_FIR.w\[7\]\[0\] net738 VPWR VGND sg13g2_buf_1
XFILLER_100_502 VPWR VGND sg13g2_decap_8
Xfanout749 u_FIR.w\[5\]\[5\] net749 VPWR VGND sg13g2_buf_1
XFILLER_113_885 VPWR VGND sg13g2_decap_8
XFILLER_105_26 VPWR VGND sg13g2_fill_2
XFILLER_85_213 VPWR VGND sg13g2_fill_1
X_21992_ _02563_ _02585_ _02586_ VPWR VGND sg13g2_nor2b_1
XFILLER_39_674 VPWR VGND sg13g2_fill_2
XFILLER_94_780 VPWR VGND sg13g2_decap_4
X_23731_ net998 VGND VPWR _00793_ u_spi_slave.tx_cnt\[1\] net1637 sg13g2_dfrbpq_1
XFILLER_26_324 VPWR VGND sg13g2_decap_8
X_20943_ _01583_ _01522_ net2072 VPWR VGND sg13g2_xnor2_1
XFILLER_121_14 VPWR VGND sg13g2_decap_4
XFILLER_121_36 VPWR VGND sg13g2_fill_2
X_23662_ net1011 VGND VPWR _00724_ u_debug_unit.mon_w4_sync\[0\] clknet_leaf_17_clkA
+ sg13g2_dfrbpq_1
X_20874_ VPWR _01514_ _01513_ VGND sg13g2_inv_1
XFILLER_53_176 VPWR VGND sg13g2_fill_1
X_22613_ net468 sys_enable_bus\[2\] _03060_ _00610_ VPWR VGND sg13g2_mux2_1
X_23593_ net964 VGND VPWR _00655_ u_debug_unit.force_w4\[7\] clknet_leaf_17_clkA sg13g2_dfrbpq_1
XFILLER_50_850 VPWR VGND sg13g2_decap_4
X_22544_ VGND VPWR u_LMS.count\[14\] _03025_ _03028_ u_LMS.count\[15\] sg13g2_a21oi_1
X_23041__1145 VPWR VGND net1144 sg13g2_tiehi
XFILLER_10_725 VPWR VGND sg13g2_decap_8
X_22475_ net960 VPWR _02987_ VGND net446 net599 sg13g2_o21ai_1
XFILLER_10_769 VPWR VGND sg13g2_fill_2
XFILLER_5_206 VPWR VGND sg13g2_fill_2
XFILLER_108_624 VPWR VGND sg13g2_fill_2
X_21426_ net211 _02042_ net601 _02043_ VPWR VGND sg13g2_nand3_1
XFILLER_108_635 VPWR VGND sg13g2_decap_4
X_23056__1123 VPWR VGND net1122 sg13g2_tiehi
X_21357_ _01974_ _01972_ _01973_ VPWR VGND sg13g2_nand2_1
XFILLER_100_4 VPWR VGND sg13g2_fill_2
XFILLER_123_616 VPWR VGND sg13g2_fill_1
X_20308_ _00958_ _00970_ _00971_ VPWR VGND sg13g2_xor2_1
X_12090_ _03502_ u_spi_slave.tx_shift\[11\] _03392_ VPWR VGND sg13g2_nand2_1
X_21288_ _01905_ net596 net170 VPWR VGND sg13g2_nand2_1
XFILLER_122_126 VPWR VGND sg13g2_fill_1
XFILLER_2_957 VPWR VGND sg13g2_decap_8
XFILLER_104_852 VPWR VGND sg13g2_decap_4
XFILLER_1_445 VPWR VGND sg13g2_decap_4
X_20239_ _00888_ _00892_ net2123 _00902_ VPWR VGND sg13g2_nand3_1
X_23027_ net1165 VGND VPWR _00089_ u_FIR.sum\[2\]\[8\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
XFILLER_39_31 VPWR VGND sg13g2_fill_2
XFILLER_7_1017 VPWR VGND sg13g2_decap_8
X_14800_ _06073_ VPWR _06087_ VGND _06069_ _06071_ sg13g2_o21ai_1
XFILLER_92_706 VPWR VGND sg13g2_decap_4
XFILLER_92_717 VPWR VGND sg13g2_fill_1
X_15780_ _07030_ _07024_ _07028_ VPWR VGND sg13g2_xnor2_1
XFILLER_29_140 VPWR VGND sg13g2_decap_4
X_12992_ _04347_ _04342_ _04349_ VPWR VGND sg13g2_xor2_1
XFILLER_29_151 VPWR VGND sg13g2_decap_8
XFILLER_57_471 VPWR VGND sg13g2_fill_2
XFILLER_45_622 VPWR VGND sg13g2_decap_4
XFILLER_17_313 VPWR VGND sg13g2_fill_1
X_14731_ _06020_ net823 u_FIR.w\[3\]\[3\] net806 u_FIR.w\[3\]\[2\] VPWR VGND sg13g2_a22oi_1
XFILLER_91_238 VPWR VGND sg13g2_fill_2
X_11943_ VPWR _03364_ net751 VGND sg13g2_inv_1
XFILLER_29_184 VPWR VGND sg13g2_decap_4
XFILLER_72_430 VPWR VGND sg13g2_fill_1
XFILLER_17_346 VPWR VGND sg13g2_fill_2
X_17450_ net419 _03268_ net184 net159 _08583_ VPWR VGND sg13g2_nor4_1
XFILLER_55_74 VPWR VGND sg13g2_fill_2
X_14662_ _05953_ u_FIR.sum\[4\]\[7\] net398 VPWR VGND sg13g2_nand2_1
XFILLER_73_986 VPWR VGND sg13g2_decap_4
XFILLER_55_85 VPWR VGND sg13g2_decap_4
X_11874_ VPWR _03295_ u_LMS.w\[8\]\[5\] VGND sg13g2_inv_1
XFILLER_45_688 VPWR VGND sg13g2_fill_2
X_16401_ _07630_ net270 _07632_ VPWR VGND sg13g2_xor2_1
X_13613_ _04943_ net756 net825 u_FIR.sum\[2\]\[6\] VPWR VGND sg13g2_and3_1
XFILLER_72_496 VPWR VGND sg13g2_fill_1
X_17381_ VGND VPWR _08528_ _08529_ _00287_ net932 sg13g2_a21oi_1
Xclkbuf_leaf_65_clkA clknet_4_0_0_clkA clknet_leaf_65_clkA VPWR VGND sg13g2_buf_8
X_14593_ _05850_ _05848_ _05884_ _05886_ VPWR VGND sg13g2_a21o_1
X_19120_ _10207_ u_LMS.w\[3\]\[4\] _10198_ VPWR VGND sg13g2_xnor2_1
XFILLER_41_850 VPWR VGND sg13g2_fill_1
X_16332_ _07566_ u_FIR.sum\[7\]\[12\] net387 VPWR VGND sg13g2_xnor2_1
X_13544_ _04876_ _04838_ _04874_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_1044 VPWR VGND sg13g2_decap_8
X_19051_ _10037_ _10038_ _10138_ VPWR VGND sg13g2_and2_1
X_23406__1131 VPWR VGND net1130 sg13g2_tiehi
X_16263_ _07457_ VPWR _07499_ VGND _07415_ _07455_ sg13g2_o21ai_1
XFILLER_9_556 VPWR VGND sg13g2_fill_2
X_13475_ net905 net755 u_FIR.sum\[2\]\[0\] _04811_ VPWR VGND sg13g2_a21o_1
X_18002_ VGND VPWR _09126_ _09127_ _00310_ net919 sg13g2_a21oi_1
X_15214_ _06485_ _06484_ _06451_ VPWR VGND sg13g2_nand2b_1
X_12426_ _03803_ net827 net723 net811 u_FIR.w\[8\]\[2\] VPWR VGND sg13g2_a22oi_1
X_16194_ _07432_ _07424_ _07431_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_7 VPWR VGND sg13g2_decap_4
XFILLER_126_421 VPWR VGND sg13g2_fill_2
XFILLER_127_955 VPWR VGND sg13g2_decap_4
XFILLER_127_966 VPWR VGND sg13g2_fill_1
X_15145_ _06417_ net777 net860 VPWR VGND sg13g2_nand2_1
X_12357_ _03736_ _03732_ _03734_ VPWR VGND sg13g2_xnor2_1
XFILLER_113_104 VPWR VGND sg13g2_fill_1
X_19953_ _10994_ _10990_ _10993_ VPWR VGND sg13g2_xnor2_1
X_15076_ _06350_ _06344_ _06348_ VPWR VGND sg13g2_xnor2_1
XFILLER_4_272 VPWR VGND sg13g2_decap_8
X_12288_ _03637_ _03668_ _03669_ VPWR VGND sg13g2_nor2_1
X_18904_ VGND VPWR _09979_ _09981_ _09991_ _09990_ sg13g2_a21oi_1
X_14027_ net997 VPWR _05341_ VGND net492 u_FIR.sum\[4\]\[3\] sg13g2_o21ai_1
XFILLER_45_1023 VPWR VGND sg13g2_decap_8
X_19884_ VGND VPWR net54 _10927_ _10928_ net24 sg13g2_a21oi_1
XFILLER_110_844 VPWR VGND sg13g2_fill_2
X_18835_ _09922_ net659 net165 VPWR VGND sg13g2_nand2_1
XFILLER_121_170 VPWR VGND sg13g2_fill_2
XFILLER_121_192 VPWR VGND sg13g2_fill_2
XFILLER_132_1059 VPWR VGND sg13g2_fill_2
X_18766_ _09762_ _09760_ _09853_ VPWR VGND sg13g2_xor2_1
X_15978_ _07211_ _07203_ _07219_ _07220_ VPWR VGND sg13g2_a21o_1
XFILLER_95_599 VPWR VGND sg13g2_fill_2
XFILLER_83_739 VPWR VGND sg13g2_decap_4
X_17717_ _08850_ _08811_ _08822_ VPWR VGND sg13g2_xnor2_1
X_14929_ _06210_ _06209_ _06212_ VPWR VGND sg13g2_xor2_1
XFILLER_82_238 VPWR VGND sg13g2_decap_4
X_18697_ _09783_ _09773_ _09784_ VPWR VGND sg13g2_xor2_1
XFILLER_91_772 VPWR VGND sg13g2_fill_1
XFILLER_36_677 VPWR VGND sg13g2_decap_4
XFILLER_35_154 VPWR VGND sg13g2_fill_1
X_17648_ _08781_ _08766_ _08780_ VPWR VGND sg13g2_nand2_1
XFILLER_23_316 VPWR VGND sg13g2_fill_1
XFILLER_35_176 VPWR VGND sg13g2_decap_8
X_17579_ _08712_ net693 net129 VPWR VGND sg13g2_nand2_1
XFILLER_91_0 VPWR VGND sg13g2_decap_8
X_19318_ _10374_ _10381_ _10382_ VPWR VGND sg13g2_and2_1
X_20590_ _01230_ _01219_ _01229_ VPWR VGND sg13g2_xnor2_1
XFILLER_52_1038 VPWR VGND sg13g2_fill_2
XFILLER_31_382 VPWR VGND sg13g2_decap_8
X_19249_ VGND VPWR net27 _10321_ _00362_ _10322_ sg13g2_a21oi_1
X_22260_ _02853_ net311 u_LMS.w\[8\]\[13\] coeff_force_packed\[57\] net561 VPWR VGND
+ sg13g2_a22oi_1
X_21211_ _01828_ _01809_ _01827_ VPWR VGND sg13g2_nand2_1
X_22191_ u_LMS.w\[8\]\[2\] net255 net586 _02785_ VPWR VGND sg13g2_nand3_1
X_21142_ _01759_ net84 net596 net150 net598 VPWR VGND sg13g2_a22oi_1
XFILLER_132_446 VPWR VGND sg13g2_decap_4
Xfanout502 net503 net502 VPWR VGND sg13g2_buf_1
XFILLER_120_608 VPWR VGND sg13g2_fill_1
X_21073_ VGND VPWR _01701_ _01702_ _00428_ net937 sg13g2_a21oi_1
Xfanout513 net514 net513 VPWR VGND sg13g2_buf_1
Xfanout524 net525 net524 VPWR VGND sg13g2_buf_1
XFILLER_113_660 VPWR VGND sg13g2_fill_2
Xfanout535 net548 net535 VPWR VGND sg13g2_buf_1
X_20024_ _11065_ _11030_ _11032_ VPWR VGND sg13g2_xnor2_1
Xfanout546 net547 net546 VPWR VGND sg13g2_buf_1
Xfanout557 net558 net557 VPWR VGND sg13g2_buf_1
Xfanout568 net569 net568 VPWR VGND sg13g2_buf_1
XFILLER_59_758 VPWR VGND sg13g2_fill_2
Xfanout579 u_LMS.x_r\[8\]\[4\] net579 VPWR VGND sg13g2_buf_1
XFILLER_27_611 VPWR VGND sg13g2_fill_1
XFILLER_132_35 VPWR VGND sg13g2_decap_8
X_21975_ _02538_ VPWR _02569_ VGND _02529_ _02536_ sg13g2_o21ai_1
XFILLER_55_953 VPWR VGND sg13g2_decap_8
XFILLER_82_750 VPWR VGND sg13g2_fill_2
XFILLER_55_964 VPWR VGND sg13g2_fill_2
X_23714_ net1424 VGND VPWR _00776_ u_FIR.x\[3\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
X_20926_ _01566_ u_LMS.w\[6\]\[17\] _01565_ VPWR VGND sg13g2_nand2_1
XFILLER_25_11 VPWR VGND sg13g2_fill_2
XFILLER_70_934 VPWR VGND sg13g2_decap_8
XFILLER_70_945 VPWR VGND sg13g2_fill_2
XFILLER_42_636 VPWR VGND sg13g2_decap_4
XFILLER_26_187 VPWR VGND sg13g2_fill_2
X_23645_ net982 VGND VPWR _00707_ u_debug_unit.mon_w1_sync\[4\] clknet_leaf_52_clkA
+ sg13g2_dfrbpq_1
XFILLER_41_124 VPWR VGND sg13g2_decap_8
X_20857_ _01497_ _01486_ _01488_ VPWR VGND sg13g2_xnor2_1
XFILLER_41_168 VPWR VGND sg13g2_decap_8
X_23576_ net953 VGND VPWR _00638_ coeff_force_packed\[20\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
X_20788_ _01428_ _01397_ _01398_ VPWR VGND sg13g2_xnor2_1
X_22527_ net916 _03016_ _03017_ _00567_ VPWR VGND sg13g2_nor3_1
XFILLER_10_566 VPWR VGND sg13g2_fill_2
XFILLER_127_229 VPWR VGND sg13g2_decap_8
X_13260_ _04606_ _04600_ _04604_ VPWR VGND sg13g2_xnor2_1
X_22458_ VGND VPWR net450 _03240_ _00537_ _02978_ sg13g2_a21oi_1
XFILLER_6_537 VPWR VGND sg13g2_decap_8
XFILLER_41_87 VPWR VGND sg13g2_decap_4
XFILLER_109_966 VPWR VGND sg13g2_fill_1
X_12211_ net413 _03595_ _03596_ VPWR VGND sg13g2_nor2_1
X_21409_ _01956_ _02025_ _02026_ VPWR VGND sg13g2_and2_1
XFILLER_68_1023 VPWR VGND sg13g2_fill_1
X_13191_ _04490_ VPWR _04539_ VGND _04487_ _04491_ sg13g2_o21ai_1
XFILLER_109_999 VPWR VGND sg13g2_fill_2
X_22389_ net947 VPWR _02944_ VGND net435 net683 sg13g2_o21ai_1
XFILLER_123_413 VPWR VGND sg13g2_decap_8
X_12142_ VPWR VGND coeff_force_packed\[50\] _03551_ net293 u_debug_unit.mon_w8_sync\[1\]
+ _03552_ _03416_ sg13g2_a221oi_1
X_16950_ _08103_ _08105_ _08106_ VPWR VGND sg13g2_nor2_1
X_12073_ u_debug_unit.mon_w7_sync\[4\] _03404_ _03486_ VPWR VGND sg13g2_and2_1
XFILLER_96_319 VPWR VGND sg13g2_decap_8
XFILLER_1_253 VPWR VGND sg13g2_decap_8
X_15901_ VGND VPWR _07119_ _07139_ _07147_ _07138_ sg13g2_a21oi_1
X_23451__1579 VPWR VGND net1578 sg13g2_tiehi
X_16881_ _08035_ _08036_ _08037_ VPWR VGND sg13g2_nor2b_1
X_18620_ VGND VPWR _09718_ _09719_ _00336_ net919 sg13g2_a21oi_1
X_15832_ _07079_ _07053_ _07081_ VPWR VGND sg13g2_xor2_1
XFILLER_66_40 VPWR VGND sg13g2_decap_8
XFILLER_64_205 VPWR VGND sg13g2_fill_1
XFILLER_18_600 VPWR VGND sg13g2_decap_4
XFILLER_66_73 VPWR VGND sg13g2_decap_8
X_18551_ _09585_ _09660_ _09661_ VPWR VGND sg13g2_and2_1
X_15763_ _07013_ VPWR _07014_ VGND net495 u_FIR.sum\[7\]\[9\] sg13g2_o21ai_1
XFILLER_17_110 VPWR VGND sg13g2_fill_2
X_12975_ _04333_ _04314_ _04332_ VPWR VGND sg13g2_xnor2_1
XFILLER_46_975 VPWR VGND sg13g2_fill_2
X_17502_ _08614_ VPWR _08635_ VGND _08611_ _08615_ sg13g2_o21ai_1
X_14714_ _06002_ VPWR _06004_ VGND _05962_ _05964_ sg13g2_o21ai_1
X_18482_ _09592_ u_LMS.w\[2\]\[15\] net2100 VPWR VGND sg13g2_nand2b_1
X_11926_ VPWR _03347_ u_LMS.w\[1\]\[24\] VGND sg13g2_inv_1
X_15694_ _06946_ _06945_ _06941_ VPWR VGND sg13g2_nand2b_1
XFILLER_32_102 VPWR VGND sg13g2_fill_1
XFILLER_61_945 VPWR VGND sg13g2_decap_8
XFILLER_45_496 VPWR VGND sg13g2_decap_4
XFILLER_33_636 VPWR VGND sg13g2_fill_1
X_17433_ _08569_ _08570_ _00298_ VPWR VGND sg13g2_nor2_1
X_14645_ net877 net767 _05934_ _05936_ VPWR VGND sg13g2_a21o_1
X_11857_ VPWR _03278_ net706 VGND sg13g2_inv_1
X_17364_ _08516_ net315 u_LMS.w\[0\]\[16\] coeff_force_packed\[4\] net564 VPWR VGND
+ sg13g2_a22oi_1
X_14576_ _05869_ _05868_ _05834_ VPWR VGND sg13g2_nand2b_1
XFILLER_20_319 VPWR VGND sg13g2_decap_4
X_11788_ VPWR _03209_ u_s2p_input.reg_sh\[1\] VGND sg13g2_inv_1
X_19103_ _10190_ u_LMS.w\[3\]\[9\] _10189_ VPWR VGND sg13g2_nand2_1
X_16315_ VGND VPWR _07518_ _07542_ _07549_ _07541_ sg13g2_a21oi_1
X_13527_ VGND VPWR _04828_ _04842_ _04859_ _04841_ sg13g2_a21oi_1
X_17295_ u_LMS.w\[0\]\[9\] _08419_ _08451_ VPWR VGND sg13g2_nor2_1
X_19034_ _10112_ _10118_ _10121_ VPWR VGND sg13g2_nor2b_1
X_16246_ VGND VPWR _07445_ _07461_ _07482_ _07470_ sg13g2_a21oi_1
X_13458_ _04796_ _04783_ _04798_ VPWR VGND sg13g2_xor2_1
XFILLER_12_1055 VPWR VGND sg13g2_decap_4
X_12409_ net940 _03786_ _00058_ VPWR VGND sg13g2_nor2_1
XFILLER_126_240 VPWR VGND sg13g2_decap_8
X_16177_ _07415_ net800 net805 VPWR VGND sg13g2_nand2_1
X_23161__1548 VPWR VGND net1547 sg13g2_tiehi
X_13389_ _04732_ _04709_ _04731_ VPWR VGND sg13g2_xnor2_1
X_15128_ _06401_ _06391_ _06399_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_581 VPWR VGND sg13g2_decap_4
XFILLER_99_157 VPWR VGND sg13g2_decap_8
X_19936_ VPWR _10977_ _10976_ VGND sg13g2_inv_1
X_15059_ VGND VPWR _06334_ _06333_ _06306_ sg13g2_or2_1
XFILLER_130_928 VPWR VGND sg13g2_fill_1
XFILLER_130_939 VPWR VGND sg13g2_fill_1
XFILLER_123_991 VPWR VGND sg13g2_fill_1
X_19867_ _10778_ _10777_ _10915_ VPWR VGND sg13g2_xor2_1
XFILLER_96_864 VPWR VGND sg13g2_decap_4
XFILLER_28_408 VPWR VGND sg13g2_fill_2
X_18818_ _09867_ _09866_ _09905_ VPWR VGND sg13g2_xor2_1
X_19798_ VGND VPWR _10859_ _10860_ _00373_ net930 sg13g2_a21oi_1
X_18749_ _09835_ _09829_ _09836_ VPWR VGND sg13g2_xor2_1
XFILLER_37_953 VPWR VGND sg13g2_decap_4
X_21760_ _02352_ _02350_ _02354_ VPWR VGND sg13g2_xor2_1
XFILLER_91_580 VPWR VGND sg13g2_decap_8
XFILLER_64_794 VPWR VGND sg13g2_fill_2
XFILLER_51_411 VPWR VGND sg13g2_fill_1
XFILLER_24_636 VPWR VGND sg13g2_decap_8
X_20711_ net136 net616 _01336_ _01351_ VPWR VGND sg13g2_a21o_1
XFILLER_52_967 VPWR VGND sg13g2_fill_1
XFILLER_24_658 VPWR VGND sg13g2_decap_8
X_21691_ _02296_ _02244_ _02297_ VPWR VGND sg13g2_xor2_1
X_23430_ net1058 VGND VPWR _00492_ u_LMS.x_r\[0\]\[5\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
X_20642_ _03231_ net141 _01282_ VPWR VGND sg13g2_nor2_1
XFILLER_20_820 VPWR VGND sg13g2_decap_8
X_20573_ _01213_ _01212_ _01200_ VPWR VGND sg13g2_nand2b_1
X_23361_ net1240 VGND VPWR _00423_ u_LMS.w\[6\]\[17\] clknet_leaf_23_clkA sg13g2_dfrbpq_1
X_22312_ VGND VPWR _02842_ _02843_ _02894_ _08494_ sg13g2_a21oi_1
X_23292_ net1312 VGND VPWR _00354_ u_LMS.w\[3\]\[17\] clknet_leaf_52_clkA sg13g2_dfrbpq_1
X_22243_ net60 u_LMS.w\[8\]\[22\] _02837_ VPWR VGND sg13g2_xor2_1
XFILLER_106_936 VPWR VGND sg13g2_decap_8
XFILLER_127_35 VPWR VGND sg13g2_decap_8
XFILLER_117_273 VPWR VGND sg13g2_fill_2
X_22174_ _03297_ _02767_ _02768_ VPWR VGND sg13g2_nor2_1
XFILLER_87_17 VPWR VGND sg13g2_fill_1
XFILLER_105_468 VPWR VGND sg13g2_decap_4
X_21125_ _03220_ net143 _01742_ VPWR VGND sg13g2_nor2_1
Xfanout310 net311 net310 VPWR VGND sg13g2_buf_1
XFILLER_132_276 VPWR VGND sg13g2_decap_8
Xfanout321 _08493_ net321 VPWR VGND sg13g2_buf_1
Xfanout332 _03070_ net332 VPWR VGND sg13g2_buf_1
X_21056_ net17 VPWR _01689_ VGND net15 _01688_ sg13g2_o21ai_1
Xfanout343 net344 net343 VPWR VGND sg13g2_buf_1
XFILLER_101_630 VPWR VGND sg13g2_fill_1
XFILLER_87_853 VPWR VGND sg13g2_decap_8
Xfanout354 net356 net354 VPWR VGND sg13g2_buf_1
Xfanout365 net367 net365 VPWR VGND sg13g2_buf_1
X_20007_ VPWR _11048_ _11047_ VGND sg13g2_inv_1
Xfanout376 _08491_ net376 VPWR VGND sg13g2_buf_1
XFILLER_86_352 VPWR VGND sg13g2_fill_2
Xfanout387 net389 net387 VPWR VGND sg13g2_buf_1
Xfanout398 _05952_ net398 VPWR VGND sg13g2_buf_1
XFILLER_98_1038 VPWR VGND sg13g2_fill_2
XFILLER_39_290 VPWR VGND sg13g2_decap_4
XFILLER_27_452 VPWR VGND sg13g2_decap_8
X_12760_ _04124_ _04090_ _04122_ VPWR VGND sg13g2_xnor2_1
XFILLER_28_997 VPWR VGND sg13g2_decap_8
X_21958_ net587 net167 net130 _02552_ VPWR VGND net585 sg13g2_nand4_1
XFILLER_36_76 VPWR VGND sg13g2_decap_4
X_20909_ _01176_ _01225_ _01226_ _01549_ VPWR VGND sg13g2_nor3_1
X_12691_ _04056_ net731 net884 VPWR VGND sg13g2_nand2_1
X_21889_ _02448_ _02447_ _02483_ VPWR VGND sg13g2_xor2_1
XFILLER_42_466 VPWR VGND sg13g2_decap_4
X_14430_ _05730_ _05713_ _05732_ VPWR VGND sg13g2_xor2_1
XFILLER_42_477 VPWR VGND sg13g2_fill_1
XFILLER_14_168 VPWR VGND sg13g2_fill_1
X_23628_ net972 VGND VPWR _00690_ u_debug_unit.error_signal_sync\[2\] clknet_leaf_47_clkA
+ sg13g2_dfrbpq_1
XFILLER_74_1060 VPWR VGND sg13g2_fill_1
X_14361_ _05660_ _05662_ _05665_ VPWR VGND sg13g2_nor2_1
X_23559_ net967 VGND VPWR _00621_ coeff_force_packed\[5\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
XFILLER_22_190 VPWR VGND sg13g2_decap_8
XFILLER_52_97 VPWR VGND sg13g2_fill_2
X_16100_ _07340_ _07299_ _07338_ VPWR VGND sg13g2_xnor2_1
XFILLER_122_1036 VPWR VGND sg13g2_decap_8
X_13312_ _04610_ VPWR _04657_ VGND _04568_ _04608_ sg13g2_o21ai_1
X_17080_ _08235_ VPWR _08236_ VGND _08221_ _08227_ sg13g2_o21ai_1
X_14292_ net1006 VPWR _05599_ VGND net507 u_FIR.sum\[4\]\[10\] sg13g2_o21ai_1
X_16031_ _07235_ _07271_ _07272_ VPWR VGND sg13g2_and2_1
XFILLER_108_240 VPWR VGND sg13g2_fill_2
XFILLER_109_763 VPWR VGND sg13g2_decap_4
X_13243_ _04590_ _04555_ _04588_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_722 VPWR VGND sg13g2_decap_8
X_13174_ _03361_ net896 _04522_ VPWR VGND sg13g2_nor2_1
X_12125_ _03528_ _03535_ _03536_ VPWR VGND sg13g2_nor2_1
X_17982_ _08983_ VPWR _09111_ VGND _08985_ _09045_ sg13g2_o21ai_1
XFILLER_112_939 VPWR VGND sg13g2_decap_8
XFILLER_96_127 VPWR VGND sg13g2_fill_1
XFILLER_2_584 VPWR VGND sg13g2_fill_2
XFILLER_123_287 VPWR VGND sg13g2_fill_1
X_19721_ _10784_ _10783_ _10785_ VPWR VGND sg13g2_nor2b_1
XFILLER_78_842 VPWR VGND sg13g2_fill_2
X_16933_ net122 _08088_ _08089_ VPWR VGND sg13g2_nor2b_1
X_12056_ _03470_ net291 coeff_force_packed\[47\] _03412_ u_debug_unit.mon_w6_sync\[5\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_42_1015 VPWR VGND sg13g2_fill_1
XFILLER_93_812 VPWR VGND sg13g2_fill_1
XFILLER_77_94 VPWR VGND sg13g2_decap_8
X_19652_ _10691_ _10690_ _10716_ VPWR VGND sg13g2_xor2_1
XFILLER_78_897 VPWR VGND sg13g2_decap_4
XFILLER_77_363 VPWR VGND sg13g2_fill_2
XFILLER_120_983 VPWR VGND sg13g2_fill_1
X_16864_ VGND VPWR _07995_ _07998_ _08020_ net122 sg13g2_a21oi_1
XFILLER_37_205 VPWR VGND sg13g2_decap_8
XFILLER_93_834 VPWR VGND sg13g2_decap_4
XFILLER_19_920 VPWR VGND sg13g2_decap_8
X_18603_ _09705_ net34 net35 _09706_ VPWR VGND sg13g2_a21o_1
XFILLER_37_238 VPWR VGND sg13g2_fill_1
X_15815_ _07064_ _07058_ _07063_ VPWR VGND sg13g2_xnor2_1
XFILLER_19_942 VPWR VGND sg13g2_fill_2
X_19583_ _10638_ _10639_ _10647_ VPWR VGND sg13g2_nor2b_1
X_16795_ _07951_ _07950_ net914 net1658 net912 VPWR VGND sg13g2_a22oi_1
XFILLER_93_867 VPWR VGND sg13g2_decap_8
XFILLER_92_344 VPWR VGND sg13g2_decap_4
X_23190__1499 VPWR VGND net1498 sg13g2_tiehi
XFILLER_80_506 VPWR VGND sg13g2_fill_2
XFILLER_34_901 VPWR VGND sg13g2_decap_4
XFILLER_19_986 VPWR VGND sg13g2_fill_1
X_18534_ _09644_ _03342_ _09598_ VPWR VGND sg13g2_nand2_1
X_15746_ VGND VPWR _06997_ _06952_ _06950_ sg13g2_or2_1
X_12958_ _04293_ VPWR _04316_ VGND _04217_ _04295_ sg13g2_o21ai_1
XFILLER_93_82 VPWR VGND sg13g2_decap_8
XFILLER_34_945 VPWR VGND sg13g2_decap_4
X_11909_ VPWR _03330_ u_LMS.w\[3\]\[8\] VGND sg13g2_inv_1
X_18465_ _09248_ _09574_ _09245_ _09575_ VPWR VGND sg13g2_nand3_1
X_15677_ _06930_ _06898_ _06928_ VPWR VGND sg13g2_xnor2_1
X_12889_ VGND VPWR _04210_ _04240_ _04249_ _04239_ sg13g2_a21oi_1
X_17416_ net364 VPWR _08558_ VGND u_LMS.w\[0\]\[3\] net382 sg13g2_o21ai_1
X_14628_ _05920_ _05890_ _05919_ VPWR VGND sg13g2_xnor2_1
X_18396_ _09500_ VPWR _09506_ VGND _03266_ net176 sg13g2_o21ai_1
XFILLER_61_797 VPWR VGND sg13g2_fill_1
X_17347_ VGND VPWR _08499_ _08502_ _00280_ net936 sg13g2_a21oi_1
X_14559_ VGND VPWR net491 _05851_ _00142_ _05852_ sg13g2_a21oi_1
XFILLER_119_505 VPWR VGND sg13g2_fill_1
X_17278_ _08430_ u_LMS.w\[0\]\[3\] _08434_ VPWR VGND sg13g2_xor2_1
X_19017_ _10090_ _10094_ _10068_ _10104_ VPWR VGND sg13g2_nand3_1
X_16229_ _07466_ u_FIR.sum\[7\]\[9\] net386 VPWR VGND sg13g2_xnor2_1
XFILLER_54_0 VPWR VGND sg13g2_decap_8
XFILLER_114_232 VPWR VGND sg13g2_fill_2
XFILLER_88_628 VPWR VGND sg13g2_fill_1
XFILLER_130_725 VPWR VGND sg13g2_fill_1
X_19919_ _10960_ _10952_ _10959_ VPWR VGND sg13g2_nand2b_1
XFILLER_87_149 VPWR VGND sg13g2_fill_2
X_22930_ VGND VPWR net325 _03194_ _00797_ _03193_ sg13g2_a21oi_1
XFILLER_96_672 VPWR VGND sg13g2_decap_4
XFILLER_56_503 VPWR VGND sg13g2_fill_2
XFILLER_69_897 VPWR VGND sg13g2_fill_1
XFILLER_3_91 VPWR VGND sg13g2_decap_8
X_22861_ VGND VPWR u_p2s_output.reg_sh\[3\] net551 _03154_ _03153_ sg13g2_a21oi_1
XFILLER_3_1042 VPWR VGND sg13g2_decap_8
XFILLER_113_59 VPWR VGND sg13g2_decap_4
X_21812_ VGND VPWR _02406_ _02392_ _02390_ sg13g2_or2_1
X_22792_ u_debug_unit.mon_w5_sync\[5\] net347 _03114_ VPWR VGND sg13g2_nor2_1
XFILLER_58_1022 VPWR VGND sg13g2_fill_1
X_21743_ _02337_ net169 net572 net178 net570 VPWR VGND sg13g2_a22oi_1
XFILLER_58_1055 VPWR VGND sg13g2_decap_4
XFILLER_24_477 VPWR VGND sg13g2_fill_2
XFILLER_52_797 VPWR VGND sg13g2_decap_8
X_21674_ net62 u_LMS.w\[7\]\[20\] _02283_ VPWR VGND sg13g2_xor2_1
X_23413_ net1109 VGND VPWR _00475_ u_LMS.w\[8\]\[23\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
X_20625_ _01262_ _01264_ _01265_ VPWR VGND sg13g2_nor2_1
XFILLER_132_7 VPWR VGND sg13g2_decap_8
XFILLER_22_23 VPWR VGND sg13g2_decap_4
XFILLER_22_34 VPWR VGND sg13g2_fill_1
X_23344_ net1257 VGND VPWR _00406_ u_LMS.w\[5\]\[23\] clknet_leaf_23_clkA sg13g2_dfrbpq_1
X_20556_ VGND VPWR _01194_ _01195_ _01196_ _01188_ sg13g2_a21oi_1
XFILLER_4_805 VPWR VGND sg13g2_decap_8
X_23275_ net1343 VGND VPWR _00337_ u_LMS.w\[2\]\[23\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
X_20487_ VGND VPWR net51 _01132_ _01133_ net19 sg13g2_a21oi_1
X_22226_ VPWR VGND _02817_ _02763_ _02816_ u_LMS.w\[8\]\[15\] _02820_ _02760_ sg13g2_a221oi_1
XFILLER_106_744 VPWR VGND sg13g2_decap_8
X_22157_ _02751_ _02737_ _02750_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_1048 VPWR VGND sg13g2_decap_8
XFILLER_78_116 VPWR VGND sg13g2_decap_4
XFILLER_65_1059 VPWR VGND sg13g2_fill_2
X_21108_ _01729_ _01612_ _01614_ VPWR VGND sg13g2_xnor2_1
X_22088_ _02682_ _02677_ _02681_ VPWR VGND sg13g2_nand2_1
Xfanout140 net1664 net140 VPWR VGND sg13g2_buf_1
Xfanout151 net152 net151 VPWR VGND sg13g2_buf_1
Xfanout162 net162 net163 VPWR VGND sg13g2_buf_4
X_13930_ VGND VPWR _05214_ _05235_ _05250_ _05234_ sg13g2_a21oi_1
XFILLER_101_460 VPWR VGND sg13g2_decap_8
X_21039_ _01634_ _01570_ _01675_ VPWR VGND sg13g2_xor2_1
Xfanout173 net173 net174 VPWR VGND sg13g2_buf_4
XFILLER_93_119 VPWR VGND sg13g2_fill_1
XFILLER_47_514 VPWR VGND sg13g2_decap_8
XFILLER_120_279 VPWR VGND sg13g2_fill_2
Xfanout184 net187 net184 VPWR VGND sg13g2_buf_2
XFILLER_59_374 VPWR VGND sg13g2_decap_8
Xfanout195 net196 net195 VPWR VGND sg13g2_buf_1
XFILLER_86_171 VPWR VGND sg13g2_decap_8
XFILLER_86_182 VPWR VGND sg13g2_fill_1
XFILLER_47_64 VPWR VGND sg13g2_fill_1
X_13861_ _05170_ VPWR _05184_ VGND net280 _05168_ sg13g2_o21ai_1
X_15600_ _06819_ _06817_ _06853_ _06855_ VPWR VGND sg13g2_a21o_1
XFILLER_62_506 VPWR VGND sg13g2_decap_4
X_12812_ _04174_ net731 net843 VPWR VGND sg13g2_nand2_1
X_16580_ VGND VPWR u_LMS.w\[3\]\[13\] _07773_ _07777_ _07774_ sg13g2_a21oi_1
X_13792_ _05112_ _05114_ _05117_ VPWR VGND sg13g2_nor2_1
X_15531_ _06767_ _06762_ _06760_ _06788_ VPWR VGND sg13g2_a21o_1
X_12743_ _04104_ _04106_ _04107_ VPWR VGND sg13g2_nor2_1
XFILLER_27_293 VPWR VGND sg13g2_fill_1
XFILLER_70_550 VPWR VGND sg13g2_fill_2
X_18250_ net127 _09359_ net678 _09360_ VPWR VGND sg13g2_nand3_1
X_15462_ _06724_ u_FIR.sum\[5\]\[17\] net394 VPWR VGND sg13g2_xnor2_1
X_12674_ _04040_ _04039_ _04002_ VPWR VGND sg13g2_nand2b_1
XFILLER_15_488 VPWR VGND sg13g2_decap_4
X_17201_ _08157_ _08151_ _08357_ VPWR VGND sg13g2_xor2_1
XFILLER_8_14 VPWR VGND sg13g2_decap_8
XFILLER_31_959 VPWR VGND sg13g2_fill_2
X_14413_ _05715_ u_FIR.sum\[3\]\[15\] net399 VPWR VGND sg13g2_nand2_1
X_23175__1525 VPWR VGND net1524 sg13g2_tiehi
X_23203__1476 VPWR VGND net1475 sg13g2_tiehi
X_18181_ VGND VPWR _09288_ _09290_ _09291_ _09261_ sg13g2_a21oi_1
X_15393_ _06636_ _06658_ _06659_ VPWR VGND sg13g2_nor2_1
XFILLER_30_458 VPWR VGND sg13g2_fill_2
X_17132_ _08263_ VPWR _08288_ VGND net417 net161 sg13g2_o21ai_1
X_14344_ _05649_ _05637_ _05648_ VPWR VGND sg13g2_xnor2_1
XFILLER_11_672 VPWR VGND sg13g2_decap_4
X_17063_ _08209_ _08218_ _08219_ VPWR VGND sg13g2_nor2_1
XFILLER_6_142 VPWR VGND sg13g2_fill_2
X_14275_ _05582_ _05567_ _05581_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_153 VPWR VGND sg13g2_fill_2
X_16014_ _07255_ _07232_ _07253_ VPWR VGND sg13g2_xnor2_1
XFILLER_109_593 VPWR VGND sg13g2_decap_4
X_13226_ _04571_ _04572_ _04573_ VPWR VGND sg13g2_nor2b_1
XFILLER_124_552 VPWR VGND sg13g2_fill_2
X_13157_ _04479_ _04505_ _04506_ VPWR VGND sg13g2_nor2_1
X_23072__1099 VPWR VGND net1098 sg13g2_tiehi
XFILLER_97_414 VPWR VGND sg13g2_decap_8
X_12108_ _03502_ VPWR _00043_ VGND _03518_ _03519_ sg13g2_o21ai_1
XFILLER_97_458 VPWR VGND sg13g2_decap_8
XFILLER_111_246 VPWR VGND sg13g2_fill_2
X_17965_ _09098_ _09036_ _09038_ VPWR VGND sg13g2_xnor2_1
X_13088_ _04439_ _04410_ _04437_ VPWR VGND sg13g2_xnor2_1
XFILLER_111_268 VPWR VGND sg13g2_fill_1
X_19704_ _10768_ net256 net649 net241 net651 VPWR VGND sg13g2_a22oi_1
XFILLER_84_108 VPWR VGND sg13g2_fill_2
X_16916_ _08072_ net705 net173 VPWR VGND sg13g2_nand2_1
X_12039_ _03454_ net288 coeff_force_packed\[62\] net292 coeff_force_packed\[20\] VPWR
+ VGND sg13g2_a22oi_1
X_17896_ _08997_ u_LMS.w\[1\]\[9\] _09029_ VPWR VGND sg13g2_xor2_1
XFILLER_66_834 VPWR VGND sg13g2_fill_1
XFILLER_77_182 VPWR VGND sg13g2_decap_8
X_19635_ _10697_ _10652_ _10699_ VPWR VGND sg13g2_xor2_1
X_16847_ VGND VPWR _08003_ _08002_ _03280_ sg13g2_or2_1
XFILLER_92_141 VPWR VGND sg13g2_decap_4
XFILLER_19_750 VPWR VGND sg13g2_decap_4
XFILLER_80_303 VPWR VGND sg13g2_fill_1
X_19566_ _10630_ net645 net241 VPWR VGND sg13g2_nand2_1
X_16778_ VGND VPWR _07931_ _07932_ _07934_ _03382_ sg13g2_a21oi_1
X_18517_ _09627_ _09626_ _09625_ VPWR VGND sg13g2_nand2b_1
X_15729_ _06980_ _06943_ _06946_ VPWR VGND sg13g2_nand2_1
X_19497_ VGND VPWR _10559_ _10560_ _10561_ _10558_ sg13g2_a21oi_1
XFILLER_22_904 VPWR VGND sg13g2_fill_2
XFILLER_33_252 VPWR VGND sg13g2_fill_2
XFILLER_61_572 VPWR VGND sg13g2_decap_4
X_18448_ _09558_ _09421_ _09554_ VPWR VGND sg13g2_nand2_1
XFILLER_22_948 VPWR VGND sg13g2_decap_8
X_18379_ _09489_ _09480_ _09487_ VPWR VGND sg13g2_xnor2_1
X_20410_ _01073_ net52 net2128 VPWR VGND sg13g2_nand2_2
X_21390_ _02007_ _02000_ _02006_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_335 VPWR VGND sg13g2_decap_8
X_20341_ u_LMS.w\[5\]\[2\] net264 net637 _01004_ VPWR VGND sg13g2_nand3_1
X_23394__1167 VPWR VGND net1166 sg13g2_tiehi
X_20272_ _00935_ _00863_ _00864_ VPWR VGND sg13g2_xnor2_1
X_23060_ net1116 VGND VPWR _00122_ u_FIR.sum\[4\]\[3\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
XFILLER_127_390 VPWR VGND sg13g2_fill_1
XFILLER_108_59 VPWR VGND sg13g2_fill_1
X_22011_ _02605_ _02592_ _02603_ VPWR VGND sg13g2_xnor2_1
XFILLER_102_202 VPWR VGND sg13g2_decap_4
XFILLER_25_1010 VPWR VGND sg13g2_decap_8
XFILLER_130_555 VPWR VGND sg13g2_decap_8
XFILLER_124_14 VPWR VGND sg13g2_decap_8
XFILLER_69_683 VPWR VGND sg13g2_fill_2
XFILLER_56_300 VPWR VGND sg13g2_fill_1
XFILLER_68_160 VPWR VGND sg13g2_decap_4
X_22913_ net1029 VPWR _03185_ VGND net554 u_s2p_input.reg_sh\[5\] sg13g2_o21ai_1
XFILLER_57_856 VPWR VGND sg13g2_decap_8
XFILLER_110_290 VPWR VGND sg13g2_fill_1
XFILLER_84_653 VPWR VGND sg13g2_fill_1
XFILLER_57_878 VPWR VGND sg13g2_decap_8
XFILLER_56_377 VPWR VGND sg13g2_fill_1
X_22844_ _03143_ net2207 _03137_ net551 u_p2s_output.reg_sh\[6\] VPWR VGND sg13g2_a22oi_1
XFILLER_37_591 VPWR VGND sg13g2_decap_8
X_23314__1288 VPWR VGND net1287 sg13g2_tiehi
X_22775_ VGND VPWR _07801_ net341 _00727_ _03105_ sg13g2_a21oi_1
X_21726_ VGND VPWR net49 _02323_ _02324_ net10 sg13g2_a21oi_1
XFILLER_40_723 VPWR VGND sg13g2_fill_2
XFILLER_33_11 VPWR VGND sg13g2_fill_1
XFILLER_40_756 VPWR VGND sg13g2_fill_1
X_21657_ _02161_ _02226_ _02227_ _02269_ VPWR VGND sg13g2_nor3_1
XFILLER_21_981 VPWR VGND sg13g2_fill_1
X_20608_ _03231_ net94 _01248_ VPWR VGND sg13g2_nor2_1
X_12390_ _03358_ net409 _03733_ _03768_ VPWR VGND sg13g2_nor3_1
X_21588_ _02205_ _03299_ _02178_ VPWR VGND sg13g2_nand2_1
XFILLER_126_817 VPWR VGND sg13g2_decap_4
X_23327_ net1274 VGND VPWR _00389_ u_LMS.w\[4\]\[6\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
X_20539_ net426 net136 _01179_ VPWR VGND sg13g2_nor2_1
XFILLER_126_839 VPWR VGND sg13g2_decap_8
X_14060_ _05372_ net757 net892 VPWR VGND sg13g2_nand2_1
XFILLER_3_112 VPWR VGND sg13g2_decap_8
X_23258_ net1377 VGND VPWR _00320_ u_LMS.w\[1\]\[6\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
X_13011_ VGND VPWR _04364_ _04365_ _04366_ net416 sg13g2_a21oi_1
X_22209_ u_LMS.w\[8\]\[9\] _02773_ _02803_ VPWR VGND sg13g2_nor2_1
XFILLER_106_574 VPWR VGND sg13g2_fill_2
X_23189_ net1499 VGND VPWR _00251_ u_FIR.w\[4\]\[6\] clknet_leaf_36_clkA sg13g2_dfrbpq_1
XFILLER_0_830 VPWR VGND sg13g2_decap_4
XFILLER_67_609 VPWR VGND sg13g2_fill_1
XFILLER_121_555 VPWR VGND sg13g2_fill_1
X_17750_ _08883_ _08852_ _08853_ VPWR VGND sg13g2_xnor2_1
X_14962_ _06238_ _06242_ _06243_ VPWR VGND sg13g2_nor2_1
XFILLER_87_480 VPWR VGND sg13g2_fill_1
X_16701_ VGND VPWR net528 _07864_ _00271_ _07865_ sg13g2_a21oi_1
X_13913_ net280 _05233_ _05234_ VPWR VGND sg13g2_nor2_1
X_17681_ _08814_ _08812_ _08813_ VPWR VGND sg13g2_xnor2_1
X_14893_ net1007 VPWR _06178_ VGND net509 u_FIR.sum\[5\]\[13\] sg13g2_o21ai_1
XFILLER_74_152 VPWR VGND sg13g2_decap_8
XFILLER_114_80 VPWR VGND sg13g2_fill_1
X_19420_ _10474_ _10473_ _10483_ _10484_ VPWR VGND sg13g2_a21o_1
XFILLER_63_826 VPWR VGND sg13g2_decap_4
X_16632_ VGND VPWR net518 _07814_ _00252_ _07815_ sg13g2_a21oi_1
X_13844_ _05168_ u_FIR.sum\[2\]\[12\] net403 VPWR VGND sg13g2_xnor2_1
XFILLER_62_325 VPWR VGND sg13g2_fill_1
XFILLER_90_645 VPWR VGND sg13g2_decap_4
XFILLER_74_196 VPWR VGND sg13g2_decap_4
X_19351_ _10410_ VPWR _10415_ VGND _10398_ _10408_ sg13g2_o21ai_1
X_16563_ net980 VPWR _07764_ VGND net485 net777 sg13g2_o21ai_1
X_13775_ VPWR _05101_ _05100_ VGND sg13g2_inv_1
XFILLER_15_241 VPWR VGND sg13g2_decap_8
X_18302_ _09412_ _09408_ _09410_ VPWR VGND sg13g2_xnor2_1
XFILLER_31_712 VPWR VGND sg13g2_fill_2
X_15514_ net973 VPWR _06772_ VGND net477 u_FIR.sum\[7\]\[2\] sg13g2_o21ai_1
X_12726_ _04077_ VPWR _04090_ VGND _04071_ _04075_ sg13g2_o21ai_1
X_19282_ net424 _03244_ net188 net162 _10346_ VPWR VGND sg13g2_nor4_1
X_16494_ _07712_ VPWR _07713_ VGND _07708_ _07709_ sg13g2_o21ai_1
XFILLER_71_892 VPWR VGND sg13g2_fill_2
XFILLER_95_7 VPWR VGND sg13g2_decap_4
XFILLER_15_296 VPWR VGND sg13g2_decap_4
X_18233_ _09343_ _09341_ _09342_ VPWR VGND sg13g2_nand2_1
X_15445_ _06707_ net276 _06708_ VPWR VGND sg13g2_xor2_1
X_12657_ _04020_ _04022_ _04023_ VPWR VGND sg13g2_nor2_1
XFILLER_90_83 VPWR VGND sg13g2_decap_8
XFILLER_90_94 VPWR VGND sg13g2_fill_2
XFILLER_128_110 VPWR VGND sg13g2_fill_2
X_18164_ VGND VPWR _09274_ _09271_ _09191_ sg13g2_or2_1
X_15376_ _06575_ _06641_ _06642_ VPWR VGND sg13g2_nor2_1
X_12588_ net883 u_FIR.sum\[0\]\[2\] net737 _03957_ VPWR VGND sg13g2_nand3_1
X_17115_ _08271_ _08264_ _08270_ VPWR VGND sg13g2_xnor2_1
X_14327_ VGND VPWR net513 _05631_ _00130_ _05632_ sg13g2_a21oi_1
X_18095_ net421 net420 net127 net98 _09205_ VPWR VGND sg13g2_nor4_1
XFILLER_128_187 VPWR VGND sg13g2_decap_4
X_17046_ _03275_ _08201_ _08202_ VPWR VGND sg13g2_nor2_1
Xrebuffer2107 _09653_ net2106 VPWR VGND sg13g2_buf_1
X_14258_ _05550_ VPWR _05565_ VGND _05546_ _05548_ sg13g2_o21ai_1
Xrebuffer2118 _09546_ net2117 VPWR VGND sg13g2_buf_1
Xrebuffer2129 _01072_ net2128 VPWR VGND sg13g2_buf_1
X_13209_ VGND VPWR _04538_ _04544_ _04556_ _04543_ sg13g2_a21oi_1
XFILLER_48_1032 VPWR VGND sg13g2_fill_1
XFILLER_112_500 VPWR VGND sg13g2_fill_1
X_14189_ _03366_ net409 _05458_ _05498_ VPWR VGND sg13g2_nor3_1
Xfanout909 net910 net909 VPWR VGND sg13g2_buf_1
XFILLER_112_533 VPWR VGND sg13g2_decap_8
XFILLER_124_393 VPWR VGND sg13g2_decap_8
XFILLER_98_767 VPWR VGND sg13g2_decap_8
X_18997_ VGND VPWR _10082_ _10083_ _10084_ _10081_ sg13g2_a21oi_1
XFILLER_97_255 VPWR VGND sg13g2_fill_2
XFILLER_79_981 VPWR VGND sg13g2_decap_4
X_17948_ VGND VPWR _09081_ _09080_ _09078_ sg13g2_or2_1
XFILLER_17_0 VPWR VGND sg13g2_decap_8
XFILLER_66_642 VPWR VGND sg13g2_decap_8
X_17879_ _09008_ VPWR _09012_ VGND _09009_ _09010_ sg13g2_o21ai_1
XFILLER_39_878 VPWR VGND sg13g2_decap_8
XFILLER_65_152 VPWR VGND sg13g2_fill_1
X_19618_ net652 net224 net649 _10682_ VPWR VGND net206 sg13g2_nand4_1
X_20890_ _01530_ _01528_ _01529_ VPWR VGND sg13g2_nand2b_1
XFILLER_0_1034 VPWR VGND sg13g2_decap_8
XFILLER_0_70 VPWR VGND sg13g2_decap_8
XFILLER_80_133 VPWR VGND sg13g2_decap_8
X_19549_ net652 net168 net650 _10613_ VPWR VGND net2114 sg13g2_nand4_1
XFILLER_94_1041 VPWR VGND sg13g2_fill_2
X_22560_ VGND VPWR u_LMS.count\[20\] _03035_ _03038_ u_LMS.count\[21\] sg13g2_a21oi_1
XFILLER_80_188 VPWR VGND sg13g2_decap_4
X_23497__1423 VPWR VGND net1422 sg13g2_tiehi
X_21511_ _02124_ VPWR _02128_ VGND _02119_ _02125_ sg13g2_o21ai_1
XFILLER_21_233 VPWR VGND sg13g2_fill_2
X_22491_ net958 VPWR _02995_ VGND net442 net581 sg13g2_o21ai_1
XFILLER_119_110 VPWR VGND sg13g2_decap_4
X_21442_ _02059_ _02049_ _02050_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_14 VPWR VGND sg13g2_decap_8
X_21373_ _01990_ _01980_ _01988_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_47 VPWR VGND sg13g2_fill_2
X_23112_ net1621 VGND VPWR _00174_ u_FIR.sum\[6\]\[17\] clknet_leaf_43_clkA sg13g2_dfrbpq_1
X_20324_ _00987_ _00936_ _00937_ VPWR VGND sg13g2_xnor2_1
X_23043_ net1141 VGND VPWR _00105_ u_FIR.sum\[3\]\[5\] clknet_leaf_33_clkA sg13g2_dfrbpq_1
X_20255_ _00918_ _00910_ _00914_ VPWR VGND sg13g2_xnor2_1
XFILLER_116_894 VPWR VGND sg13g2_decap_8
XFILLER_115_382 VPWR VGND sg13g2_fill_2
XFILLER_0_126 VPWR VGND sg13g2_decap_8
X_20186_ _00845_ VPWR _00849_ VGND _11191_ _00841_ sg13g2_o21ai_1
XFILLER_88_244 VPWR VGND sg13g2_decap_8
XFILLER_130_330 VPWR VGND sg13g2_decap_8
XFILLER_77_918 VPWR VGND sg13g2_fill_1
XFILLER_130_341 VPWR VGND sg13g2_fill_1
XFILLER_89_789 VPWR VGND sg13g2_decap_8
XFILLER_103_599 VPWR VGND sg13g2_fill_2
XFILLER_29_355 VPWR VGND sg13g2_fill_1
X_23719__1390 VPWR VGND net1389 sg13g2_tiehi
XFILLER_72_623 VPWR VGND sg13g2_decap_8
X_11890_ VPWR _03311_ u_LMS.w\[5\]\[10\] VGND sg13g2_inv_1
XFILLER_71_100 VPWR VGND sg13g2_fill_2
XFILLER_45_848 VPWR VGND sg13g2_decap_8
XFILLER_72_645 VPWR VGND sg13g2_decap_4
X_22827_ VGND VPWR _07876_ net344 _00753_ _03131_ sg13g2_a21oi_1
XFILLER_44_369 VPWR VGND sg13g2_decap_8
XFILLER_71_155 VPWR VGND sg13g2_fill_1
X_13560_ VGND VPWR _04891_ _04889_ _04860_ sg13g2_or2_1
XFILLER_71_188 VPWR VGND sg13g2_fill_2
XFILLER_25_583 VPWR VGND sg13g2_fill_2
X_22758_ u_debug_unit.mon_w3_sync\[2\] net334 _03097_ VPWR VGND sg13g2_nor2_1
XFILLER_25_594 VPWR VGND sg13g2_fill_1
X_12511_ _03884_ VPWR _03886_ VGND _03851_ _03854_ sg13g2_o21ai_1
X_21709_ _02311_ _02192_ _02193_ VPWR VGND sg13g2_xnor2_1
X_13491_ _04825_ net905 net752 net893 net753 VPWR VGND sg13g2_a22oi_1
X_22689_ coeff_force_packed\[55\] net461 _03068_ _00678_ VPWR VGND sg13g2_mux2_1
X_15230_ _06498_ _06499_ _06500_ VPWR VGND sg13g2_and2_1
X_12442_ _03817_ VPWR _03819_ VGND _03781_ _03784_ sg13g2_o21ai_1
XFILLER_60_31 VPWR VGND sg13g2_fill_1
XFILLER_8_259 VPWR VGND sg13g2_fill_2
XFILLER_121_0 VPWR VGND sg13g2_decap_8
X_15161_ _06433_ _06415_ _06431_ VPWR VGND sg13g2_xnor2_1
X_12373_ _03742_ VPWR _03751_ VGND _03714_ _03743_ sg13g2_o21ai_1
XFILLER_126_625 VPWR VGND sg13g2_decap_8
X_14112_ _05423_ _05415_ _05421_ VPWR VGND sg13g2_xnor2_1
X_15092_ _06366_ _06338_ _06365_ VPWR VGND sg13g2_xnor2_1
XFILLER_126_669 VPWR VGND sg13g2_decap_8
XFILLER_119_1019 VPWR VGND sg13g2_decap_8
X_18920_ _10007_ _09961_ _09968_ VPWR VGND sg13g2_xnor2_1
X_14043_ _05356_ _05354_ _05355_ VPWR VGND sg13g2_nand2_1
XFILLER_106_371 VPWR VGND sg13g2_fill_1
XFILLER_107_894 VPWR VGND sg13g2_decap_4
X_18851_ _09903_ _09899_ _09938_ VPWR VGND sg13g2_xor2_1
X_17802_ _08935_ _08927_ _08931_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_374 VPWR VGND sg13g2_decap_8
X_18782_ _09869_ _09802_ _09804_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_385 VPWR VGND sg13g2_fill_2
X_15994_ net872 u_FIR.sum\[7\]\[2\] net801 _07235_ VPWR VGND sg13g2_nand3_1
XFILLER_10_7 VPWR VGND sg13g2_decap_8
X_17733_ _08795_ _08865_ _08866_ VPWR VGND sg13g2_nor2b_1
X_14945_ _06227_ _06200_ _06225_ VPWR VGND sg13g2_xnor2_1
XFILLER_78_1014 VPWR VGND sg13g2_fill_2
XFILLER_76_995 VPWR VGND sg13g2_fill_2
XFILLER_36_826 VPWR VGND sg13g2_decap_4
X_17664_ VPWR _08797_ _08796_ VGND sg13g2_inv_1
XFILLER_47_174 VPWR VGND sg13g2_fill_2
X_14876_ VGND VPWR _06161_ _06159_ _06158_ sg13g2_or2_1
X_19403_ _10467_ _10455_ _10462_ VPWR VGND sg13g2_xnor2_1
X_16615_ VGND VPWR net515 _07801_ _00248_ _07802_ sg13g2_a21oi_1
X_13827_ VGND VPWR _05119_ _05143_ _05151_ _05142_ sg13g2_a21oi_1
XFILLER_90_453 VPWR VGND sg13g2_decap_8
X_17595_ _08728_ _08725_ _08726_ VPWR VGND sg13g2_xnor2_1
X_19334_ VGND VPWR _10372_ _10383_ _10398_ _10382_ sg13g2_a21oi_1
X_16546_ u_LMS.w\[2\]\[24\] u_LMS.w\[2\]\[23\] u_LMS.w\[2\]\[22\] u_LMS.w\[2\]\[21\]
+ _07751_ VPWR VGND sg13g2_nor4_1
X_13758_ _05052_ _05045_ _05059_ _05084_ VPWR VGND sg13g2_a21o_1
XFILLER_90_497 VPWR VGND sg13g2_decap_8
X_12709_ _04072_ _04073_ _04074_ VPWR VGND sg13g2_nor2_1
X_19265_ _10334_ net55 _10333_ VPWR VGND sg13g2_nand2_1
X_16477_ _07700_ u_FIR.x\[4\] net524 VPWR VGND sg13g2_nand2_1
X_13689_ _05014_ _05015_ _05016_ _05017_ VPWR VGND sg13g2_nor3_1
XFILLER_15_1020 VPWR VGND sg13g2_fill_1
X_18216_ _09326_ net669 net235 VPWR VGND sg13g2_nand2_1
X_15428_ _06692_ _06644_ _06690_ VPWR VGND sg13g2_xnor2_1
X_19196_ _10280_ net309 u_LMS.w\[3\]\[15\] coeff_force_packed\[24\] net559 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_15_1042 VPWR VGND sg13g2_decap_8
XFILLER_102_1023 VPWR VGND sg13g2_decap_4
X_18147_ _09257_ _09221_ _09256_ VPWR VGND sg13g2_xnor2_1
X_15359_ _06626_ _06619_ _06624_ VPWR VGND sg13g2_xnor2_1
XFILLER_116_113 VPWR VGND sg13g2_decap_4
X_18078_ _09188_ net678 net144 VPWR VGND sg13g2_nand2_1
XFILLER_132_606 VPWR VGND sg13g2_decap_8
XFILLER_104_319 VPWR VGND sg13g2_fill_1
X_17029_ _08185_ _08181_ _08183_ VPWR VGND sg13g2_xnor2_1
XFILLER_113_820 VPWR VGND sg13g2_decap_8
XFILLER_113_831 VPWR VGND sg13g2_decap_8
X_20040_ _11081_ _11080_ _11079_ VPWR VGND sg13g2_nand2b_1
Xfanout706 u_LMS.x_r\[0\]\[4\] net706 VPWR VGND sg13g2_buf_1
XFILLER_113_842 VPWR VGND sg13g2_fill_1
Xfanout717 u_LMS.w\[3\]\[24\] net717 VPWR VGND sg13g2_buf_1
Xfanout728 u_FIR.w\[8\]\[0\] net728 VPWR VGND sg13g2_buf_1
XFILLER_59_918 VPWR VGND sg13g2_decap_8
Xfanout739 net740 net739 VPWR VGND sg13g2_buf_1
XFILLER_85_203 VPWR VGND sg13g2_fill_2
XFILLER_98_597 VPWR VGND sg13g2_fill_1
XFILLER_100_569 VPWR VGND sg13g2_decap_8
XFILLER_38_130 VPWR VGND sg13g2_decap_4
X_21991_ _02585_ _02575_ _02583_ VPWR VGND sg13g2_xnor2_1
XFILLER_67_984 VPWR VGND sg13g2_decap_4
X_23730_ net998 VGND VPWR _00792_ u_spi_slave.tx_cnt\[0\] net1636 sg13g2_dfrbpq_1
X_20942_ _01582_ u_LMS.w\[6\]\[11\] _01581_ VPWR VGND sg13g2_nand2_1
XFILLER_53_111 VPWR VGND sg13g2_decap_8
XFILLER_27_848 VPWR VGND sg13g2_decap_8
XFILLER_82_954 VPWR VGND sg13g2_decap_4
XFILLER_53_122 VPWR VGND sg13g2_fill_2
X_23661_ net989 VGND VPWR _00723_ u_debug_unit.mon_w3_sync\[6\] clknet_leaf_38_clkA
+ sg13g2_dfrbpq_1
XFILLER_53_144 VPWR VGND sg13g2_decap_4
X_20873_ _01507_ _01512_ _01513_ VPWR VGND sg13g2_nor2_1
XFILLER_121_48 VPWR VGND sg13g2_fill_2
X_22612_ net470 sys_enable_bus\[1\] _03060_ _00609_ VPWR VGND sg13g2_mux2_1
X_23592_ net963 VGND VPWR _00654_ coeff_force_packed\[34\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_22543_ net916 _03027_ _00573_ VPWR VGND sg13g2_nor2_1
XFILLER_22_553 VPWR VGND sg13g2_decap_8
XFILLER_50_873 VPWR VGND sg13g2_fill_2
XFILLER_14_57 VPWR VGND sg13g2_decap_4
XFILLER_50_884 VPWR VGND sg13g2_decap_8
XFILLER_10_748 VPWR VGND sg13g2_decap_8
X_22474_ VGND VPWR net447 _03232_ _00545_ _02986_ sg13g2_a21oi_1
X_21425_ _02041_ _02014_ _02042_ VPWR VGND sg13g2_xor2_1
XFILLER_107_113 VPWR VGND sg13g2_fill_1
X_21356_ net132 net600 _01971_ _01973_ VPWR VGND sg13g2_a21o_1
X_20307_ _00970_ _00959_ _00969_ VPWR VGND sg13g2_xnor2_1
XFILLER_2_936 VPWR VGND sg13g2_decap_8
XFILLER_122_116 VPWR VGND sg13g2_fill_2
X_21287_ _01904_ net598 net170 VPWR VGND sg13g2_nand2_1
X_23026_ net1167 VGND VPWR _00088_ u_FIR.sum\[2\]\[7\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
X_20238_ _00886_ _00899_ _00901_ VPWR VGND sg13g2_xor2_1
XFILLER_118_1052 VPWR VGND sg13g2_decap_8
XFILLER_104_875 VPWR VGND sg13g2_decap_8
XFILLER_77_726 VPWR VGND sg13g2_fill_1
XFILLER_103_374 VPWR VGND sg13g2_decap_4
XFILLER_39_65 VPWR VGND sg13g2_decap_8
XFILLER_131_683 VPWR VGND sg13g2_fill_1
X_20169_ _00830_ _00831_ _00832_ VPWR VGND sg13g2_nor2_1
X_12991_ _04348_ _04347_ _04342_ VPWR VGND sg13g2_nand2b_1
XFILLER_85_770 VPWR VGND sg13g2_fill_1
X_14730_ _06019_ _06011_ _06018_ VPWR VGND sg13g2_xnor2_1
X_11942_ VPWR _03363_ u_FIR.w\[5\]\[6\] VGND sg13g2_inv_1
XFILLER_91_228 VPWR VGND sg13g2_fill_1
XFILLER_18_859 VPWR VGND sg13g2_fill_1
XFILLER_55_53 VPWR VGND sg13g2_decap_8
X_14661_ net774 net806 _05952_ VPWR VGND sg13g2_and2_1
XFILLER_72_453 VPWR VGND sg13g2_fill_2
X_11873_ VPWR _03294_ u_LMS.w\[8\]\[6\] VGND sg13g2_inv_1
XFILLER_33_818 VPWR VGND sg13g2_decap_8
XFILLER_44_155 VPWR VGND sg13g2_decap_8
XFILLER_32_306 VPWR VGND sg13g2_fill_1
X_16400_ VGND VPWR _07631_ _07630_ net270 sg13g2_or2_1
X_13612_ _04897_ _04899_ _04942_ VPWR VGND sg13g2_and2_1
X_17380_ VGND VPWR u_LMS.w\[0\]\[19\] net313 _08529_ _08524_ sg13g2_a21oi_1
X_14592_ _05850_ _05884_ _05848_ _05885_ VPWR VGND sg13g2_nand3_1
XFILLER_13_520 VPWR VGND sg13g2_fill_2
XFILLER_111_70 VPWR VGND sg13g2_fill_2
XFILLER_111_81 VPWR VGND sg13g2_fill_1
X_16331_ _07565_ u_FIR.sum\[7\]\[12\] net387 VPWR VGND sg13g2_nand2_1
X_13543_ _04875_ _04874_ _04838_ VPWR VGND sg13g2_nand2b_1
XFILLER_125_1023 VPWR VGND sg13g2_decap_8
XFILLER_41_873 VPWR VGND sg13g2_decap_8
XFILLER_40_361 VPWR VGND sg13g2_decap_8
X_19050_ VGND VPWR _10066_ _10137_ _10136_ _10135_ sg13g2_a21oi_2
X_16262_ _07498_ _07483_ _07497_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_546 VPWR VGND sg13g2_decap_4
X_13474_ net905 u_FIR.sum\[2\]\[0\] net755 _04810_ VPWR VGND sg13g2_nand3_1
X_23017__1181 VPWR VGND net1180 sg13g2_tiehi
X_23424__1077 VPWR VGND net1076 sg13g2_tiehi
X_18001_ VGND VPWR u_LMS.w\[1\]\[19\] net301 _09127_ _09122_ sg13g2_a21oi_1
X_15213_ _06483_ _06452_ _06484_ VPWR VGND sg13g2_xor2_1
X_12425_ _03802_ _03794_ _03801_ VPWR VGND sg13g2_xnor2_1
X_16193_ _07431_ _07388_ _07429_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_934 VPWR VGND sg13g2_fill_2
XFILLER_127_945 VPWR VGND sg13g2_fill_2
X_15144_ _06416_ _06378_ _06380_ VPWR VGND sg13g2_nand2_1
X_12356_ _03735_ _03734_ _03732_ VPWR VGND sg13g2_nand2b_1
XFILLER_5_741 VPWR VGND sg13g2_decap_4
XFILLER_58_7 VPWR VGND sg13g2_fill_2
XFILLER_126_477 VPWR VGND sg13g2_fill_2
XFILLER_126_488 VPWR VGND sg13g2_decap_8
X_19952_ _10991_ _10992_ _10993_ VPWR VGND sg13g2_nor2_1
X_23463__1543 VPWR VGND net1542 sg13g2_tiehi
X_15075_ _06349_ _06348_ _06344_ VPWR VGND sg13g2_nand2b_1
XFILLER_114_639 VPWR VGND sg13g2_decap_8
X_12287_ _03668_ _03651_ _03666_ VPWR VGND sg13g2_xnor2_1
XFILLER_126_499 VPWR VGND sg13g2_fill_2
XFILLER_45_1002 VPWR VGND sg13g2_fill_1
XFILLER_113_138 VPWR VGND sg13g2_decap_8
X_18903_ _09982_ _09989_ _09990_ VPWR VGND sg13g2_nor2b_1
X_14026_ _05340_ _05318_ _05338_ VPWR VGND sg13g2_xnor2_1
X_19883_ _10927_ _10789_ _10791_ VPWR VGND sg13g2_xnor2_1
XFILLER_122_650 VPWR VGND sg13g2_fill_1
XFILLER_110_801 VPWR VGND sg13g2_fill_2
X_18834_ _09921_ net660 net165 VPWR VGND sg13g2_nand2_1
XFILLER_49_940 VPWR VGND sg13g2_decap_4
XFILLER_132_1038 VPWR VGND sg13g2_decap_8
XFILLER_96_93 VPWR VGND sg13g2_decap_4
X_18765_ _09848_ VPWR _09852_ VGND _09849_ _09850_ sg13g2_o21ai_1
X_15977_ VGND VPWR _07205_ _07209_ _07219_ _07203_ sg13g2_a21oi_1
XFILLER_49_973 VPWR VGND sg13g2_decap_8
XFILLER_48_461 VPWR VGND sg13g2_decap_4
XFILLER_82_217 VPWR VGND sg13g2_decap_4
X_17716_ VGND VPWR _08841_ _08848_ _08849_ _08840_ sg13g2_a21oi_1
X_14928_ _06211_ _06209_ _06210_ VPWR VGND sg13g2_nand2_1
X_18696_ _09783_ _09774_ _09782_ VPWR VGND sg13g2_nand2b_1
XFILLER_63_442 VPWR VGND sg13g2_decap_8
X_17647_ net130 net696 _08765_ _08780_ VPWR VGND sg13g2_a21o_1
XFILLER_24_818 VPWR VGND sg13g2_decap_8
X_14859_ _06119_ _06144_ _06145_ VPWR VGND sg13g2_nor2_1
XFILLER_36_689 VPWR VGND sg13g2_decap_8
X_17578_ _03271_ net140 _08711_ VPWR VGND sg13g2_nor2_1
XFILLER_91_1022 VPWR VGND sg13g2_decap_8
X_19317_ _10381_ _10375_ _10380_ VPWR VGND sg13g2_xnor2_1
X_16529_ VGND VPWR u_LMS.w\[1\]\[14\] _07733_ _07739_ _07734_ sg13g2_a21oi_1
XFILLER_50_158 VPWR VGND sg13g2_decap_4
XFILLER_52_1017 VPWR VGND sg13g2_decap_4
XFILLER_31_350 VPWR VGND sg13g2_decap_8
XFILLER_84_0 VPWR VGND sg13g2_decap_8
X_19248_ net354 VPWR _10322_ VGND u_LMS.w\[3\]\[2\] net370 sg13g2_o21ai_1
X_19179_ _10262_ _10265_ _10266_ VPWR VGND sg13g2_nor2_1
XFILLER_118_945 VPWR VGND sg13g2_decap_8
X_21210_ _01827_ _01790_ _01826_ VPWR VGND sg13g2_xnor2_1
X_22190_ _02784_ u_LMS.w\[8\]\[3\] _02783_ VPWR VGND sg13g2_nand2_1
X_21141_ _01758_ net84 _01756_ VPWR VGND sg13g2_nand2b_1
XFILLER_6_91 VPWR VGND sg13g2_decap_8
XFILLER_104_127 VPWR VGND sg13g2_decap_8
X_21072_ _01702_ net317 u_LMS.w\[6\]\[22\] coeff_force_packed\[48\] net565 VPWR VGND
+ sg13g2_a22oi_1
Xfanout503 net504 net503 VPWR VGND sg13g2_buf_1
XFILLER_99_862 VPWR VGND sg13g2_fill_1
Xfanout514 net550 net514 VPWR VGND sg13g2_buf_1
XFILLER_101_801 VPWR VGND sg13g2_decap_8
Xfanout525 net526 net525 VPWR VGND sg13g2_buf_1
Xfanout536 net537 net536 VPWR VGND sg13g2_buf_1
X_20023_ _11064_ _11063_ _11059_ VPWR VGND sg13g2_nand2b_1
Xfanout547 net548 net547 VPWR VGND sg13g2_buf_1
Xfanout558 net560 net558 VPWR VGND sg13g2_buf_1
Xfanout569 debug_load_bus\[0\] net569 VPWR VGND sg13g2_buf_1
XFILLER_132_14 VPWR VGND sg13g2_decap_8
XFILLER_100_388 VPWR VGND sg13g2_fill_1
XFILLER_73_228 VPWR VGND sg13g2_fill_1
X_21974_ _02566_ _02565_ _02568_ VPWR VGND sg13g2_xor2_1
XFILLER_55_943 VPWR VGND sg13g2_decap_4
XFILLER_66_291 VPWR VGND sg13g2_decap_4
X_23713_ net1431 VGND VPWR _00775_ u_FIR.x\[2\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
XFILLER_54_442 VPWR VGND sg13g2_fill_2
X_20925_ _01564_ _01562_ _01565_ VPWR VGND sg13g2_xor2_1
XFILLER_42_615 VPWR VGND sg13g2_decap_8
XFILLER_42_626 VPWR VGND sg13g2_fill_2
X_23644_ net981 VGND VPWR _00706_ u_debug_unit.mon_w1_sync\[3\] clknet_leaf_52_clkA
+ sg13g2_dfrbpq_1
X_20856_ _01496_ _01491_ _01492_ VPWR VGND sg13g2_xnor2_1
XFILLER_41_147 VPWR VGND sg13g2_decap_4
XFILLER_25_78 VPWR VGND sg13g2_fill_2
X_23575_ net956 VGND VPWR _00637_ coeff_force_packed\[19\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
X_20787_ VGND VPWR _01425_ net2074 _01427_ _01423_ sg13g2_a21oi_1
XFILLER_23_884 VPWR VGND sg13g2_decap_8
X_22526_ _03017_ u_LMS.count\[8\] u_LMS.count\[7\] _03014_ VPWR VGND sg13g2_and3_1
XFILLER_22_383 VPWR VGND sg13g2_decap_8
XFILLER_6_505 VPWR VGND sg13g2_decap_8
XFILLER_6_516 VPWR VGND sg13g2_fill_2
X_22457_ net961 VPWR _02978_ VGND net450 net617 sg13g2_o21ai_1
XFILLER_108_422 VPWR VGND sg13g2_decap_4
X_12210_ _03595_ net906 net725 net894 net727 VPWR VGND sg13g2_a22oi_1
XFILLER_108_444 VPWR VGND sg13g2_fill_2
X_21408_ _01955_ VPWR _02025_ VGND _03226_ net141 sg13g2_o21ai_1
X_13190_ _04499_ u_FIR.w\[6\]\[6\] _04497_ _04538_ VPWR VGND sg13g2_a21o_1
X_22388_ VGND VPWR net453 net418 _00502_ _02943_ sg13g2_a21oi_1
X_12141_ _03549_ _03550_ _03541_ _03551_ VPWR VGND sg13g2_nand3_1
X_21339_ net605 net170 net132 _01956_ VPWR VGND net603 sg13g2_nand4_1
XFILLER_29_1019 VPWR VGND sg13g2_decap_8
X_12072_ _03485_ _03438_ u_debug_unit.error_signal_sync\[4\] _03407_ u_debug_unit.mon_w1_sync\[4\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_89_361 VPWR VGND sg13g2_fill_1
X_23009_ net1192 VGND VPWR _00071_ u_FIR.sum\[1\]\[6\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
X_15900_ _07141_ _07143_ _07146_ VPWR VGND sg13g2_nor2_1
XFILLER_89_372 VPWR VGND sg13g2_decap_8
X_16880_ _08032_ VPWR _08036_ VGND _08033_ _08034_ sg13g2_o21ai_1
XFILLER_2_49 VPWR VGND sg13g2_decap_8
X_15831_ _07053_ _07079_ _07080_ VPWR VGND sg13g2_nor2_1
XFILLER_77_567 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_32_clkA clknet_4_13_0_clkA clknet_leaf_32_clkA VPWR VGND sg13g2_buf_8
X_18550_ net70 u_LMS.w\[2\]\[18\] _09660_ VPWR VGND sg13g2_xor2_1
XFILLER_131_1060 VPWR VGND sg13g2_fill_1
X_15762_ net495 VPWR _07013_ VGND _07011_ _07012_ sg13g2_o21ai_1
X_12974_ _04332_ _04315_ _04330_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_548 VPWR VGND sg13g2_fill_1
X_17501_ VGND VPWR _08608_ _08619_ _08634_ _08618_ sg13g2_a21oi_1
XFILLER_17_133 VPWR VGND sg13g2_fill_1
X_14713_ _05962_ _05964_ _06002_ _06003_ VPWR VGND sg13g2_or3_1
X_18481_ _09591_ _09566_ _09564_ VPWR VGND sg13g2_xnor2_1
X_11925_ VPWR _03346_ u_LMS.w\[1\]\[5\] VGND sg13g2_inv_1
X_15693_ _06943_ _06944_ _06945_ VPWR VGND sg13g2_and2_1
XFILLER_122_80 VPWR VGND sg13g2_decap_8
XFILLER_73_795 VPWR VGND sg13g2_decap_4
X_17432_ net365 VPWR _08570_ VGND u_LMS.w\[0\]\[7\] net383 sg13g2_o21ai_1
X_14644_ net877 _05934_ net767 _05935_ VPWR VGND sg13g2_nand3_1
X_11856_ VPWR _03277_ net705 VGND sg13g2_inv_1
XFILLER_82_51 VPWR VGND sg13g2_fill_1
XFILLER_32_136 VPWR VGND sg13g2_fill_2
XFILLER_82_84 VPWR VGND sg13g2_fill_2
X_17363_ net46 VPWR _08515_ VGND net44 _08514_ sg13g2_o21ai_1
X_14575_ _05866_ _05859_ _05868_ VPWR VGND sg13g2_xor2_1
X_11787_ VPWR _03208_ u_s2p_input.reg_sh\[2\] VGND sg13g2_inv_1
XFILLER_14_873 VPWR VGND sg13g2_decap_8
XFILLER_9_310 VPWR VGND sg13g2_fill_1
X_19102_ _10189_ _10132_ _10134_ VPWR VGND sg13g2_xnor2_1
XFILLER_14_895 VPWR VGND sg13g2_decap_4
XFILLER_13_372 VPWR VGND sg13g2_decap_8
X_16314_ VGND VPWR net486 _07547_ _00201_ _07548_ sg13g2_a21oi_1
X_13526_ VGND VPWR net523 _04857_ _00103_ _04858_ sg13g2_a21oi_1
XFILLER_119_709 VPWR VGND sg13g2_fill_2
X_17294_ VGND VPWR _08447_ _08448_ _08450_ _08422_ sg13g2_a21oi_1
X_19033_ _10120_ net196 _10119_ VPWR VGND sg13g2_nand2_1
X_23327__1275 VPWR VGND net1274 sg13g2_tiehi
X_16245_ _07468_ VPWR _07481_ VGND _07464_ _07466_ sg13g2_o21ai_1
X_13457_ _04797_ _04783_ _04796_ VPWR VGND sg13g2_nand2_1
XFILLER_9_376 VPWR VGND sg13g2_decap_8
XFILLER_12_1034 VPWR VGND sg13g2_decap_8
X_12408_ _03785_ VPWR _03786_ VGND net543 u_FIR.sum\[0\]\[8\] sg13g2_o21ai_1
X_16176_ _07414_ _07406_ _07413_ VPWR VGND sg13g2_xnor2_1
X_13388_ _04731_ _04710_ _04729_ VPWR VGND sg13g2_xnor2_1
XFILLER_115_915 VPWR VGND sg13g2_fill_2
XFILLER_5_560 VPWR VGND sg13g2_decap_8
X_15127_ _06400_ _06391_ _06399_ VPWR VGND sg13g2_nand2_1
X_12339_ _03692_ _03690_ _03717_ _03718_ VPWR VGND sg13g2_a21o_1
XFILLER_115_959 VPWR VGND sg13g2_decap_8
X_19935_ net154 VPWR _10976_ VGND net635 net638 sg13g2_o21ai_1
X_15058_ _06333_ _06304_ _06331_ VPWR VGND sg13g2_xnor2_1
XFILLER_68_501 VPWR VGND sg13g2_fill_2
X_14009_ _05323_ _05321_ _05322_ VPWR VGND sg13g2_nand2_1
XFILLER_96_832 VPWR VGND sg13g2_fill_2
X_19866_ _10913_ _10914_ _00387_ VPWR VGND sg13g2_nor2_1
X_22987__1226 VPWR VGND net1225 sg13g2_tiehi
XFILLER_95_320 VPWR VGND sg13g2_decap_4
XFILLER_122_491 VPWR VGND sg13g2_decap_4
X_18817_ _09898_ VPWR _09904_ VGND _09899_ _09903_ sg13g2_o21ai_1
XFILLER_68_578 VPWR VGND sg13g2_decap_8
X_19797_ _10860_ net311 u_LMS.w\[4\]\[13\] coeff_force_packed\[29\] net562 VPWR VGND
+ sg13g2_a22oi_1
X_18748_ _09835_ _09811_ _09833_ VPWR VGND sg13g2_xnor2_1
XFILLER_52_902 VPWR VGND sg13g2_fill_2
X_18679_ _09766_ net655 net128 VPWR VGND sg13g2_nand2_1
X_20710_ _01308_ _01306_ _01350_ VPWR VGND sg13g2_xor2_1
XFILLER_23_114 VPWR VGND sg13g2_fill_1
X_21690_ _02241_ VPWR _02296_ VGND _02240_ _02243_ sg13g2_o21ai_1
X_20641_ _01281_ net616 net88 VPWR VGND sg13g2_nand2_1
X_23360_ net1241 VGND VPWR _00422_ u_LMS.w\[6\]\[16\] clknet_leaf_23_clkA sg13g2_dfrbpq_1
XFILLER_20_832 VPWR VGND sg13g2_decap_8
X_20572_ _01211_ _01201_ _01212_ VPWR VGND sg13g2_xor2_1
XFILLER_109_208 VPWR VGND sg13g2_decap_8
X_22311_ VGND VPWR _02892_ _02893_ _00475_ net924 sg13g2_a21oi_1
XFILLER_20_876 VPWR VGND sg13g2_decap_8
X_23291_ net1313 VGND VPWR _00353_ u_LMS.w\[3\]\[16\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
XFILLER_11_14 VPWR VGND sg13g2_decap_4
X_22242_ _02836_ u_LMS.w\[8\]\[22\] net60 VPWR VGND sg13g2_nand2_1
XFILLER_118_753 VPWR VGND sg13g2_decap_4
XFILLER_106_915 VPWR VGND sg13g2_decap_8
XFILLER_127_14 VPWR VGND sg13g2_decap_8
XFILLER_3_519 VPWR VGND sg13g2_decap_4
XFILLER_118_786 VPWR VGND sg13g2_fill_1
X_22173_ _02767_ _02707_ _02717_ VPWR VGND sg13g2_xnor2_1
X_23137__1584 VPWR VGND net1583 sg13g2_tiehi
XFILLER_105_447 VPWR VGND sg13g2_decap_8
X_21124_ net427 _03219_ net188 net162 _01741_ VPWR VGND sg13g2_nor4_1
XFILLER_132_255 VPWR VGND sg13g2_decap_8
Xfanout300 _03141_ net300 VPWR VGND sg13g2_buf_1
Xfanout311 net312 net311 VPWR VGND sg13g2_buf_1
Xclkbuf_leaf_55_clkA clknet_4_3_0_clkA clknet_leaf_55_clkA VPWR VGND sg13g2_buf_8
Xfanout322 _08493_ net322 VPWR VGND sg13g2_buf_1
X_21055_ _01688_ _01561_ _01687_ VPWR VGND sg13g2_xnor2_1
Xfanout333 net334 net333 VPWR VGND sg13g2_buf_1
Xfanout344 net345 net344 VPWR VGND sg13g2_buf_1
Xfanout355 net356 net355 VPWR VGND sg13g2_buf_1
Xfanout366 net367 net366 VPWR VGND sg13g2_buf_1
X_20006_ _11047_ _10977_ _11046_ VPWR VGND sg13g2_nand2_1
Xfanout377 net385 net377 VPWR VGND sg13g2_buf_1
Xfanout388 net389 net388 VPWR VGND sg13g2_buf_1
XFILLER_101_675 VPWR VGND sg13g2_decap_8
Xfanout399 net400 net399 VPWR VGND sg13g2_buf_1
XFILLER_74_548 VPWR VGND sg13g2_fill_2
XFILLER_100_196 VPWR VGND sg13g2_decap_8
XFILLER_28_965 VPWR VGND sg13g2_fill_2
X_21957_ _02551_ net584 net167 VPWR VGND sg13g2_nand2_1
XFILLER_55_773 VPWR VGND sg13g2_decap_4
X_20908_ _01548_ _01546_ _01547_ VPWR VGND sg13g2_nand2_1
XFILLER_36_99 VPWR VGND sg13g2_decap_4
X_12690_ _04033_ _04042_ _04055_ VPWR VGND sg13g2_and2_1
X_21888_ _02476_ VPWR _02482_ VGND _02477_ _02481_ sg13g2_o21ai_1
X_23627_ net972 VGND VPWR _00689_ u_debug_unit.error_signal_sync\[1\] clknet_leaf_47_clkA
+ sg13g2_dfrbpq_1
XFILLER_70_776 VPWR VGND sg13g2_decap_8
X_20839_ _01479_ net618 net228 VPWR VGND sg13g2_nand2_1
XFILLER_23_670 VPWR VGND sg13g2_decap_8
X_14360_ VGND VPWR net513 _05663_ _00131_ _05664_ sg13g2_a21oi_1
X_23558_ net1015 VGND VPWR _00620_ coeff_force_packed\[4\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
XFILLER_122_1015 VPWR VGND sg13g2_decap_8
X_13311_ _04656_ _04638_ _04655_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_814 VPWR VGND sg13g2_decap_4
X_22509_ _03216_ _03003_ _03006_ VPWR VGND sg13g2_nor2_1
XFILLER_6_302 VPWR VGND sg13g2_fill_2
X_14291_ _05596_ _05563_ _05598_ VPWR VGND sg13g2_xor2_1
XFILLER_7_836 VPWR VGND sg13g2_decap_4
X_23489_ net1451 VGND VPWR _00551_ u_LMS.x_r\[8\]\[0\] clknet_leaf_7_clkA sg13g2_dfrbpq_1
X_16030_ net872 net801 u_FIR.sum\[7\]\[2\] _07271_ VPWR VGND sg13g2_a21o_1
X_13242_ _04589_ _04588_ _04555_ VPWR VGND sg13g2_nand2b_1
X_13173_ _04521_ net741 net868 VPWR VGND sg13g2_nand2_1
XFILLER_124_756 VPWR VGND sg13g2_fill_1
X_12124_ _03529_ _03530_ _03521_ _03535_ VPWR VGND _03534_ sg13g2_nand4_1
X_17981_ VGND VPWR _09109_ _09110_ _00306_ net923 sg13g2_a21oi_1
XFILLER_123_266 VPWR VGND sg13g2_fill_1
XFILLER_111_417 VPWR VGND sg13g2_decap_8
XFILLER_2_574 VPWR VGND sg13g2_decap_4
X_19720_ _10784_ u_LMS.w\[4\]\[7\] _10763_ VPWR VGND sg13g2_xnor2_1
X_16932_ _08081_ VPWR _08088_ VGND _07988_ _08082_ sg13g2_o21ai_1
X_12055_ _03469_ _03434_ u_debug_unit.mon_w0_sync\[5\] net293 coeff_force_packed\[54\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_96_139 VPWR VGND sg13g2_decap_8
XFILLER_77_73 VPWR VGND sg13g2_decap_8
XFILLER_77_342 VPWR VGND sg13g2_decap_8
X_19651_ _10714_ _10713_ _10715_ VPWR VGND sg13g2_nor2b_1
X_16863_ net156 VPWR _08019_ VGND net712 net715 sg13g2_o21ai_1
XFILLER_38_718 VPWR VGND sg13g2_decap_4
XFILLER_120_973 VPWR VGND sg13g2_decap_8
X_18602_ _09704_ net2104 _09705_ VPWR VGND sg13g2_xor2_1
X_15814_ _07063_ _07062_ _07061_ VPWR VGND sg13g2_nand2b_1
XFILLER_77_397 VPWR VGND sg13g2_fill_2
X_19582_ _10644_ _10643_ _10646_ VPWR VGND sg13g2_xor2_1
X_16794_ _07931_ _07949_ _07950_ VPWR VGND sg13g2_xor2_1
X_18533_ _09601_ VPWR _09643_ VGND _09641_ _09640_ sg13g2_o21ai_1
X_15745_ _06996_ _06979_ _06995_ VPWR VGND sg13g2_xnor2_1
X_12957_ VGND VPWR _04285_ _04296_ _04315_ _04303_ sg13g2_a21oi_1
XFILLER_34_924 VPWR VGND sg13g2_decap_4
XFILLER_33_401 VPWR VGND sg13g2_fill_1
XFILLER_34_935 VPWR VGND sg13g2_fill_2
XFILLER_73_592 VPWR VGND sg13g2_decap_8
X_18464_ _09244_ _09573_ _09226_ _09574_ VPWR VGND sg13g2_nand3_1
X_11908_ VPWR _03329_ u_LMS.w\[3\]\[10\] VGND sg13g2_inv_1
X_15676_ _06898_ _06928_ _06929_ VPWR VGND sg13g2_and2_1
X_12888_ VGND VPWR net545 _04247_ _00075_ _04248_ sg13g2_a21oi_1
XFILLER_60_231 VPWR VGND sg13g2_decap_8
X_22998__1210 VPWR VGND net1209 sg13g2_tiehi
X_17415_ VGND VPWR net58 _08556_ _08557_ net42 sg13g2_a21oi_1
X_14627_ _05917_ _05891_ _05919_ VPWR VGND sg13g2_xor2_1
X_18395_ _09456_ _09503_ _09505_ VPWR VGND sg13g2_nor2_1
X_11839_ VPWR _03260_ net670 VGND sg13g2_inv_1
XFILLER_60_286 VPWR VGND sg13g2_fill_1
X_17346_ _08502_ net315 u_LMS.w\[0\]\[12\] coeff_force_packed\[0\] net564 VPWR VGND
+ sg13g2_a22oi_1
X_14558_ net993 VPWR _05852_ VGND net491 u_FIR.sum\[5\]\[4\] sg13g2_o21ai_1
XFILLER_9_151 VPWR VGND sg13g2_decap_8
XFILLER_119_528 VPWR VGND sg13g2_decap_4
X_13509_ _04840_ _04823_ _04842_ VPWR VGND sg13g2_xor2_1
XFILLER_119_539 VPWR VGND sg13g2_decap_4
X_23248__1396 VPWR VGND net1395 sg13g2_tiehi
X_17277_ u_LMS.w\[0\]\[3\] _08430_ _08433_ VPWR VGND sg13g2_nor2_1
X_14489_ _05786_ _05784_ _05785_ VPWR VGND sg13g2_xnor2_1
X_19016_ _10101_ _10088_ _10103_ VPWR VGND sg13g2_xor2_1
X_16228_ _07465_ u_FIR.sum\[7\]\[9\] net386 VPWR VGND sg13g2_nand2_1
XFILLER_6_880 VPWR VGND sg13g2_fill_1
X_16159_ _07396_ _07363_ _07398_ VPWR VGND sg13g2_xor2_1
XFILLER_115_734 VPWR VGND sg13g2_fill_2
XFILLER_47_0 VPWR VGND sg13g2_decap_8
XFILLER_102_417 VPWR VGND sg13g2_decap_4
XFILLER_69_821 VPWR VGND sg13g2_decap_4
X_19918_ net154 VPWR _10959_ VGND net627 net629 sg13g2_o21ai_1
X_23133__1590 VPWR VGND net1589 sg13g2_tiehi
XFILLER_68_331 VPWR VGND sg13g2_decap_4
XFILLER_3_70 VPWR VGND sg13g2_decap_8
XFILLER_111_973 VPWR VGND sg13g2_fill_1
X_19849_ VGND VPWR _10900_ _10901_ _00383_ net931 sg13g2_a21oi_1
XFILLER_110_461 VPWR VGND sg13g2_decap_8
XFILLER_83_312 VPWR VGND sg13g2_decap_8
XFILLER_28_217 VPWR VGND sg13g2_decap_8
X_22860_ _07905_ _03138_ _03153_ VPWR VGND sg13g2_nor2_1
XFILLER_3_1021 VPWR VGND sg13g2_decap_8
XFILLER_84_868 VPWR VGND sg13g2_decap_8
X_21811_ _02395_ VPWR _02405_ VGND _02362_ _02396_ sg13g2_o21ai_1
XFILLER_37_762 VPWR VGND sg13g2_fill_1
X_22791_ VGND VPWR _07822_ net348 _00735_ _03113_ sg13g2_a21oi_1
XFILLER_83_389 VPWR VGND sg13g2_fill_2
XFILLER_64_570 VPWR VGND sg13g2_decap_4
X_21742_ _02336_ net576 net131 VPWR VGND sg13g2_nand2_1
XFILLER_19_1007 VPWR VGND sg13g2_fill_1
XFILLER_51_242 VPWR VGND sg13g2_fill_2
X_21673_ VGND VPWR _02277_ _02281_ _00448_ _02282_ sg13g2_a21oi_1
X_23412_ net1112 VGND VPWR _00474_ u_LMS.w\[8\]\[22\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
XFILLER_33_990 VPWR VGND sg13g2_decap_4
X_20624_ _01257_ _01263_ _01264_ VPWR VGND sg13g2_nor2b_1
X_23343_ net1258 VGND VPWR _00405_ u_LMS.w\[5\]\[22\] clknet_leaf_23_clkA sg13g2_dfrbpq_1
X_20555_ _01187_ _01172_ _01195_ VPWR VGND sg13g2_xor2_1
XFILLER_22_46 VPWR VGND sg13g2_fill_2
XFILLER_125_7 VPWR VGND sg13g2_decap_8
X_23274_ net1345 VGND VPWR _00336_ u_LMS.w\[2\]\[22\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
XFILLER_106_701 VPWR VGND sg13g2_decap_8
X_20486_ _01132_ _01013_ _01014_ VPWR VGND sg13g2_xnor2_1
X_22225_ VGND VPWR _02816_ _02817_ _02819_ _02763_ sg13g2_a21oi_1
XFILLER_98_39 VPWR VGND sg13g2_decap_8
XFILLER_106_734 VPWR VGND sg13g2_decap_4
XFILLER_79_607 VPWR VGND sg13g2_fill_1
X_22156_ _02750_ _02740_ _02749_ VPWR VGND sg13g2_xnor2_1
XFILLER_79_618 VPWR VGND sg13g2_decap_8
X_21107_ _01727_ _01728_ _00436_ VPWR VGND sg13g2_nor2_1
XFILLER_78_139 VPWR VGND sg13g2_decap_8
X_22087_ _02679_ _02634_ _02681_ VPWR VGND sg13g2_xor2_1
Xfanout130 net2114 net130 VPWR VGND sg13g2_buf_1
Xfanout141 net141 net143 VPWR VGND sg13g2_buf_4
Xfanout152 net157 net152 VPWR VGND sg13g2_buf_1
X_21038_ VGND VPWR _01673_ _01674_ _00421_ net938 sg13g2_a21oi_1
Xfanout163 _07942_ net163 VPWR VGND sg13g2_buf_8
XFILLER_75_802 VPWR VGND sg13g2_fill_1
Xfanout174 net174 net175 VPWR VGND sg13g2_buf_4
Xfanout185 net186 net185 VPWR VGND sg13g2_buf_1
XFILLER_74_301 VPWR VGND sg13g2_fill_2
Xfanout196 _08102_ net196 VPWR VGND sg13g2_buf_1
XFILLER_74_312 VPWR VGND sg13g2_decap_8
XFILLER_59_397 VPWR VGND sg13g2_fill_2
X_13860_ VGND VPWR _05152_ _05175_ _05183_ _05174_ sg13g2_a21oi_1
X_12811_ _04173_ _04138_ _04141_ VPWR VGND sg13g2_nand2_1
X_22989_ net1222 VGND VPWR _00051_ u_FIR.sum\[0\]\[1\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
X_13791_ VGND VPWR net537 _05115_ _00110_ _05116_ sg13g2_a21oi_1
XFILLER_63_20 VPWR VGND sg13g2_fill_2
X_15530_ _06787_ _06778_ _06785_ VPWR VGND sg13g2_xnor2_1
XFILLER_103_82 VPWR VGND sg13g2_fill_2
X_12742_ _04106_ net856 net732 net843 net733 VPWR VGND sg13g2_a22oi_1
XFILLER_16_968 VPWR VGND sg13g2_fill_2
XFILLER_15_445 VPWR VGND sg13g2_fill_2
XFILLER_70_540 VPWR VGND sg13g2_decap_4
XFILLER_15_467 VPWR VGND sg13g2_decap_8
X_15461_ u_FIR.sum\[5\]\[17\] net394 _06723_ VPWR VGND sg13g2_nor2b_1
X_12673_ _04038_ _04035_ _04039_ VPWR VGND sg13g2_xor2_1
X_17200_ VGND VPWR _08241_ _08247_ _08356_ _08240_ sg13g2_a21oi_1
X_14412_ VGND VPWR _05696_ _05706_ _05714_ _05705_ sg13g2_a21oi_1
X_18180_ _09290_ _09282_ _09289_ VPWR VGND sg13g2_nand2_1
XFILLER_129_804 VPWR VGND sg13g2_decap_8
X_15392_ _06658_ _06637_ _06657_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_600 VPWR VGND sg13g2_decap_8
XFILLER_128_303 VPWR VGND sg13g2_decap_8
X_17131_ _08286_ VPWR _08287_ VGND _08255_ _08284_ sg13g2_o21ai_1
X_14343_ _05648_ net279 _05646_ VPWR VGND sg13g2_xnor2_1
XFILLER_11_684 VPWR VGND sg13g2_fill_2
XFILLER_6_121 VPWR VGND sg13g2_decap_8
XFILLER_7_655 VPWR VGND sg13g2_fill_2
X_17062_ _08218_ _08213_ _08216_ VPWR VGND sg13g2_xnor2_1
X_14274_ _05580_ net279 _05581_ VPWR VGND sg13g2_xor2_1
X_16013_ _07254_ _07253_ _07232_ VPWR VGND sg13g2_nand2b_1
X_13225_ _04568_ VPWR _04572_ VGND _04569_ _04570_ sg13g2_o21ai_1
XFILLER_7_699 VPWR VGND sg13g2_fill_1
XFILLER_98_916 VPWR VGND sg13g2_fill_1
X_13156_ _04505_ _04495_ _04503_ VPWR VGND sg13g2_xnor2_1
XFILLER_98_938 VPWR VGND sg13g2_decap_8
XFILLER_69_117 VPWR VGND sg13g2_fill_2
Xclkbuf_leaf_7_clkA clknet_4_8_0_clkA clknet_leaf_7_clkA VPWR VGND sg13g2_buf_8
X_12107_ _00019_ VPWR _03519_ VGND u_spi_slave.tx_shift\[10\] net328 sg13g2_o21ai_1
XFILLER_69_128 VPWR VGND sg13g2_decap_4
X_17964_ VGND VPWR _09097_ _09096_ _09092_ sg13g2_or2_1
X_13087_ VGND VPWR _04438_ _04437_ _04410_ sg13g2_or2_1
XFILLER_78_640 VPWR VGND sg13g2_fill_2
X_19703_ _10767_ _10673_ _10708_ VPWR VGND sg13g2_xnor2_1
X_16915_ net193 _08069_ net703 _08071_ VPWR VGND sg13g2_nand3_1
X_12038_ VPWR _00047_ _03453_ VGND sg13g2_inv_1
X_17895_ u_LMS.w\[1\]\[9\] _08997_ _09028_ VPWR VGND sg13g2_nor2_1
XFILLER_120_770 VPWR VGND sg13g2_decap_4
X_19634_ _10698_ net649 net241 VPWR VGND sg13g2_nand2_1
X_16846_ _08002_ _07993_ _08001_ VPWR VGND sg13g2_nand2b_1
X_19565_ _10629_ net646 net240 VPWR VGND sg13g2_nand2_1
X_16777_ _07931_ _07932_ _07933_ VPWR VGND sg13g2_and2_1
XFILLER_92_164 VPWR VGND sg13g2_fill_2
XFILLER_81_838 VPWR VGND sg13g2_fill_1
XFILLER_65_389 VPWR VGND sg13g2_decap_8
X_13989_ VGND VPWR net492 _05303_ _00120_ _05304_ sg13g2_a21oi_1
XFILLER_19_795 VPWR VGND sg13g2_decap_8
XFILLER_18_272 VPWR VGND sg13g2_fill_1
X_18516_ _09626_ u_LMS.w\[2\]\[6\] _09609_ VPWR VGND sg13g2_xnor2_1
X_15728_ _06947_ _06940_ _06955_ _06979_ VPWR VGND sg13g2_a21o_1
X_19496_ _10560_ _10556_ _10557_ VPWR VGND sg13g2_xnor2_1
X_18447_ _09557_ _09424_ net1669 _09556_ VPWR VGND sg13g2_and3_1
XFILLER_22_927 VPWR VGND sg13g2_decap_8
XFILLER_21_404 VPWR VGND sg13g2_decap_8
X_15659_ net817 _06911_ net789 _06912_ VPWR VGND sg13g2_nand3_1
XFILLER_33_275 VPWR VGND sg13g2_fill_1
X_18378_ _09480_ _09487_ _09488_ VPWR VGND sg13g2_nor2b_1
XFILLER_21_459 VPWR VGND sg13g2_decap_4
X_17329_ VPWR _08485_ _08484_ VGND sg13g2_inv_1
X_20340_ _01003_ u_LMS.w\[5\]\[3\] _01002_ VPWR VGND sg13g2_nand2_1
X_20271_ _00885_ VPWR _00934_ VGND _00932_ _00931_ sg13g2_o21ai_1
XFILLER_89_905 VPWR VGND sg13g2_decap_8
X_22010_ VGND VPWR _02574_ _02584_ _02604_ _02603_ sg13g2_a21oi_1
XFILLER_115_553 VPWR VGND sg13g2_decap_8
XFILLER_89_938 VPWR VGND sg13g2_fill_1
XFILLER_130_534 VPWR VGND sg13g2_decap_8
XFILLER_102_269 VPWR VGND sg13g2_decap_4
XFILLER_29_526 VPWR VGND sg13g2_fill_2
XFILLER_112_1025 VPWR VGND sg13g2_decap_4
X_22912_ VGND VPWR net554 _03207_ _00785_ _03184_ sg13g2_a21oi_1
X_22843_ _03142_ _03139_ _03140_ VPWR VGND sg13g2_nand2b_1
XFILLER_84_687 VPWR VGND sg13g2_decap_8
XFILLER_44_518 VPWR VGND sg13g2_decap_4
XFILLER_16_209 VPWR VGND sg13g2_fill_1
XFILLER_17_46 VPWR VGND sg13g2_fill_1
XFILLER_56_389 VPWR VGND sg13g2_fill_2
XFILLER_25_710 VPWR VGND sg13g2_fill_1
XFILLER_65_890 VPWR VGND sg13g2_decap_8
XFILLER_17_79 VPWR VGND sg13g2_fill_2
X_22774_ u_debug_unit.mon_w4_sync\[3\] net341 _03105_ VPWR VGND sg13g2_nor2_1
X_23322__1280 VPWR VGND net1279 sg13g2_tiehi
X_21725_ _02323_ _02204_ _02206_ VPWR VGND sg13g2_xnor2_1
XFILLER_24_264 VPWR VGND sg13g2_decap_4
XFILLER_25_798 VPWR VGND sg13g2_fill_2
X_21656_ VGND VPWR _02267_ _02268_ _00445_ net932 sg13g2_a21oi_1
XFILLER_33_78 VPWR VGND sg13g2_fill_1
XFILLER_21_960 VPWR VGND sg13g2_fill_1
X_20607_ _03230_ net102 _01247_ VPWR VGND sg13g2_nor2_1
X_21587_ _02180_ u_LMS.w\[7\]\[7\] _02203_ _02204_ VPWR VGND sg13g2_a21o_1
X_23326_ net1275 VGND VPWR _00388_ u_LMS.w\[4\]\[5\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
X_20538_ _01178_ net610 net88 VPWR VGND sg13g2_nand2_1
X_23171__1532 VPWR VGND net1531 sg13g2_tiehi
XFILLER_126_829 VPWR VGND sg13g2_fill_1
X_23257_ net1379 VGND VPWR _00319_ u_LMS.w\[1\]\[5\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
X_20469_ _01119_ net384 _01072_ VPWR VGND sg13g2_nand2_1
X_13010_ net908 net746 u_FIR.sum\[1\]\[0\] _04365_ VPWR VGND sg13g2_a21o_1
X_22208_ VGND VPWR _02800_ _02801_ _02802_ _02776_ sg13g2_a21oi_1
X_23188_ net1501 VGND VPWR _00250_ u_FIR.w\[4\]\[5\] clknet_leaf_35_clkA sg13g2_dfrbpq_1
X_22139_ _02731_ _02732_ _02733_ VPWR VGND sg13g2_nor2_1
XFILLER_58_31 VPWR VGND sg13g2_decap_8
X_14961_ _06242_ _06221_ _06241_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_589 VPWR VGND sg13g2_fill_1
XFILLER_0_886 VPWR VGND sg13g2_decap_8
XFILLER_0_897 VPWR VGND sg13g2_fill_1
XFILLER_48_835 VPWR VGND sg13g2_decap_8
XFILLER_102_792 VPWR VGND sg13g2_decap_4
X_16700_ net1030 VPWR _07865_ VGND net528 u_FIR.w\[7\]\[5\] sg13g2_o21ai_1
X_13912_ _05233_ u_FIR.sum\[2\]\[15\] net402 VPWR VGND sg13g2_xnor2_1
X_17680_ _03273_ net140 _08813_ VPWR VGND sg13g2_nor2_1
X_14892_ _06175_ _06150_ _06177_ VPWR VGND sg13g2_xor2_1
X_16631_ net1024 VPWR _07815_ VGND net518 net755 sg13g2_o21ai_1
XFILLER_74_30 VPWR VGND sg13g2_fill_2
X_13843_ _05167_ u_FIR.sum\[2\]\[12\] net403 VPWR VGND sg13g2_nand2_1
XFILLER_90_613 VPWR VGND sg13g2_decap_8
XFILLER_90_635 VPWR VGND sg13g2_decap_4
X_19350_ _10414_ _10388_ _10413_ VPWR VGND sg13g2_nand2_1
X_16562_ VGND VPWR u_LMS.w\[2\]\[16\] _07753_ _07763_ _07754_ sg13g2_a21oi_1
X_13774_ _05056_ VPWR _05100_ VGND _05014_ _05054_ sg13g2_o21ai_1
X_18301_ _09411_ _09408_ _09410_ VPWR VGND sg13g2_nand2_1
X_15513_ _06769_ _06768_ _06771_ VPWR VGND sg13g2_xor2_1
XFILLER_43_562 VPWR VGND sg13g2_fill_1
X_19281_ VGND VPWR _10318_ _10344_ _00371_ _10345_ sg13g2_a21oi_1
X_12725_ VGND VPWR _04054_ _04082_ _04089_ _04081_ sg13g2_a21oi_1
XFILLER_16_787 VPWR VGND sg13g2_decap_8
X_16493_ _07712_ _07710_ _07711_ VPWR VGND sg13g2_nand2_1
XFILLER_128_1054 VPWR VGND sg13g2_decap_8
XFILLER_70_370 VPWR VGND sg13g2_fill_2
XFILLER_31_735 VPWR VGND sg13g2_decap_8
X_18232_ _09342_ _09302_ _09308_ VPWR VGND sg13g2_xnor2_1
XFILLER_130_91 VPWR VGND sg13g2_decap_8
X_15444_ net393 u_FIR.sum\[5\]\[16\] _06707_ VPWR VGND sg13g2_xor2_1
X_12656_ _04022_ net910 net730 net897 net731 VPWR VGND sg13g2_a22oi_1
X_18163_ _09273_ net676 net79 VPWR VGND sg13g2_nand2_1
X_15375_ _06609_ VPWR _06641_ VGND _03370_ net805 sg13g2_o21ai_1
X_12587_ _03954_ _03955_ _03956_ VPWR VGND sg13g2_nor2_1
XFILLER_8_942 VPWR VGND sg13g2_decap_4
X_17114_ _08268_ _08269_ _08270_ VPWR VGND sg13g2_nor2b_1
XFILLER_117_807 VPWR VGND sg13g2_fill_1
X_14326_ net1006 VPWR _05632_ VGND net513 u_FIR.sum\[4\]\[11\] sg13g2_o21ai_1
X_18094_ net421 net127 _09204_ VPWR VGND sg13g2_nor2_1
X_17045_ _08201_ _08199_ _08200_ VPWR VGND sg13g2_xnor2_1
XFILLER_99_60 VPWR VGND sg13g2_decap_4
XFILLER_116_339 VPWR VGND sg13g2_decap_4
X_14257_ VGND VPWR _05525_ _05555_ _05564_ _05554_ sg13g2_a21oi_1
Xrebuffer2108 _09379_ net2107 VPWR VGND sg13g2_buf_1
Xrebuffer2119 _07953_ net2118 VPWR VGND sg13g2_buf_1
XFILLER_99_82 VPWR VGND sg13g2_fill_2
XFILLER_48_1022 VPWR VGND sg13g2_decap_4
X_13208_ VGND VPWR _04518_ _04546_ _04555_ _04548_ sg13g2_a21oi_1
XFILLER_124_350 VPWR VGND sg13g2_fill_1
X_14188_ _05497_ net764 net807 VPWR VGND sg13g2_nand2_1
XFILLER_98_724 VPWR VGND sg13g2_decap_4
X_23364__1238 VPWR VGND net1237 sg13g2_tiehi
XFILLER_124_372 VPWR VGND sg13g2_decap_8
XFILLER_98_746 VPWR VGND sg13g2_decap_4
XFILLER_97_212 VPWR VGND sg13g2_fill_1
X_13139_ _04488_ net742 net855 VPWR VGND sg13g2_nand2_1
XFILLER_97_234 VPWR VGND sg13g2_fill_1
X_18996_ _10080_ _10079_ _10083_ VPWR VGND sg13g2_xor2_1
XFILLER_86_919 VPWR VGND sg13g2_decap_8
XFILLER_100_729 VPWR VGND sg13g2_fill_1
X_17947_ VGND VPWR u_LMS.w\[1\]\[21\] u_LMS.w\[1\]\[20\] _09080_ net77 sg13g2_a21oi_1
XFILLER_85_418 VPWR VGND sg13g2_decap_8
XFILLER_38_301 VPWR VGND sg13g2_decap_8
X_17878_ _09007_ u_LMS.w\[1\]\[3\] _09011_ VPWR VGND sg13g2_xor2_1
X_23241__1408 VPWR VGND net1407 sg13g2_tiehi
XFILLER_94_985 VPWR VGND sg13g2_decap_4
XFILLER_54_816 VPWR VGND sg13g2_decap_8
X_19617_ _10681_ net651 net203 VPWR VGND sg13g2_nand2_1
X_16829_ net912 net915 _07985_ VPWR VGND sg13g2_nor2_1
XFILLER_38_378 VPWR VGND sg13g2_fill_2
XFILLER_38_389 VPWR VGND sg13g2_decap_4
XFILLER_0_1013 VPWR VGND sg13g2_decap_8
XFILLER_93_484 VPWR VGND sg13g2_fill_1
XFILLER_65_197 VPWR VGND sg13g2_fill_1
X_19548_ _10612_ net650 net168 VPWR VGND sg13g2_nand2_1
X_19479_ _10543_ _10536_ _10537_ VPWR VGND sg13g2_xnor2_1
X_21510_ _02111_ _02126_ _02121_ _02127_ VPWR VGND sg13g2_nand3_1
X_22490_ VGND VPWR net445 _03223_ _00553_ _02994_ sg13g2_a21oi_1
X_21441_ VGND VPWR _02058_ _02057_ _02056_ sg13g2_or2_1
X_21372_ _01989_ _01988_ _01980_ VPWR VGND sg13g2_nand2b_1
XFILLER_119_37 VPWR VGND sg13g2_fill_2
X_23111_ net1622 VGND VPWR _00173_ u_FIR.sum\[6\]\[16\] clknet_leaf_43_clkA sg13g2_dfrbpq_1
X_20323_ _03321_ _00985_ _00986_ VPWR VGND sg13g2_nor2_1
X_23042_ net1143 VGND VPWR _00104_ u_FIR.sum\[3\]\[4\] clknet_leaf_33_clkA sg13g2_dfrbpq_1
X_20254_ _00917_ _00916_ _00908_ VPWR VGND sg13g2_nand2b_1
XFILLER_103_512 VPWR VGND sg13g2_decap_4
XFILLER_0_105 VPWR VGND sg13g2_decap_8
X_20185_ _00848_ _00839_ _00847_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_908 VPWR VGND sg13g2_fill_1
XFILLER_95_29 VPWR VGND sg13g2_fill_2
XFILLER_103_578 VPWR VGND sg13g2_decap_8
XFILLER_130_375 VPWR VGND sg13g2_decap_8
XFILLER_57_610 VPWR VGND sg13g2_decap_4
XFILLER_45_827 VPWR VGND sg13g2_decap_8
XFILLER_17_518 VPWR VGND sg13g2_decap_4
XFILLER_17_529 VPWR VGND sg13g2_decap_8
XFILLER_44_326 VPWR VGND sg13g2_decap_4
X_22826_ u_debug_unit.mon_w8_sync\[1\] net344 _03131_ VPWR VGND sg13g2_nor2_1
XFILLER_72_679 VPWR VGND sg13g2_decap_8
XFILLER_44_33 VPWR VGND sg13g2_fill_1
XFILLER_25_562 VPWR VGND sg13g2_decap_8
XFILLER_71_178 VPWR VGND sg13g2_fill_2
X_22757_ VGND VPWR _07777_ net334 _00718_ _03096_ sg13g2_a21oi_1
XFILLER_44_77 VPWR VGND sg13g2_decap_8
X_12510_ _03851_ _03854_ _03884_ _03885_ VPWR VGND sg13g2_or3_1
XFILLER_52_392 VPWR VGND sg13g2_decap_4
X_21708_ _02309_ _02310_ _00455_ VPWR VGND sg13g2_nor2_1
X_13490_ VPWR _04824_ _04823_ VGND sg13g2_inv_1
X_22688_ coeff_force_packed\[54\] net463 _03068_ _00677_ VPWR VGND sg13g2_mux2_1
X_12441_ _03781_ _03784_ _03817_ _03818_ VPWR VGND sg13g2_or3_1
X_21639_ _02220_ _02219_ _02255_ VPWR VGND sg13g2_xor2_1
XFILLER_100_83 VPWR VGND sg13g2_decap_8
XFILLER_60_65 VPWR VGND sg13g2_decap_8
X_15160_ _06432_ _06415_ _06431_ VPWR VGND sg13g2_nand2_1
X_12372_ _03749_ _03750_ _00057_ VPWR VGND sg13g2_nor2_1
XFILLER_5_901 VPWR VGND sg13g2_fill_2
XFILLER_5_912 VPWR VGND sg13g2_fill_2
XFILLER_60_87 VPWR VGND sg13g2_fill_1
X_14111_ _05422_ _05415_ _05421_ VPWR VGND sg13g2_nand2_1
XFILLER_114_0 VPWR VGND sg13g2_decap_4
X_23309_ net1292 VGND VPWR _00371_ u_LMS.w\[3\]\[11\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
X_15091_ _06363_ _06327_ _06365_ VPWR VGND sg13g2_xor2_1
XFILLER_125_125 VPWR VGND sg13g2_fill_2
XFILLER_5_49 VPWR VGND sg13g2_decap_8
X_14042_ net853 net766 u_FIR.sum\[3\]\[4\] _05355_ VPWR VGND sg13g2_a21o_1
XFILLER_122_810 VPWR VGND sg13g2_fill_2
XFILLER_4_488 VPWR VGND sg13g2_fill_1
XFILLER_106_394 VPWR VGND sg13g2_fill_1
X_18850_ _09929_ VPWR _09937_ VGND _09930_ _09936_ sg13g2_o21ai_1
XFILLER_79_256 VPWR VGND sg13g2_decap_8
XFILLER_68_919 VPWR VGND sg13g2_fill_1
X_17801_ _08934_ _08933_ _08925_ VPWR VGND sg13g2_nand2b_1
XFILLER_79_267 VPWR VGND sg13g2_fill_1
XFILLER_67_407 VPWR VGND sg13g2_decap_8
XFILLER_0_650 VPWR VGND sg13g2_decap_8
XFILLER_67_418 VPWR VGND sg13g2_fill_1
X_18781_ VGND VPWR _09866_ _09867_ _09868_ _09863_ sg13g2_a21oi_1
X_15993_ _07234_ _07232_ _07233_ VPWR VGND sg13g2_nand2_1
X_17732_ _08865_ _08859_ _08863_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_941 VPWR VGND sg13g2_decap_8
X_14944_ _06226_ _06225_ _06200_ VPWR VGND sg13g2_nand2b_1
XFILLER_94_259 VPWR VGND sg13g2_fill_2
XFILLER_63_602 VPWR VGND sg13g2_decap_8
X_23006__1198 VPWR VGND net1197 sg13g2_tiehi
X_17663_ VGND VPWR _08796_ _08795_ _08774_ sg13g2_or2_1
XFILLER_48_687 VPWR VGND sg13g2_decap_8
X_23403__1140 VPWR VGND net1139 sg13g2_tiehi
X_14875_ _06155_ _06157_ _06160_ VPWR VGND sg13g2_nor2_1
XFILLER_91_933 VPWR VGND sg13g2_fill_1
XFILLER_78_1037 VPWR VGND sg13g2_fill_2
X_19402_ _10466_ _10464_ _10465_ VPWR VGND sg13g2_nand2_1
XFILLER_35_337 VPWR VGND sg13g2_decap_4
X_16614_ net1022 VPWR _07802_ VGND net515 net761 sg13g2_o21ai_1
XFILLER_90_432 VPWR VGND sg13g2_decap_8
X_13826_ _05145_ _05147_ _05150_ VPWR VGND sg13g2_nor2_1
X_17594_ _08725_ _08726_ _08727_ VPWR VGND sg13g2_and2_1
XFILLER_91_988 VPWR VGND sg13g2_decap_8
X_19333_ _10397_ _10387_ _10394_ VPWR VGND sg13g2_xnor2_1
X_16545_ u_LMS.w\[2\]\[20\] u_LMS.w\[2\]\[19\] u_LMS.w\[2\]\[18\] _07750_ VPWR VGND
+ sg13g2_nor3_1
XFILLER_90_487 VPWR VGND sg13g2_fill_1
X_13757_ VGND VPWR _05044_ _05060_ _05083_ _05069_ sg13g2_a21oi_1
X_19264_ _10333_ _10214_ _10215_ VPWR VGND sg13g2_xnor2_1
X_12708_ VGND VPWR net736 net830 _04073_ u_FIR.sum\[0\]\[6\] sg13g2_a21oi_1
X_16476_ VGND VPWR _07698_ _07699_ _00212_ net938 sg13g2_a21oi_1
X_13688_ _05016_ net839 net751 net825 net752 VPWR VGND sg13g2_a22oi_1
X_18215_ _09325_ _09315_ _09320_ VPWR VGND sg13g2_xnor2_1
X_15427_ _06644_ _06690_ _06691_ VPWR VGND sg13g2_nor2_1
X_19195_ net31 VPWR _10279_ VGND net29 _10278_ sg13g2_o21ai_1
X_12639_ _04006_ _04005_ _03969_ VPWR VGND sg13g2_nand2b_1
XFILLER_129_431 VPWR VGND sg13g2_fill_1
X_18146_ _09254_ _09241_ _09256_ VPWR VGND sg13g2_xor2_1
X_15358_ _06619_ _06624_ _06625_ VPWR VGND sg13g2_nor2b_1
X_14309_ _05614_ net279 _05615_ VPWR VGND sg13g2_xor2_1
XFILLER_7_271 VPWR VGND sg13g2_decap_8
XFILLER_116_125 VPWR VGND sg13g2_fill_1
X_18077_ VPWR _09187_ _09186_ VGND sg13g2_inv_1
X_15289_ _06558_ _06515_ _06556_ VPWR VGND sg13g2_xnor2_1
X_17028_ net212 _08183_ net705 _08184_ VPWR VGND sg13g2_nand3_1
Xfanout707 u_LMS.x_r\[0\]\[4\] net707 VPWR VGND sg13g2_buf_1
XFILLER_124_180 VPWR VGND sg13g2_decap_8
Xfanout718 u_FIR.w\[8\]\[6\] net718 VPWR VGND sg13g2_buf_1
XFILLER_113_854 VPWR VGND sg13g2_fill_1
Xfanout729 net730 net729 VPWR VGND sg13g2_buf_1
X_18979_ _10064_ _10065_ _10066_ VPWR VGND sg13g2_nor2_1
XFILLER_22_1003 VPWR VGND sg13g2_fill_1
X_21990_ _02584_ _02583_ _02575_ VPWR VGND sg13g2_nand2b_1
XFILLER_67_963 VPWR VGND sg13g2_fill_2
XFILLER_67_974 VPWR VGND sg13g2_fill_2
X_20941_ _01581_ _01524_ _01525_ VPWR VGND sg13g2_xnor2_1
XFILLER_38_186 VPWR VGND sg13g2_decap_8
X_20872_ _01512_ _01511_ net197 _01510_ _01477_ VPWR VGND sg13g2_a22oi_1
X_23660_ net986 VGND VPWR _00722_ u_debug_unit.mon_w3_sync\[5\] clknet_leaf_53_clkA
+ sg13g2_dfrbpq_1
XFILLER_42_808 VPWR VGND sg13g2_decap_4
XFILLER_121_38 VPWR VGND sg13g2_fill_1
XFILLER_81_454 VPWR VGND sg13g2_fill_1
XFILLER_82_999 VPWR VGND sg13g2_fill_1
X_22611_ net473 net556 _03060_ _00608_ VPWR VGND sg13g2_mux2_1
XFILLER_81_487 VPWR VGND sg13g2_fill_2
XFILLER_35_882 VPWR VGND sg13g2_fill_1
X_23591_ net963 VGND VPWR _00653_ coeff_force_packed\[33\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
XFILLER_14_14 VPWR VGND sg13g2_fill_1
X_22542_ _03027_ u_LMS.count\[14\] _03025_ VPWR VGND sg13g2_xnor2_1
XFILLER_14_25 VPWR VGND sg13g2_decap_8
X_22473_ net960 VPWR _02986_ VGND net447 net601 sg13g2_o21ai_1
X_21424_ _02041_ net597 net262 VPWR VGND sg13g2_nand2_1
XFILLER_5_208 VPWR VGND sg13g2_fill_1
X_21355_ net132 _01971_ net600 _01972_ VPWR VGND sg13g2_nand3_1
XFILLER_123_607 VPWR VGND sg13g2_decap_8
X_20306_ _00969_ _10985_ _00968_ VPWR VGND sg13g2_xnor2_1
XFILLER_123_629 VPWR VGND sg13g2_fill_2
X_21286_ _03223_ net100 _01903_ VPWR VGND sg13g2_nor2_1
X_23025_ net1168 VGND VPWR _00087_ u_FIR.sum\[2\]\[6\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
XFILLER_116_692 VPWR VGND sg13g2_decap_8
X_20237_ _00886_ _00899_ _00900_ VPWR VGND sg13g2_nor2_1
XFILLER_89_543 VPWR VGND sg13g2_fill_2
XFILLER_118_1031 VPWR VGND sg13g2_decap_8
XFILLER_77_716 VPWR VGND sg13g2_decap_4
X_20168_ _00831_ _11169_ _11180_ VPWR VGND sg13g2_xnor2_1
X_23097__1061 VPWR VGND net1060 sg13g2_tiehi
XFILLER_76_215 VPWR VGND sg13g2_fill_1
X_20099_ _11140_ _11124_ _11125_ VPWR VGND sg13g2_xnor2_1
X_12990_ _04345_ _04321_ _04347_ VPWR VGND sg13g2_xor2_1
X_11941_ VPWR _03362_ net742 VGND sg13g2_inv_1
XFILLER_57_473 VPWR VGND sg13g2_fill_1
XFILLER_73_933 VPWR VGND sg13g2_fill_2
XFILLER_17_348 VPWR VGND sg13g2_fill_1
X_14660_ _05902_ VPWR _05951_ VGND _05899_ _05903_ sg13g2_o21ai_1
XFILLER_44_134 VPWR VGND sg13g2_fill_2
X_11872_ VPWR _03293_ u_LMS.w\[8\]\[7\] VGND sg13g2_inv_1
XFILLER_73_977 VPWR VGND sg13g2_decap_4
XFILLER_26_860 VPWR VGND sg13g2_decap_8
X_13611_ _04940_ _04901_ _04941_ VPWR VGND sg13g2_xor2_1
XFILLER_38_1010 VPWR VGND sg13g2_fill_2
XFILLER_26_871 VPWR VGND sg13g2_fill_2
X_22809_ VGND VPWR _03308_ net351 _00744_ _03122_ sg13g2_a21oi_1
XFILLER_26_882 VPWR VGND sg13g2_decap_8
X_14591_ _05882_ _05853_ _05884_ VPWR VGND sg13g2_xor2_1
XFILLER_60_649 VPWR VGND sg13g2_fill_2
XFILLER_41_830 VPWR VGND sg13g2_fill_2
X_16330_ _07564_ _07552_ _07563_ VPWR VGND sg13g2_xnor2_1
X_13542_ _04873_ _04870_ _04874_ VPWR VGND sg13g2_xor2_1
XFILLER_41_863 VPWR VGND sg13g2_fill_1
XFILLER_40_340 VPWR VGND sg13g2_decap_8
XFILLER_9_514 VPWR VGND sg13g2_fill_2
XFILLER_71_64 VPWR VGND sg13g2_fill_1
X_16261_ _07496_ net272 _07497_ VPWR VGND sg13g2_xor2_1
XFILLER_71_75 VPWR VGND sg13g2_decap_8
X_13473_ VGND VPWR net414 _03379_ _00099_ _04809_ sg13g2_a21oi_1
X_18000_ net40 VPWR _09126_ VGND net38 _09125_ sg13g2_o21ai_1
XFILLER_9_569 VPWR VGND sg13g2_decap_4
X_15212_ _06481_ _06453_ _06483_ VPWR VGND sg13g2_xor2_1
X_12424_ _03801_ _03795_ _03799_ VPWR VGND sg13g2_xnor2_1
X_23378__1215 VPWR VGND net1214 sg13g2_tiehi
X_16192_ _07430_ _07429_ _07388_ VPWR VGND sg13g2_nand2b_1
XFILLER_127_924 VPWR VGND sg13g2_fill_2
XFILLER_126_423 VPWR VGND sg13g2_fill_1
X_15143_ _06389_ VPWR _06415_ VGND _06341_ _06381_ sg13g2_o21ai_1
X_12355_ _03733_ _03688_ _03734_ VPWR VGND sg13g2_xor2_1
XFILLER_99_318 VPWR VGND sg13g2_fill_1
XFILLER_114_618 VPWR VGND sg13g2_decap_8
X_19951_ _10992_ net86 net624 net103 net622 VPWR VGND sg13g2_a22oi_1
X_15074_ _06346_ _06312_ _06348_ VPWR VGND sg13g2_xor2_1
X_12286_ _03667_ _03651_ _03666_ VPWR VGND sg13g2_nand2_1
X_18902_ _09988_ _09983_ _09989_ VPWR VGND sg13g2_xor2_1
X_14025_ _05339_ _05318_ _05338_ VPWR VGND sg13g2_nand2_1
X_19882_ _10925_ _10926_ _00391_ VPWR VGND sg13g2_nor2_1
XFILLER_122_640 VPWR VGND sg13g2_decap_4
XFILLER_122_673 VPWR VGND sg13g2_decap_8
X_23281__1332 VPWR VGND net1331 sg13g2_tiehi
X_18833_ _03256_ net99 _09920_ VPWR VGND sg13g2_nor2_1
XFILLER_96_61 VPWR VGND sg13g2_decap_8
XFILLER_95_513 VPWR VGND sg13g2_decap_8
XFILLER_132_1017 VPWR VGND sg13g2_decap_8
XFILLER_110_846 VPWR VGND sg13g2_fill_1
XFILLER_0_480 VPWR VGND sg13g2_decap_8
X_18764_ _09847_ _09850_ _09851_ VPWR VGND sg13g2_nor2_1
XFILLER_110_879 VPWR VGND sg13g2_decap_8
X_15976_ VGND VPWR net499 _07217_ _00193_ _07218_ sg13g2_a21oi_1
XFILLER_67_259 VPWR VGND sg13g2_fill_1
XFILLER_48_440 VPWR VGND sg13g2_fill_1
XFILLER_95_579 VPWR VGND sg13g2_fill_2
X_17715_ _08846_ net2209 _08848_ VPWR VGND sg13g2_xor2_1
X_14927_ _06186_ VPWR _06210_ VGND net268 _06184_ sg13g2_o21ai_1
X_23288__1319 VPWR VGND net1318 sg13g2_tiehi
X_18695_ net145 VPWR _09782_ VGND net659 net660 sg13g2_o21ai_1
XFILLER_63_410 VPWR VGND sg13g2_decap_8
XFILLER_63_421 VPWR VGND sg13g2_fill_1
XFILLER_75_292 VPWR VGND sg13g2_decap_8
X_17646_ _08737_ _08735_ _08779_ VPWR VGND sg13g2_xor2_1
X_14858_ _06144_ _06120_ _06143_ VPWR VGND sg13g2_xnor2_1
XFILLER_36_668 VPWR VGND sg13g2_fill_1
XFILLER_91_785 VPWR VGND sg13g2_fill_1
XFILLER_17_871 VPWR VGND sg13g2_fill_1
X_13809_ VGND VPWR net754 _05086_ _05134_ _05055_ sg13g2_a21oi_1
X_17577_ _08710_ net696 net81 VPWR VGND sg13g2_nand2_1
X_14789_ _06050_ _06076_ _06077_ VPWR VGND sg13g2_nor2b_1
XFILLER_32_830 VPWR VGND sg13g2_fill_2
X_19316_ _10377_ _10379_ _10380_ VPWR VGND sg13g2_nor2_1
X_16528_ VGND VPWR net482 _07737_ _00225_ _07738_ sg13g2_a21oi_1
XFILLER_31_340 VPWR VGND sg13g2_fill_2
X_19247_ net55 _10320_ _10203_ _10321_ VPWR VGND sg13g2_nand3_1
X_16459_ _07687_ _07684_ _07686_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_0 VPWR VGND sg13g2_decap_8
X_19178_ net717 net67 _10258_ _10265_ VPWR VGND sg13g2_nor3_2
XFILLER_118_924 VPWR VGND sg13g2_fill_2
XFILLER_118_935 VPWR VGND sg13g2_decap_4
XFILLER_117_401 VPWR VGND sg13g2_decap_4
X_18129_ _09237_ _09220_ _09239_ VPWR VGND sg13g2_xor2_1
XFILLER_118_979 VPWR VGND sg13g2_fill_1
X_21140_ net93 _01756_ _01757_ VPWR VGND sg13g2_nor2_1
XFILLER_6_70 VPWR VGND sg13g2_decap_8
X_23188__1502 VPWR VGND net1501 sg13g2_tiehi
X_23216__1453 VPWR VGND net1452 sg13g2_tiehi
XFILLER_132_426 VPWR VGND sg13g2_fill_2
X_21071_ net17 VPWR _01701_ VGND net15 _01700_ sg13g2_o21ai_1
Xfanout504 net514 net504 VPWR VGND sg13g2_buf_1
XFILLER_116_38 VPWR VGND sg13g2_decap_8
Xfanout515 net516 net515 VPWR VGND sg13g2_buf_1
XFILLER_116_49 VPWR VGND sg13g2_fill_2
X_20022_ _11063_ _11062_ _11060_ VPWR VGND sg13g2_nand2b_1
Xfanout526 net549 net526 VPWR VGND sg13g2_buf_1
Xfanout537 net539 net537 VPWR VGND sg13g2_buf_1
XFILLER_99_896 VPWR VGND sg13g2_decap_8
XFILLER_100_301 VPWR VGND sg13g2_fill_2
Xfanout548 net549 net548 VPWR VGND sg13g2_buf_1
Xfanout559 net560 net559 VPWR VGND sg13g2_buf_1
XFILLER_100_323 VPWR VGND sg13g2_fill_2
XFILLER_86_546 VPWR VGND sg13g2_decap_8
XFILLER_100_334 VPWR VGND sg13g2_fill_1
X_23059__1118 VPWR VGND net1117 sg13g2_tiehi
XFILLER_55_922 VPWR VGND sg13g2_decap_8
X_21973_ _02567_ _02566_ _02565_ VPWR VGND sg13g2_nand2b_1
XFILLER_54_410 VPWR VGND sg13g2_fill_2
XFILLER_92_19 VPWR VGND sg13g2_fill_1
XFILLER_82_741 VPWR VGND sg13g2_decap_4
X_23712_ net1438 VGND VPWR _00774_ u_FIR.x\[1\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
X_20924_ _01269_ _01543_ _01564_ VPWR VGND sg13g2_nor2_1
XFILLER_82_785 VPWR VGND sg13g2_fill_1
XFILLER_25_35 VPWR VGND sg13g2_fill_2
X_20855_ _01493_ _01494_ _01495_ VPWR VGND sg13g2_nor2_1
X_23643_ net976 VGND VPWR _00705_ u_debug_unit.mon_w1_sync\[2\] clknet_leaf_52_clkA
+ sg13g2_dfrbpq_1
XFILLER_26_189 VPWR VGND sg13g2_fill_1
XFILLER_81_295 VPWR VGND sg13g2_decap_4
X_20786_ _01422_ _01421_ _01426_ VPWR VGND sg13g2_xor2_1
X_23574_ net986 VGND VPWR _00636_ coeff_force_packed\[18\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
X_22525_ VGND VPWR u_LMS.count\[7\] _03014_ _03016_ u_LMS.count\[8\] sg13g2_a21oi_1
XFILLER_10_546 VPWR VGND sg13g2_decap_4
X_22456_ VGND VPWR net450 _03241_ _00536_ _02977_ sg13g2_a21oi_1
XFILLER_109_946 VPWR VGND sg13g2_decap_8
XFILLER_109_957 VPWR VGND sg13g2_fill_1
X_21407_ _02018_ VPWR _02024_ VGND _01929_ _02014_ sg13g2_o21ai_1
X_22387_ net962 VPWR _02943_ VGND net453 u_LMS.x_r\[1\]\[7\] sg13g2_o21ai_1
XFILLER_108_478 VPWR VGND sg13g2_fill_1
X_12140_ _03550_ _03439_ coeff_force_packed\[29\] _03400_ u_debug_unit.mon_w3_sync\[1\]
+ VPWR VGND sg13g2_a22oi_1
X_21338_ _01955_ net603 net170 VPWR VGND sg13g2_nand2_1
XFILLER_1_211 VPWR VGND sg13g2_fill_1
X_12071_ _03484_ u_spi_slave.tx_shift\[12\] _03392_ VPWR VGND sg13g2_nand2_1
X_21269_ _01883_ net116 _01886_ VPWR VGND sg13g2_xor2_1
XFILLER_89_340 VPWR VGND sg13g2_decap_8
X_23008_ net1194 VGND VPWR _00070_ u_FIR.sum\[1\]\[5\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
XFILLER_132_982 VPWR VGND sg13g2_decap_8
XFILLER_2_28 VPWR VGND sg13g2_decap_8
XFILLER_1_288 VPWR VGND sg13g2_decap_8
X_15830_ _07079_ _07054_ _07078_ VPWR VGND sg13g2_xnor2_1
XFILLER_65_708 VPWR VGND sg13g2_fill_2
XFILLER_46_911 VPWR VGND sg13g2_fill_2
XFILLER_64_218 VPWR VGND sg13g2_decap_8
X_15761_ VGND VPWR _06970_ _06973_ _07012_ _07010_ sg13g2_a21oi_1
XFILLER_58_782 VPWR VGND sg13g2_decap_8
X_12973_ _04315_ _04330_ _04331_ VPWR VGND sg13g2_nor2b_1
XFILLER_58_793 VPWR VGND sg13g2_fill_2
X_17500_ _08630_ net121 _08633_ VPWR VGND sg13g2_xor2_1
XFILLER_18_646 VPWR VGND sg13g2_fill_2
X_14712_ _06002_ _05967_ _06000_ VPWR VGND sg13g2_xnor2_1
XFILLER_57_292 VPWR VGND sg13g2_decap_4
X_23527__1312 VPWR VGND net1311 sg13g2_tiehi
X_18480_ u_LMS.w\[2\]\[16\] net2105 _09590_ VPWR VGND sg13g2_and2_1
X_11924_ VPWR _03345_ u_LMS.w\[1\]\[6\] VGND sg13g2_inv_1
XFILLER_73_752 VPWR VGND sg13g2_decap_4
X_15692_ net860 net784 _06942_ _06944_ VPWR VGND sg13g2_a21o_1
XFILLER_75_1007 VPWR VGND sg13g2_decap_8
XFILLER_72_251 VPWR VGND sg13g2_decap_8
XFILLER_46_999 VPWR VGND sg13g2_fill_2
X_17431_ VGND VPWR net59 _08568_ _08569_ _08550_ sg13g2_a21oi_1
XFILLER_33_627 VPWR VGND sg13g2_decap_8
X_23499__1416 VPWR VGND net1415 sg13g2_tiehi
X_14643_ _03367_ net891 _05934_ VPWR VGND sg13g2_nor2_1
X_11855_ VPWR _03276_ net704 VGND sg13g2_inv_1
XFILLER_61_969 VPWR VGND sg13g2_fill_2
X_17362_ _08469_ _08513_ _08514_ VPWR VGND sg13g2_and2_1
X_14574_ _05867_ _05859_ _05866_ VPWR VGND sg13g2_nand2_1
XFILLER_60_468 VPWR VGND sg13g2_fill_2
X_11786_ VPWR _03207_ u_s2p_input.reg_sh\[3\] VGND sg13g2_inv_1
X_19101_ _03329_ _10187_ _10188_ VPWR VGND sg13g2_nor2_1
X_16313_ net979 VPWR _07548_ VGND net486 u_FIR.sum\[8\]\[11\] sg13g2_o21ai_1
XFILLER_13_362 VPWR VGND sg13g2_decap_4
X_13525_ net1026 VPWR _04858_ VGND net516 u_FIR.sum\[3\]\[3\] sg13g2_o21ai_1
X_17293_ _08449_ _08448_ _08422_ VPWR VGND sg13g2_nand2b_1
X_23299__1303 VPWR VGND net1302 sg13g2_tiehi
X_19032_ _10112_ _10118_ _10119_ VPWR VGND sg13g2_nor2_1
X_16244_ VGND VPWR _07443_ _07473_ _07480_ _07472_ sg13g2_a21oi_1
X_13456_ _04795_ _04784_ _04796_ VPWR VGND sg13g2_xor2_1
XFILLER_51_1051 VPWR VGND sg13g2_decap_4
X_12407_ net543 VPWR _03785_ VGND _03783_ _03784_ sg13g2_o21ai_1
XFILLER_127_743 VPWR VGND sg13g2_fill_1
X_16175_ _07413_ _07407_ _07411_ VPWR VGND sg13g2_xnor2_1
X_13387_ _04710_ _04729_ _04730_ VPWR VGND sg13g2_nor2b_1
X_15126_ _06399_ _06356_ _06397_ VPWR VGND sg13g2_xnor2_1
X_12338_ _03717_ net728 net811 VPWR VGND sg13g2_nand2_1
XFILLER_127_798 VPWR VGND sg13g2_decap_8
XFILLER_5_594 VPWR VGND sg13g2_fill_2
X_19934_ _10975_ net637 net154 VPWR VGND sg13g2_nand2_1
X_15057_ _06332_ _06304_ _06331_ VPWR VGND sg13g2_nand2_1
X_12269_ VPWR _03650_ _03649_ VGND sg13g2_inv_1
X_14008_ net865 net765 u_FIR.sum\[3\]\[3\] _05322_ VPWR VGND sg13g2_a21o_1
X_19865_ net358 VPWR _10914_ VGND u_LMS.w\[4\]\[4\] net373 sg13g2_o21ai_1
XFILLER_68_535 VPWR VGND sg13g2_fill_1
XFILLER_68_546 VPWR VGND sg13g2_decap_8
X_18816_ _09900_ net119 _09903_ VPWR VGND sg13g2_xor2_1
XFILLER_110_665 VPWR VGND sg13g2_decap_8
X_19796_ net26 VPWR _10859_ VGND net25 _10858_ sg13g2_o21ai_1
X_18747_ _09834_ _09833_ _09811_ VPWR VGND sg13g2_nand2b_1
X_15959_ _07195_ _07199_ _07202_ VPWR VGND sg13g2_nor2_1
X_18678_ _09765_ net653 net159 VPWR VGND sg13g2_nand2_1
X_23055__1124 VPWR VGND net1123 sg13g2_tiehi
XFILLER_52_925 VPWR VGND sg13g2_decap_4
XFILLER_64_796 VPWR VGND sg13g2_fill_1
XFILLER_36_487 VPWR VGND sg13g2_decap_8
X_17629_ _08760_ VPWR _08762_ VGND _08756_ _08761_ sg13g2_o21ai_1
X_20640_ _01280_ _01277_ _01278_ VPWR VGND sg13g2_xnor2_1
XFILLER_60_991 VPWR VGND sg13g2_fill_1
XFILLER_32_682 VPWR VGND sg13g2_decap_4
X_20571_ _01211_ _01176_ _01210_ VPWR VGND sg13g2_xnor2_1
XFILLER_20_855 VPWR VGND sg13g2_decap_8
X_22310_ VGND VPWR u_LMS.w\[8\]\[23\] net307 _02893_ _02871_ sg13g2_a21oi_1
X_23290_ net1315 VGND VPWR _00352_ u_LMS.w\[3\]\[15\] clknet_leaf_53_clkA sg13g2_dfrbpq_1
XFILLER_118_710 VPWR VGND sg13g2_fill_2
X_22241_ _02835_ _02833_ _02834_ VPWR VGND sg13g2_nand2_1
XFILLER_117_231 VPWR VGND sg13g2_decap_4
X_22172_ _02766_ u_LMS.w\[8\]\[13\] _02765_ VPWR VGND sg13g2_nand2_1
XFILLER_117_275 VPWR VGND sg13g2_fill_1
XFILLER_117_297 VPWR VGND sg13g2_fill_2
X_21123_ _01739_ _01740_ _00440_ VPWR VGND sg13g2_nor2_1
XFILLER_132_234 VPWR VGND sg13g2_decap_8
Xfanout301 net302 net301 VPWR VGND sg13g2_buf_1
Xfanout312 net320 net312 VPWR VGND sg13g2_buf_1
X_21054_ VGND VPWR u_LMS.w\[6\]\[18\] net74 _01687_ _01639_ sg13g2_a21oi_1
Xfanout323 _03574_ net323 VPWR VGND sg13g2_buf_1
XFILLER_120_429 VPWR VGND sg13g2_decap_4
Xfanout334 net335 net334 VPWR VGND sg13g2_buf_1
XFILLER_86_310 VPWR VGND sg13g2_fill_1
Xfanout345 net353 net345 VPWR VGND sg13g2_buf_1
X_20005_ VGND VPWR _11046_ _11039_ _11037_ sg13g2_or2_1
Xfanout356 net367 net356 VPWR VGND sg13g2_buf_1
XFILLER_101_643 VPWR VGND sg13g2_decap_8
Xfanout367 _08553_ net367 VPWR VGND sg13g2_buf_1
XFILLER_100_131 VPWR VGND sg13g2_decap_4
Xfanout378 net379 net378 VPWR VGND sg13g2_buf_1
XFILLER_86_354 VPWR VGND sg13g2_fill_1
Xfanout389 _07387_ net389 VPWR VGND sg13g2_buf_1
XFILLER_100_164 VPWR VGND sg13g2_decap_8
X_23715__1418 VPWR VGND net1417 sg13g2_tiehi
XFILLER_86_387 VPWR VGND sg13g2_decap_8
XFILLER_28_922 VPWR VGND sg13g2_decap_8
XFILLER_55_752 VPWR VGND sg13g2_fill_2
X_21956_ _02550_ _02534_ _02548_ VPWR VGND sg13g2_xnor2_1
XFILLER_27_476 VPWR VGND sg13g2_decap_8
XFILLER_14_104 VPWR VGND sg13g2_decap_4
X_20907_ _01200_ _01219_ _01229_ _01547_ VPWR VGND sg13g2_or3_1
XFILLER_82_582 VPWR VGND sg13g2_fill_2
X_21887_ _02478_ _02376_ _02481_ VPWR VGND sg13g2_xor2_1
XFILLER_42_435 VPWR VGND sg13g2_fill_1
X_23626_ net972 VGND VPWR _00688_ u_debug_unit.error_signal_sync\[0\] clknet_leaf_47_clkA
+ sg13g2_dfrbpq_1
X_20838_ _01432_ _01476_ _01478_ VPWR VGND sg13g2_nor2_1
XFILLER_52_33 VPWR VGND sg13g2_decap_8
XFILLER_11_811 VPWR VGND sg13g2_decap_8
XFILLER_11_822 VPWR VGND sg13g2_fill_2
X_23557_ net1015 VGND VPWR _00619_ coeff_force_packed\[3\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
X_20769_ _01409_ net261 net609 net245 net611 VPWR VGND sg13g2_a22oi_1
XFILLER_22_181 VPWR VGND sg13g2_fill_1
X_13310_ _04655_ _04644_ _04654_ VPWR VGND sg13g2_xnor2_1
X_22508_ VGND VPWR u_LMS.count\[1\] _03002_ _03005_ u_LMS.count\[2\] sg13g2_a21oi_1
XFILLER_52_99 VPWR VGND sg13g2_fill_1
XFILLER_128_529 VPWR VGND sg13g2_decap_8
X_14290_ _05563_ _05596_ _05597_ VPWR VGND sg13g2_nor2b_1
XFILLER_109_721 VPWR VGND sg13g2_decap_8
X_23488_ net1455 VGND VPWR _00550_ u_LMS.x_r\[7\]\[7\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
X_13241_ _04587_ _04556_ _04588_ VPWR VGND sg13g2_xor2_1
XFILLER_109_754 VPWR VGND sg13g2_decap_4
XFILLER_10_398 VPWR VGND sg13g2_fill_1
X_22439_ net968 VPWR _02969_ VGND net444 net635 sg13g2_o21ai_1
XFILLER_6_369 VPWR VGND sg13g2_fill_1
XFILLER_109_798 VPWR VGND sg13g2_fill_2
X_13172_ _04520_ _04482_ _04484_ VPWR VGND sg13g2_nand2_1
XFILLER_108_297 VPWR VGND sg13g2_decap_4
X_12123_ VPWR VGND coeff_force_packed\[58\] _03533_ net288 u_debug_unit.mon_w5_sync\[2\]
+ _03534_ _03405_ sg13g2_a221oi_1
XFILLER_7_0 VPWR VGND sg13g2_decap_8
X_17980_ _09110_ net303 u_LMS.w\[1\]\[15\] coeff_force_packed\[10\] net557 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_105_982 VPWR VGND sg13g2_decap_8
X_16931_ _08085_ _08086_ _08087_ VPWR VGND sg13g2_nor2_1
X_12054_ coeff_force_packed\[61\] net288 _03468_ VPWR VGND sg13g2_and2_1
XFILLER_104_470 VPWR VGND sg13g2_decap_8
XFILLER_2_597 VPWR VGND sg13g2_fill_2
X_19650_ _10714_ _10688_ _10689_ VPWR VGND sg13g2_xnor2_1
X_16862_ _08018_ net715 net155 VPWR VGND sg13g2_nand2_1
XFILLER_38_708 VPWR VGND sg13g2_decap_4
Xfanout890 net891 net890 VPWR VGND sg13g2_buf_1
X_18601_ VGND VPWR net2091 net2092 _09704_ _09659_ sg13g2_a21oi_1
X_15813_ _07062_ _07059_ _07060_ VPWR VGND sg13g2_nand2_1
XFILLER_120_996 VPWR VGND sg13g2_fill_1
X_19581_ _10643_ _10644_ _10645_ VPWR VGND sg13g2_nor2_1
X_16793_ _07949_ _07946_ _07947_ VPWR VGND sg13g2_xnor2_1
XFILLER_46_730 VPWR VGND sg13g2_fill_1
XFILLER_19_944 VPWR VGND sg13g2_fill_1
XFILLER_19_955 VPWR VGND sg13g2_decap_8
X_18532_ _09600_ u_LMS.w\[2\]\[11\] _09642_ VPWR VGND sg13g2_xor2_1
X_15744_ _06995_ _06988_ _06993_ VPWR VGND sg13g2_xnor2_1
X_12956_ _04301_ VPWR _04314_ VGND net284 _04299_ sg13g2_o21ai_1
XFILLER_93_62 VPWR VGND sg13g2_fill_2
XFILLER_80_519 VPWR VGND sg13g2_decap_8
XFILLER_46_774 VPWR VGND sg13g2_decap_4
XFILLER_46_785 VPWR VGND sg13g2_decap_8
X_18463_ _09573_ u_LMS.x_r\[2\]\[7\] net158 VPWR VGND sg13g2_nand2_1
X_11907_ VPWR _03328_ u_LMS.w\[4\]\[12\] VGND sg13g2_inv_1
X_15675_ _06927_ _06899_ _06928_ VPWR VGND sg13g2_xor2_1
X_12887_ net1040 VPWR _04248_ VGND net545 u_FIR.sum\[1\]\[10\] sg13g2_o21ai_1
X_17414_ _08556_ _08432_ _08434_ VPWR VGND sg13g2_xnor2_1
X_14626_ _05891_ _05917_ _05918_ VPWR VGND sg13g2_nor2_1
X_18394_ VPWR _09504_ _09503_ VGND sg13g2_inv_1
X_11838_ VPWR _03259_ net669 VGND sg13g2_inv_1
X_23051__1130 VPWR VGND net1129 sg13g2_tiehi
X_17345_ _08501_ net368 net561 VPWR VGND sg13g2_nand2b_1
X_14557_ _05851_ _05822_ _05849_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_130 VPWR VGND sg13g2_decap_8
X_13508_ _04823_ _04840_ _04841_ VPWR VGND sg13g2_nor2_1
X_17276_ u_LMS.w\[0\]\[2\] net265 net714 _08432_ VPWR VGND sg13g2_nand3_1
X_14488_ _05785_ net772 net902 VPWR VGND sg13g2_nand2_1
X_19015_ _10088_ _10101_ _10102_ VPWR VGND sg13g2_nor2_1
XFILLER_9_185 VPWR VGND sg13g2_decap_8
X_16227_ VPWR _07464_ _07463_ VGND sg13g2_inv_1
X_13439_ VGND VPWR _04759_ _04762_ _04780_ _04778_ sg13g2_a21oi_1
X_16158_ _07363_ _07396_ _07397_ VPWR VGND sg13g2_nor2_1
X_15109_ _06382_ _06340_ _06381_ VPWR VGND sg13g2_xnor2_1
XFILLER_114_234 VPWR VGND sg13g2_fill_1
X_16089_ _07329_ net795 net873 VPWR VGND sg13g2_nand2_1
X_19917_ VGND VPWR _10949_ _10957_ _10958_ _10947_ sg13g2_a21oi_1
XFILLER_96_641 VPWR VGND sg13g2_fill_2
X_19848_ VGND VPWR u_LMS.w\[4\]\[23\] net310 _10901_ _10879_ sg13g2_a21oi_1
XFILLER_56_505 VPWR VGND sg13g2_fill_1
XFILLER_84_825 VPWR VGND sg13g2_fill_2
XFILLER_3_1000 VPWR VGND sg13g2_decap_8
XFILLER_95_184 VPWR VGND sg13g2_decap_8
X_19779_ _10843_ u_LMS.w\[4\]\[22\] net65 VPWR VGND sg13g2_nand2_1
XFILLER_113_39 VPWR VGND sg13g2_decap_8
X_21810_ _02399_ VPWR _02404_ VGND _02387_ _02397_ sg13g2_o21ai_1
XFILLER_83_368 VPWR VGND sg13g2_decap_4
X_22790_ u_debug_unit.mon_w5_sync\[4\] net348 _03113_ VPWR VGND sg13g2_nor2_1
XFILLER_58_1013 VPWR VGND sg13g2_decap_4
XFILLER_37_785 VPWR VGND sg13g2_decap_8
X_21741_ net570 net572 net178 net169 _02335_ VPWR VGND sg13g2_and4_1
X_23711__1446 VPWR VGND net1445 sg13g2_tiehi
XFILLER_51_232 VPWR VGND sg13g2_decap_8
X_23391__1176 VPWR VGND net1175 sg13g2_tiehi
XFILLER_52_777 VPWR VGND sg13g2_decap_4
X_21672_ net962 VPWR _02282_ VGND u_LMS.w\[7\]\[19\] _08501_ sg13g2_o21ai_1
XFILLER_51_265 VPWR VGND sg13g2_decap_4
X_23411_ net1115 VGND VPWR _00473_ u_LMS.w\[8\]\[21\] clknet_leaf_55_clkA sg13g2_dfrbpq_1
X_20623_ _01263_ _01260_ _01261_ VPWR VGND sg13g2_xnor2_1
X_23408__1125 VPWR VGND net1124 sg13g2_tiehi
X_20554_ VPWR _01194_ _01193_ VGND sg13g2_inv_1
X_23342_ net1259 VGND VPWR _00404_ u_LMS.w\[5\]\[21\] clknet_leaf_23_clkA sg13g2_dfrbpq_1
Xclkbuf_leaf_22_clkA clknet_4_14_0_clkA clknet_leaf_22_clkA VPWR VGND sg13g2_buf_8
X_20485_ _01130_ _01131_ _00411_ VPWR VGND sg13g2_nor2_1
X_23273_ net1347 VGND VPWR _00335_ u_LMS.w\[2\]\[21\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
XFILLER_118_7 VPWR VGND sg13g2_decap_8
X_23465__1536 VPWR VGND net1535 sg13g2_tiehi
X_22224_ _02818_ _02817_ _02763_ VPWR VGND sg13g2_nand2b_1
XFILLER_3_339 VPWR VGND sg13g2_decap_4
X_22155_ _02749_ _02742_ _02748_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_7 VPWR VGND sg13g2_decap_8
X_21106_ net361 VPWR _01728_ VGND u_LMS.w\[6\]\[7\] net378 sg13g2_o21ai_1
X_22086_ _02680_ net584 net240 VPWR VGND sg13g2_nand2_1
XFILLER_121_749 VPWR VGND sg13g2_fill_2
Xfanout120 _09215_ net120 VPWR VGND sg13g2_buf_1
Xfanout131 net133 net131 VPWR VGND sg13g2_buf_1
XFILLER_59_321 VPWR VGND sg13g2_fill_2
Xfanout142 net143 net142 VPWR VGND sg13g2_buf_1
X_21037_ _01674_ net317 u_LMS.w\[6\]\[15\] coeff_force_packed\[45\] net565 VPWR VGND
+ sg13g2_a22oi_1
Xfanout153 net157 net153 VPWR VGND sg13g2_buf_1
XFILLER_101_451 VPWR VGND sg13g2_fill_1
Xfanout164 net165 net164 VPWR VGND sg13g2_buf_2
XFILLER_47_22 VPWR VGND sg13g2_decap_8
Xfanout175 _07941_ net175 VPWR VGND sg13g2_buf_8
Xfanout186 net187 net186 VPWR VGND sg13g2_buf_2
Xfanout197 net199 net197 VPWR VGND sg13g2_buf_1
XFILLER_101_484 VPWR VGND sg13g2_decap_8
X_12810_ _04142_ _04135_ _04149_ _04172_ VPWR VGND sg13g2_a21o_1
XFILLER_47_88 VPWR VGND sg13g2_fill_2
X_13790_ net1035 VPWR _05116_ VGND net537 u_FIR.sum\[3\]\[10\] sg13g2_o21ai_1
X_22988_ net1224 VGND VPWR _00050_ u_FIR.sum\[0\]\[0\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
XFILLER_27_262 VPWR VGND sg13g2_fill_2
XFILLER_16_925 VPWR VGND sg13g2_decap_4
X_12741_ VGND VPWR _04105_ _04103_ _04064_ sg13g2_or2_1
XFILLER_16_947 VPWR VGND sg13g2_decap_4
X_21939_ _02533_ _02532_ _02531_ VPWR VGND sg13g2_nand2b_1
XFILLER_42_210 VPWR VGND sg13g2_decap_8
XFILLER_31_906 VPWR VGND sg13g2_decap_8
X_15460_ VGND VPWR net276 _06707_ _06722_ _06709_ sg13g2_a21oi_1
XFILLER_70_552 VPWR VGND sg13g2_fill_1
XFILLER_43_777 VPWR VGND sg13g2_fill_2
X_12672_ _04038_ _04036_ _04037_ VPWR VGND sg13g2_nand2_1
XFILLER_43_788 VPWR VGND sg13g2_fill_2
XFILLER_42_265 VPWR VGND sg13g2_decap_8
X_14411_ _05708_ _05710_ _05713_ VPWR VGND sg13g2_nor2_1
X_23609_ net965 VGND VPWR _00671_ u_debug_unit.force_w6\[7\] clknet_leaf_17_clkA sg13g2_dfrbpq_1
X_15391_ _06657_ _06638_ _06655_ VPWR VGND sg13g2_xnor2_1
X_17130_ net212 _08285_ net710 _08286_ VPWR VGND sg13g2_nand3_1
XFILLER_8_49 VPWR VGND sg13g2_decap_8
X_14342_ VPWR _05647_ _05646_ VGND sg13g2_inv_1
XFILLER_128_326 VPWR VGND sg13g2_decap_4
XFILLER_128_348 VPWR VGND sg13g2_decap_4
X_17061_ _08213_ _08216_ _08217_ VPWR VGND sg13g2_nor2_1
X_14273_ _05580_ _05571_ _05578_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_144 VPWR VGND sg13g2_fill_1
Xclkbuf_4_1_0_clkA clknet_0_clkA clknet_4_1_0_clkA VPWR VGND sg13g2_buf_8
X_16012_ _07252_ _07249_ _07253_ VPWR VGND sg13g2_xor2_1
XFILLER_6_155 VPWR VGND sg13g2_fill_1
X_13224_ _04568_ _04569_ _04570_ _04571_ VPWR VGND sg13g2_nor3_1
XFILLER_128_91 VPWR VGND sg13g2_decap_8
X_13155_ _04504_ _04495_ _04503_ VPWR VGND sg13g2_nand2_1
XFILLER_97_405 VPWR VGND sg13g2_fill_1
XFILLER_3_862 VPWR VGND sg13g2_fill_1
XFILLER_111_204 VPWR VGND sg13g2_fill_2
X_12106_ _03511_ _03517_ _03518_ VPWR VGND sg13g2_nor2_1
XFILLER_3_895 VPWR VGND sg13g2_fill_2
XFILLER_33_7 VPWR VGND sg13g2_decap_4
X_17963_ u_LMS.w\[1\]\[24\] _09067_ _09087_ _09096_ VPWR VGND sg13g2_nor3_1
X_13086_ _04437_ _04408_ _04435_ VPWR VGND sg13g2_xnor2_1
X_19702_ _10766_ _10705_ _10710_ VPWR VGND sg13g2_xnor2_1
X_16914_ net418 _03276_ net180 net232 _08070_ VPWR VGND sg13g2_nor4_1
X_12037_ _03453_ _00019_ _03452_ _03392_ u_spi_slave.tx_shift\[15\] VPWR VGND sg13g2_a22oi_1
XFILLER_66_803 VPWR VGND sg13g2_decap_4
X_17894_ VGND VPWR _09024_ _09025_ _09027_ _09000_ sg13g2_a21oi_1
XFILLER_65_313 VPWR VGND sg13g2_decap_8
X_19633_ net204 _10696_ net649 _10697_ VPWR VGND sg13g2_nand3_1
X_16845_ net155 VPWR _08001_ VGND net706 net708 sg13g2_o21ai_1
XFILLER_19_730 VPWR VGND sg13g2_decap_8
X_19564_ _10628_ net648 net222 VPWR VGND sg13g2_nand2_1
X_16776_ _07905_ _07930_ net2069 _07932_ VPWR VGND sg13g2_nand3_1
X_13988_ net997 VPWR _05304_ VGND net492 u_FIR.sum\[4\]\[1\] sg13g2_o21ai_1
XFILLER_93_688 VPWR VGND sg13g2_fill_1
XFILLER_81_828 VPWR VGND sg13g2_fill_2
XFILLER_74_880 VPWR VGND sg13g2_decap_8
X_18515_ _09611_ _09624_ _09625_ VPWR VGND sg13g2_nor2_1
X_15727_ VGND VPWR _06958_ _06965_ _06978_ _06957_ sg13g2_a21oi_1
XFILLER_74_891 VPWR VGND sg13g2_fill_1
X_12939_ _04298_ u_FIR.sum\[0\]\[12\] net408 VPWR VGND sg13g2_nand2_1
XFILLER_92_198 VPWR VGND sg13g2_fill_2
XFILLER_80_338 VPWR VGND sg13g2_fill_2
XFILLER_34_733 VPWR VGND sg13g2_fill_1
XFILLER_33_210 VPWR VGND sg13g2_decap_8
X_19495_ _10551_ _10550_ _10553_ _10559_ VPWR VGND sg13g2_a21o_1
XFILLER_34_755 VPWR VGND sg13g2_decap_8
XFILLER_22_906 VPWR VGND sg13g2_fill_1
X_18446_ _09554_ _09555_ _09556_ VPWR VGND sg13g2_and2_1
X_15658_ _06910_ _06869_ _06911_ VPWR VGND sg13g2_xor2_1
X_14609_ _05901_ net771 net849 VPWR VGND sg13g2_nand2_1
Xclkbuf_leaf_45_clkA clknet_4_5_0_clkA clknet_leaf_45_clkA VPWR VGND sg13g2_buf_8
X_18377_ _09486_ _09484_ _09487_ VPWR VGND sg13g2_xor2_1
X_15589_ _06843_ _06840_ _06844_ VPWR VGND sg13g2_xor2_1
X_17328_ net71 u_LMS.w\[0\]\[22\] _08484_ VPWR VGND sg13g2_xor2_1
XFILLER_105_1055 VPWR VGND sg13g2_decap_4
X_17259_ _08352_ _08353_ _08415_ VPWR VGND sg13g2_xor2_1
XFILLER_88_1028 VPWR VGND sg13g2_fill_2
X_20270_ _00933_ _00883_ _00884_ VPWR VGND sg13g2_xnor2_1
XFILLER_88_427 VPWR VGND sg13g2_fill_1
XFILLER_130_513 VPWR VGND sg13g2_decap_8
X_23755__1331 VPWR VGND net1330 sg13g2_tiehi
XFILLER_69_630 VPWR VGND sg13g2_fill_1
XFILLER_102_259 VPWR VGND sg13g2_fill_1
XFILLER_97_972 VPWR VGND sg13g2_decap_8
XFILLER_69_663 VPWR VGND sg13g2_fill_1
XFILLER_25_1034 VPWR VGND sg13g2_fill_2
X_22911_ net1028 VPWR _03184_ VGND net554 u_s2p_input.reg_sh\[4\] sg13g2_o21ai_1
XFILLER_68_173 VPWR VGND sg13g2_decap_8
XFILLER_112_1059 VPWR VGND sg13g2_fill_2
X_22842_ _03140_ _03139_ _03141_ VPWR VGND sg13g2_nor2b_1
XFILLER_56_368 VPWR VGND sg13g2_decap_8
X_22773_ VGND VPWR _07799_ net340 _00726_ _03104_ sg13g2_a21oi_1
XFILLER_25_744 VPWR VGND sg13g2_decap_4
X_21724_ _02321_ _02322_ _00459_ VPWR VGND sg13g2_nor2_1
XFILLER_80_883 VPWR VGND sg13g2_decap_8
XFILLER_40_747 VPWR VGND sg13g2_fill_1
X_21655_ _02268_ net312 u_LMS.w\[7\]\[16\] coeff_force_packed\[53\] net563 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_40_769 VPWR VGND sg13g2_decap_8
X_20606_ _01246_ _01244_ _01245_ VPWR VGND sg13g2_xnor2_1
X_21586_ _02202_ _02201_ _02203_ VPWR VGND sg13g2_nor2b_1
XFILLER_21_994 VPWR VGND sg13g2_decap_8
X_23325_ net1276 VGND VPWR _00387_ u_LMS.w\[4\]\[4\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
X_20537_ _01159_ VPWR _01177_ VGND _01156_ _01157_ sg13g2_o21ai_1
XFILLER_4_604 VPWR VGND sg13g2_fill_2
XFILLER_119_893 VPWR VGND sg13g2_decap_8
XFILLER_106_510 VPWR VGND sg13g2_decap_4
X_20468_ VGND VPWR _01117_ _01118_ _00407_ net937 sg13g2_a21oi_1
X_23256_ net1381 VGND VPWR _00318_ u_LMS.w\[1\]\[4\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
XFILLER_106_532 VPWR VGND sg13g2_decap_4
X_22207_ _02801_ u_LMS.w\[8\]\[8\] _02775_ VPWR VGND sg13g2_xnor2_1
X_20399_ _01057_ _01061_ _01062_ VPWR VGND sg13g2_and2_1
X_23187_ net1503 VGND VPWR _00249_ u_FIR.w\[4\]\[4\] clknet_leaf_36_clkA sg13g2_dfrbpq_1
XFILLER_3_169 VPWR VGND sg13g2_decap_4
XFILLER_0_821 VPWR VGND sg13g2_decap_4
X_22138_ _02488_ VPWR _02732_ VGND _02487_ _02520_ sg13g2_o21ai_1
XFILLER_95_909 VPWR VGND sg13g2_fill_2
XFILLER_0_865 VPWR VGND sg13g2_decap_8
X_14960_ _06241_ net268 _06240_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_876 VPWR VGND sg13g2_fill_1
X_22069_ _02661_ _02659_ _02663_ VPWR VGND sg13g2_xor2_1
XFILLER_58_76 VPWR VGND sg13g2_fill_2
XFILLER_87_471 VPWR VGND sg13g2_decap_4
X_13911_ _05232_ u_FIR.sum\[2\]\[15\] net402 VPWR VGND sg13g2_nand2_1
XFILLER_59_173 VPWR VGND sg13g2_decap_4
X_14891_ _06150_ _06175_ _06176_ VPWR VGND sg13g2_nor2b_1
XFILLER_74_132 VPWR VGND sg13g2_fill_2
X_16630_ VGND VPWR u_LMS.w\[5\]\[12\] _07812_ _07814_ _07813_ sg13g2_a21oi_1
XFILLER_114_71 VPWR VGND sg13g2_decap_8
X_13842_ _05166_ _05154_ _05165_ VPWR VGND sg13g2_xnor2_1
XFILLER_35_519 VPWR VGND sg13g2_fill_2
XFILLER_114_93 VPWR VGND sg13g2_fill_2
XFILLER_62_305 VPWR VGND sg13g2_fill_2
X_16561_ VGND VPWR net488 _07761_ _00234_ _07762_ sg13g2_a21oi_1
X_13773_ _05099_ _05084_ _05098_ VPWR VGND sg13g2_xnor2_1
XFILLER_90_669 VPWR VGND sg13g2_fill_2
X_18300_ _09363_ _09409_ _09410_ VPWR VGND sg13g2_nor2_1
X_15512_ _06768_ _06769_ _06770_ VPWR VGND sg13g2_nor2b_1
X_19280_ net355 VPWR _10345_ VGND u_LMS.w\[3\]\[11\] net371 sg13g2_o21ai_1
X_12724_ VGND VPWR net541 _04087_ _00071_ _04088_ sg13g2_a21oi_1
X_16492_ u_LMS.w\[0\]\[24\] u_LMS.w\[0\]\[23\] u_LMS.w\[0\]\[22\] u_LMS.w\[0\]\[21\]
+ _07711_ VPWR VGND sg13g2_nor4_1
XFILLER_128_1033 VPWR VGND sg13g2_decap_8
XFILLER_31_714 VPWR VGND sg13g2_fill_1
XFILLER_71_894 VPWR VGND sg13g2_fill_1
XFILLER_130_70 VPWR VGND sg13g2_decap_8
X_18231_ _09333_ VPWR _09341_ VGND net2102 _09340_ sg13g2_o21ai_1
X_15443_ _06706_ u_FIR.sum\[5\]\[16\] net393 VPWR VGND sg13g2_nand2_1
X_12655_ VGND VPWR _04021_ _04019_ _03991_ sg13g2_or2_1
XFILLER_90_52 VPWR VGND sg13g2_fill_1
XFILLER_31_769 VPWR VGND sg13g2_fill_1
XFILLER_129_602 VPWR VGND sg13g2_decap_4
X_18162_ _09272_ net674 net106 VPWR VGND sg13g2_nand2_1
X_15374_ _06640_ _06611_ _06613_ _06575_ net776 VPWR VGND sg13g2_a22oi_1
XFILLER_8_921 VPWR VGND sg13g2_fill_2
X_12586_ _03955_ net909 net733 net896 net735 VPWR VGND sg13g2_a22oi_1
XFILLER_128_112 VPWR VGND sg13g2_fill_1
X_17113_ _08267_ VPWR _08269_ VGND _08197_ _08266_ sg13g2_o21ai_1
X_14325_ _05629_ _05600_ _05631_ VPWR VGND sg13g2_xor2_1
XFILLER_11_482 VPWR VGND sg13g2_decap_8
X_18093_ _09203_ net672 net79 VPWR VGND sg13g2_nand2_1
XFILLER_8_976 VPWR VGND sg13g2_decap_8
X_17044_ _03281_ net141 _08200_ VPWR VGND sg13g2_nor2_1
X_14256_ _05557_ _05560_ _05563_ VPWR VGND sg13g2_nor2_1
Xrebuffer2109 _09468_ net2108 VPWR VGND sg13g2_buf_1
XFILLER_87_1050 VPWR VGND sg13g2_decap_8
X_13207_ VGND VPWR net534 _04553_ _00088_ _04554_ sg13g2_a21oi_1
X_14187_ _05496_ _05488_ _05495_ VPWR VGND sg13g2_xnor2_1
XFILLER_112_513 VPWR VGND sg13g2_fill_2
X_23372__1230 VPWR VGND net1229 sg13g2_tiehi
X_13138_ _04487_ net745 net842 VPWR VGND sg13g2_nand2_1
XFILLER_3_681 VPWR VGND sg13g2_fill_1
X_18995_ _10074_ _10072_ _10076_ _10082_ VPWR VGND sg13g2_a21o_1
XFILLER_79_950 VPWR VGND sg13g2_fill_2
X_17946_ u_LMS.w\[1\]\[20\] net77 _09079_ VPWR VGND sg13g2_nor2_1
X_13069_ _04420_ _04419_ _04415_ VPWR VGND sg13g2_nand2b_1
XFILLER_66_611 VPWR VGND sg13g2_decap_8
XFILLER_38_313 VPWR VGND sg13g2_fill_2
X_17877_ u_LMS.w\[1\]\[3\] _09007_ _09010_ VPWR VGND sg13g2_nor2_1
X_19616_ _10678_ _10675_ _10680_ VPWR VGND sg13g2_xor2_1
XFILLER_65_143 VPWR VGND sg13g2_decap_8
X_16828_ VPWR _07984_ _07983_ VGND sg13g2_inv_1
XFILLER_93_463 VPWR VGND sg13g2_fill_2
X_23697__1538 VPWR VGND net1537 sg13g2_tiehi
X_19547_ _10609_ _10608_ _10611_ VPWR VGND sg13g2_xor2_1
X_16759_ _07897_ _07896_ _07895_ _07915_ VPWR VGND sg13g2_mux2_1
XFILLER_55_1016 VPWR VGND sg13g2_decap_8
XFILLER_34_563 VPWR VGND sg13g2_decap_8
X_19478_ _10542_ _10540_ _10541_ VPWR VGND sg13g2_nand2_1
XFILLER_55_1027 VPWR VGND sg13g2_decap_4
XFILLER_62_894 VPWR VGND sg13g2_decap_4
XFILLER_61_360 VPWR VGND sg13g2_fill_1
X_18429_ _09529_ _09521_ _09539_ VPWR VGND sg13g2_xor2_1
XFILLER_22_747 VPWR VGND sg13g2_decap_4
X_21440_ _02057_ _02034_ _02035_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_70 VPWR VGND sg13g2_fill_1
XFILLER_108_808 VPWR VGND sg13g2_fill_2
X_21371_ _01987_ _01981_ _01988_ VPWR VGND sg13g2_xor2_1
XFILLER_119_49 VPWR VGND sg13g2_fill_1
X_20322_ _00985_ _11189_ net2120 VPWR VGND sg13g2_xnor2_1
X_23110_ net1626 VGND VPWR _00172_ u_FIR.sum\[6\]\[15\] clknet_leaf_43_clkA sg13g2_dfrbpq_1
XFILLER_119_178 VPWR VGND sg13g2_decap_8
X_20253_ _00914_ _00910_ _00915_ _00916_ VPWR VGND sg13g2_a21o_1
X_23041_ net1144 VGND VPWR _00103_ u_FIR.sum\[3\]\[3\] clknet_leaf_35_clkA sg13g2_dfrbpq_1
XFILLER_116_863 VPWR VGND sg13g2_fill_2
XFILLER_115_384 VPWR VGND sg13g2_fill_1
X_20184_ _11155_ _00846_ _00847_ VPWR VGND sg13g2_nor2b_1
XFILLER_88_224 VPWR VGND sg13g2_fill_2
XFILLER_88_257 VPWR VGND sg13g2_decap_8
XFILLER_130_354 VPWR VGND sg13g2_decap_8
XFILLER_130_398 VPWR VGND sg13g2_decap_8
XFILLER_28_35 VPWR VGND sg13g2_fill_2
XFILLER_85_964 VPWR VGND sg13g2_fill_1
XFILLER_29_346 VPWR VGND sg13g2_fill_1
XFILLER_28_57 VPWR VGND sg13g2_decap_8
XFILLER_28_68 VPWR VGND sg13g2_fill_1
XFILLER_84_452 VPWR VGND sg13g2_decap_8
XFILLER_84_463 VPWR VGND sg13g2_fill_2
XFILLER_38_891 VPWR VGND sg13g2_decap_4
X_22825_ VGND VPWR _07874_ net338 _00752_ _03130_ sg13g2_a21oi_1
XFILLER_72_669 VPWR VGND sg13g2_fill_1
XFILLER_71_168 VPWR VGND sg13g2_fill_2
X_22756_ u_debug_unit.mon_w3_sync\[1\] net334 _03096_ VPWR VGND sg13g2_nor2_1
XFILLER_25_585 VPWR VGND sg13g2_fill_1
XFILLER_12_202 VPWR VGND sg13g2_fill_2
XFILLER_13_736 VPWR VGND sg13g2_decap_4
X_21707_ net362 VPWR _02310_ VGND u_LMS.w\[7\]\[3\] net380 sg13g2_o21ai_1
XFILLER_40_533 VPWR VGND sg13g2_decap_8
X_22687_ coeff_force_packed\[53\] net465 _03068_ _00676_ VPWR VGND sg13g2_mux2_1
XFILLER_9_718 VPWR VGND sg13g2_decap_4
X_12440_ _03815_ _03787_ _03817_ VPWR VGND sg13g2_xor2_1
X_21638_ VGND VPWR _02253_ _02254_ _00441_ net932 sg13g2_a21oi_1
XFILLER_8_228 VPWR VGND sg13g2_fill_2
X_12371_ net1038 VPWR _03750_ VGND net543 u_FIR.sum\[0\]\[7\] sg13g2_o21ai_1
X_21569_ _02186_ net262 net603 net244 net604 VPWR VGND sg13g2_a22oi_1
X_23086__1078 VPWR VGND net1077 sg13g2_tiehi
X_14110_ _05420_ _05416_ _05421_ VPWR VGND sg13g2_xor2_1
X_23308_ net1293 VGND VPWR _00370_ u_LMS.w\[3\]\[10\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
X_15090_ _06327_ _06363_ _06364_ VPWR VGND sg13g2_nor2_1
XFILLER_4_412 VPWR VGND sg13g2_fill_2
XFILLER_5_28 VPWR VGND sg13g2_decap_8
XFILLER_107_0 VPWR VGND sg13g2_decap_8
X_14041_ net853 u_FIR.sum\[3\]\[4\] net766 _05354_ VPWR VGND sg13g2_nand3_1
X_23239_ net1411 VGND VPWR _00301_ u_LMS.w\[0\]\[10\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
XFILLER_121_310 VPWR VGND sg13g2_decap_8
X_17800_ _08931_ _08927_ _08932_ _08933_ VPWR VGND sg13g2_a21o_1
X_18780_ _09862_ _09861_ _09867_ VPWR VGND sg13g2_xor2_1
X_15992_ net858 net801 u_FIR.sum\[7\]\[3\] _07233_ VPWR VGND sg13g2_a21o_1
XFILLER_0_673 VPWR VGND sg13g2_decap_8
X_17731_ _08864_ _08863_ _08859_ VPWR VGND sg13g2_nand2b_1
X_14943_ _06225_ net268 _06223_ VPWR VGND sg13g2_xnor2_1
X_17662_ _08795_ net690 net258 VPWR VGND sg13g2_nand2_1
X_14874_ net269 _06157_ _06159_ VPWR VGND sg13g2_and2_1
XFILLER_78_1016 VPWR VGND sg13g2_fill_1
XFILLER_76_997 VPWR VGND sg13g2_fill_1
XFILLER_75_474 VPWR VGND sg13g2_fill_1
X_23421__1086 VPWR VGND net1085 sg13g2_tiehi
X_19401_ _10413_ _10388_ _10465_ VPWR VGND sg13g2_xor2_1
X_16613_ VGND VPWR u_LMS.w\[4\]\[15\] _07793_ _07801_ _07794_ sg13g2_a21oi_1
X_13825_ VGND VPWR net537 _05148_ _00111_ _05149_ sg13g2_a21oi_1
XFILLER_78_1049 VPWR VGND sg13g2_decap_8
X_17593_ _08692_ _08691_ _08726_ VPWR VGND sg13g2_xor2_1
XFILLER_35_349 VPWR VGND sg13g2_fill_2
XFILLER_16_530 VPWR VGND sg13g2_decap_4
X_19332_ VPWR _10396_ _10395_ VGND sg13g2_inv_1
X_16544_ u_LMS.w\[2\]\[23\] u_LMS.w\[2\]\[22\] u_LMS.w\[2\]\[24\] _07749_ VPWR VGND
+ u_LMS.w\[2\]\[21\] sg13g2_nand4_1
X_13756_ _05067_ VPWR _05082_ VGND _05063_ _05065_ sg13g2_o21ai_1
XFILLER_16_574 VPWR VGND sg13g2_decap_8
XFILLER_16_585 VPWR VGND sg13g2_fill_1
X_12707_ _04072_ net736 net830 u_FIR.sum\[0\]\[6\] VPWR VGND sg13g2_and3_1
X_19263_ VPWR VGND _10332_ _08554_ net27 _03331_ _00366_ net368 sg13g2_a221oi_1
X_16475_ _07699_ net413 net866 VPWR VGND sg13g2_nand2_1
XFILLER_31_533 VPWR VGND sg13g2_fill_2
X_23460__1552 VPWR VGND net1551 sg13g2_tiehi
X_13687_ _03364_ net409 _04975_ _05015_ VPWR VGND sg13g2_nor3_1
XFILLER_31_544 VPWR VGND sg13g2_decap_8
X_18214_ _09321_ _09322_ _09319_ _09324_ VPWR VGND sg13g2_nand3_1
X_15426_ _06690_ _06668_ _06688_ VPWR VGND sg13g2_xnor2_1
X_19194_ _10278_ _10237_ _10277_ VPWR VGND sg13g2_xnor2_1
X_12638_ _04004_ _04001_ _04005_ VPWR VGND sg13g2_xor2_1
XFILLER_129_443 VPWR VGND sg13g2_decap_4
X_18145_ _09241_ _09254_ _09255_ VPWR VGND sg13g2_and2_1
X_15357_ _06624_ _06588_ _06622_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_751 VPWR VGND sg13g2_decap_8
X_12569_ net906 u_FIR.sum\[0\]\[0\] net738 _03940_ VPWR VGND sg13g2_nand3_1
XFILLER_102_1036 VPWR VGND sg13g2_fill_2
XFILLER_7_250 VPWR VGND sg13g2_decap_8
X_14308_ _05614_ _05605_ _05612_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_784 VPWR VGND sg13g2_decap_8
X_18076_ _09184_ _09178_ _09186_ VPWR VGND sg13g2_xor2_1
XFILLER_8_795 VPWR VGND sg13g2_fill_1
X_15288_ _06557_ _06556_ _06515_ VPWR VGND sg13g2_nand2b_1
X_17027_ _08182_ _08174_ _08183_ VPWR VGND sg13g2_xor2_1
X_14239_ _05547_ u_FIR.sum\[3\]\[9\] net401 VPWR VGND sg13g2_nand2_1
X_23313__1289 VPWR VGND net1288 sg13g2_tiehi
Xfanout708 u_LMS.x_r\[0\]\[3\] net708 VPWR VGND sg13g2_buf_1
Xfanout719 net720 net719 VPWR VGND sg13g2_buf_1
XFILLER_98_555 VPWR VGND sg13g2_fill_1
XFILLER_86_706 VPWR VGND sg13g2_fill_2
XFILLER_100_516 VPWR VGND sg13g2_decap_4
X_18978_ _10065_ _10035_ _10036_ VPWR VGND sg13g2_xnor2_1
XFILLER_85_205 VPWR VGND sg13g2_fill_1
XFILLER_22_0 VPWR VGND sg13g2_decap_8
XFILLER_67_931 VPWR VGND sg13g2_decap_4
X_17929_ _09061_ VPWR _09062_ VGND _03268_ _08636_ sg13g2_o21ai_1
XFILLER_27_817 VPWR VGND sg13g2_fill_2
X_20940_ _03310_ _01579_ _01580_ VPWR VGND sg13g2_nor2_1
XFILLER_93_260 VPWR VGND sg13g2_decap_4
XFILLER_82_923 VPWR VGND sg13g2_decap_8
XFILLER_38_165 VPWR VGND sg13g2_decap_8
XFILLER_22_1059 VPWR VGND sg13g2_fill_2
XFILLER_94_794 VPWR VGND sg13g2_decap_8
XFILLER_93_282 VPWR VGND sg13g2_decap_8
X_20871_ _01502_ _01508_ _01511_ VPWR VGND sg13g2_nor2_1
XFILLER_54_669 VPWR VGND sg13g2_fill_2
X_22610_ _03060_ net429 _03441_ VPWR VGND sg13g2_nand2_1
X_23590_ net965 VGND VPWR _00652_ coeff_force_packed\[32\] clknet_leaf_16_clkA sg13g2_dfrbpq_1
XFILLER_22_500 VPWR VGND sg13g2_decap_8
XFILLER_62_680 VPWR VGND sg13g2_decap_8
X_22541_ _03025_ _03026_ _00572_ VPWR VGND sg13g2_nor2_1
XFILLER_50_875 VPWR VGND sg13g2_fill_1
X_22472_ VGND VPWR net448 _03233_ _00544_ _02985_ sg13g2_a21oi_1
XFILLER_10_739 VPWR VGND sg13g2_decap_4
X_21423_ net604 net191 net602 _02040_ VPWR VGND net229 sg13g2_nand4_1
XFILLER_107_104 VPWR VGND sg13g2_decap_8
X_21354_ _01946_ _01904_ _01971_ VPWR VGND sg13g2_xor2_1
X_20305_ _00968_ _00960_ _00967_ VPWR VGND sg13g2_xnor2_1
X_21285_ _01902_ _01900_ _01901_ VPWR VGND sg13g2_nand2b_1
X_23082__1084 VPWR VGND net1083 sg13g2_tiehi
X_23024_ net1170 VGND VPWR _00086_ u_FIR.sum\[2\]\[5\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
XFILLER_118_1010 VPWR VGND sg13g2_decap_8
XFILLER_103_310 VPWR VGND sg13g2_fill_1
X_20236_ _00899_ _00896_ _00898_ VPWR VGND sg13g2_nand2_1
XFILLER_115_181 VPWR VGND sg13g2_decap_8
XFILLER_89_555 VPWR VGND sg13g2_fill_1
XFILLER_131_641 VPWR VGND sg13g2_fill_2
XFILLER_103_343 VPWR VGND sg13g2_decap_4
X_20167_ VGND VPWR _00822_ _00829_ _00830_ _00821_ sg13g2_a21oi_1
XFILLER_39_45 VPWR VGND sg13g2_decap_8
XFILLER_131_674 VPWR VGND sg13g2_decap_8
X_20098_ _11096_ _11094_ _11139_ VPWR VGND sg13g2_xor2_1
XFILLER_76_249 VPWR VGND sg13g2_decap_8
XFILLER_58_975 VPWR VGND sg13g2_decap_8
XFILLER_85_761 VPWR VGND sg13g2_fill_1
XFILLER_73_901 VPWR VGND sg13g2_decap_8
X_11940_ VPWR _03361_ u_FIR.w\[6\]\[6\] VGND sg13g2_inv_1
XFILLER_55_11 VPWR VGND sg13g2_fill_2
XFILLER_85_783 VPWR VGND sg13g2_fill_1
XFILLER_29_165 VPWR VGND sg13g2_fill_1
XFILLER_72_411 VPWR VGND sg13g2_decap_8
XFILLER_84_282 VPWR VGND sg13g2_fill_2
XFILLER_73_945 VPWR VGND sg13g2_decap_8
XFILLER_72_422 VPWR VGND sg13g2_fill_1
XFILLER_84_293 VPWR VGND sg13g2_fill_1
XFILLER_73_956 VPWR VGND sg13g2_fill_2
XFILLER_45_647 VPWR VGND sg13g2_fill_1
X_11871_ VPWR _03292_ u_LMS.w\[8\]\[8\] VGND sg13g2_inv_1
X_13610_ _04940_ _04932_ _04938_ VPWR VGND sg13g2_xnor2_1
X_22808_ u_debug_unit.mon_w6_sync\[6\] net351 _03122_ VPWR VGND sg13g2_nor2_1
XFILLER_77_1060 VPWR VGND sg13g2_fill_1
X_14590_ _05883_ _05853_ _05882_ VPWR VGND sg13g2_nand2b_1
XFILLER_25_360 VPWR VGND sg13g2_fill_1
XFILLER_13_522 VPWR VGND sg13g2_fill_1
XFILLER_111_72 VPWR VGND sg13g2_fill_1
X_13541_ _04873_ _04871_ _04872_ VPWR VGND sg13g2_nand2_1
X_22739_ VGND VPWR _03347_ net331 _00709_ _03087_ sg13g2_a21oi_1
X_16260_ _07496_ _07487_ _07494_ VPWR VGND sg13g2_xnor2_1
X_13472_ VGND VPWR net414 _03380_ _00098_ _04809_ sg13g2_a21oi_1
XFILLER_125_1058 VPWR VGND sg13g2_fill_2
XFILLER_13_599 VPWR VGND sg13g2_decap_4
X_15211_ _06482_ _06453_ _06481_ VPWR VGND sg13g2_nand2b_1
XFILLER_40_396 VPWR VGND sg13g2_decap_8
X_12423_ _03800_ _03799_ _03795_ VPWR VGND sg13g2_nand2b_1
XFILLER_127_903 VPWR VGND sg13g2_decap_8
X_16191_ _07429_ _07425_ _07428_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_936 VPWR VGND sg13g2_fill_1
X_15142_ _06400_ VPWR _06414_ VGND _06351_ _06390_ sg13g2_o21ai_1
X_12354_ _03733_ net724 net841 VPWR VGND sg13g2_nand2_1
XFILLER_126_457 VPWR VGND sg13g2_fill_2
X_19950_ net425 _03236_ net113 net95 _10991_ VPWR VGND sg13g2_nor4_1
X_15073_ VGND VPWR _06347_ _06345_ _06313_ sg13g2_or2_1
XFILLER_5_765 VPWR VGND sg13g2_decap_8
XFILLER_126_479 VPWR VGND sg13g2_fill_1
X_12285_ _03666_ _03631_ _03664_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_787 VPWR VGND sg13g2_decap_8
X_18901_ _09988_ _09986_ _09987_ VPWR VGND sg13g2_nand2_1
X_14024_ _05338_ _05335_ _05336_ VPWR VGND sg13g2_xnor2_1
X_19881_ net359 VPWR _10926_ VGND u_LMS.w\[4\]\[8\] net375 sg13g2_o21ai_1
X_18832_ _09919_ _09917_ _09918_ VPWR VGND sg13g2_nand2b_1
XFILLER_96_40 VPWR VGND sg13g2_fill_2
XFILLER_96_51 VPWR VGND sg13g2_decap_4
XFILLER_121_151 VPWR VGND sg13g2_decap_8
XFILLER_110_825 VPWR VGND sg13g2_decap_8
XFILLER_68_739 VPWR VGND sg13g2_decap_8
XFILLER_67_216 VPWR VGND sg13g2_decap_8
XFILLER_1_982 VPWR VGND sg13g2_decap_8
XFILLER_67_238 VPWR VGND sg13g2_fill_1
X_18763_ VGND VPWR net655 net183 _09850_ _09846_ sg13g2_a21oi_1
X_15975_ net1002 VPWR _07218_ VGND net499 u_FIR.sum\[7\]\[17\] sg13g2_o21ai_1
X_17714_ net2209 _08846_ _08847_ VPWR VGND sg13g2_nor2_1
X_14926_ _06207_ _06208_ _06209_ VPWR VGND sg13g2_and2_1
X_18694_ VGND VPWR _09772_ _09780_ _09781_ _09770_ sg13g2_a21oi_1
XFILLER_35_113 VPWR VGND sg13g2_fill_2
XFILLER_36_647 VPWR VGND sg13g2_decap_8
X_17645_ _08777_ VPWR _08778_ VGND _08773_ _08774_ sg13g2_o21ai_1
X_14857_ _06143_ _06121_ _06141_ VPWR VGND sg13g2_xnor2_1
X_13808_ _05133_ _05121_ _05132_ VPWR VGND sg13g2_xnor2_1
X_17576_ _08709_ _08706_ _08707_ VPWR VGND sg13g2_xnor2_1
X_14788_ _06076_ _06067_ _06074_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_1002 VPWR VGND sg13g2_decap_8
X_19315_ VGND VPWR net641 net114 _10379_ _10376_ sg13g2_a21oi_1
X_16527_ net974 VPWR _07738_ VGND net482 net789 sg13g2_o21ai_1
X_13739_ _05066_ _05062_ _05065_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_1057 VPWR VGND sg13g2_decap_4
X_19246_ _10320_ _10118_ u_LMS.w\[3\]\[2\] VPWR VGND sg13g2_nand2b_1
X_16458_ _07686_ net271 _07685_ VPWR VGND sg13g2_xnor2_1
X_15409_ _06674_ _06646_ _06672_ VPWR VGND sg13g2_xnor2_1
X_19177_ _08494_ _10262_ _10264_ VPWR VGND sg13g2_nor2_1
X_16389_ _07621_ _07610_ _07620_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_273 VPWR VGND sg13g2_fill_1
X_18128_ _09220_ _09237_ _09238_ VPWR VGND sg13g2_nor2_1
X_18059_ VPWR VGND _09170_ _08554_ net37 _03343_ _00324_ net369 sg13g2_a221oi_1
XFILLER_132_405 VPWR VGND sg13g2_decap_8
XFILLER_126_980 VPWR VGND sg13g2_fill_1
X_21070_ _01651_ _01649_ _01700_ VPWR VGND sg13g2_xor2_1
XFILLER_98_330 VPWR VGND sg13g2_fill_2
Xfanout505 net508 net505 VPWR VGND sg13g2_buf_1
X_20021_ _11059_ _11061_ _11062_ VPWR VGND sg13g2_nor2_1
Xfanout516 net517 net516 VPWR VGND sg13g2_buf_1
XFILLER_98_352 VPWR VGND sg13g2_fill_2
Xfanout527 net530 net527 VPWR VGND sg13g2_buf_1
Xfanout538 net539 net538 VPWR VGND sg13g2_buf_1
XFILLER_98_363 VPWR VGND sg13g2_decap_8
XFILLER_101_836 VPWR VGND sg13g2_decap_8
Xfanout549 net550 net549 VPWR VGND sg13g2_buf_1
XFILLER_101_847 VPWR VGND sg13g2_decap_8
XFILLER_112_184 VPWR VGND sg13g2_decap_8
XFILLER_58_238 VPWR VGND sg13g2_fill_2
XFILLER_6_1053 VPWR VGND sg13g2_decap_8
X_21972_ _02542_ _02499_ _02566_ VPWR VGND sg13g2_xor2_1
XFILLER_132_49 VPWR VGND sg13g2_decap_8
XFILLER_66_271 VPWR VGND sg13g2_fill_2
X_23711_ net1445 VGND VPWR _00773_ u_FIR.x\[0\] clknet_leaf_26_clkA sg13g2_dfrbpq_1
X_20923_ _01563_ _01265_ _01268_ VPWR VGND sg13g2_xnor2_1
XFILLER_70_904 VPWR VGND sg13g2_decap_8
XFILLER_55_978 VPWR VGND sg13g2_fill_2
X_23642_ net981 VGND VPWR _00704_ u_debug_unit.mon_w1_sync\[1\] clknet_leaf_52_clkA
+ sg13g2_dfrbpq_1
X_20854_ _01494_ _01470_ _01471_ VPWR VGND sg13g2_xnor2_1
XFILLER_41_138 VPWR VGND sg13g2_fill_1
X_23573_ net986 VGND VPWR _00635_ coeff_force_packed\[17\] clknet_leaf_53_clkA sg13g2_dfrbpq_1
X_20785_ _01424_ VPWR _01425_ VGND net2059 _01419_ sg13g2_o21ai_1
X_22524_ net916 _03015_ _00566_ VPWR VGND sg13g2_nor2_1
XFILLER_10_525 VPWR VGND sg13g2_decap_8
XFILLER_10_536 VPWR VGND sg13g2_decap_4
X_22455_ net961 VPWR _02977_ VGND net450 net619 sg13g2_o21ai_1
XFILLER_41_46 VPWR VGND sg13g2_fill_2
X_21406_ net604 net189 net171 _02023_ VPWR VGND net602 sg13g2_nand4_1
XFILLER_108_446 VPWR VGND sg13g2_fill_1
X_22386_ VGND VPWR net452 _03276_ _00501_ _02942_ sg13g2_a21oi_1
X_21337_ _01954_ _01938_ _01952_ VPWR VGND sg13g2_xnor2_1
XFILLER_2_713 VPWR VGND sg13g2_fill_1
XFILLER_123_427 VPWR VGND sg13g2_decap_4
XFILLER_2_735 VPWR VGND sg13g2_fill_2
X_12070_ _03466_ VPWR _00045_ VGND _03482_ _03483_ sg13g2_o21ai_1
X_21268_ VPWR _01885_ _01884_ VGND sg13g2_inv_1
XFILLER_2_768 VPWR VGND sg13g2_decap_8
XFILLER_132_961 VPWR VGND sg13g2_decap_8
X_23007_ net1195 VGND VPWR _00069_ u_FIR.sum\[1\]\[4\] clknet_leaf_31_clkA sg13g2_dfrbpq_1
XFILLER_89_352 VPWR VGND sg13g2_decap_8
X_20219_ _00880_ _00881_ _00882_ VPWR VGND sg13g2_and2_1
XFILLER_1_267 VPWR VGND sg13g2_decap_8
X_21199_ _01816_ _01815_ _01794_ VPWR VGND sg13g2_nand2b_1
XFILLER_49_216 VPWR VGND sg13g2_fill_2
XFILLER_103_184 VPWR VGND sg13g2_decap_8
X_15760_ _07011_ _06970_ _06973_ _07010_ VPWR VGND sg13g2_and3_1
X_12972_ _04330_ _04323_ _04328_ VPWR VGND sg13g2_xnor2_1
XFILLER_18_614 VPWR VGND sg13g2_fill_2
XFILLER_131_1051 VPWR VGND sg13g2_decap_8
X_23492__1441 VPWR VGND net1440 sg13g2_tiehi
XFILLER_92_539 VPWR VGND sg13g2_decap_8
XFILLER_66_87 VPWR VGND sg13g2_fill_2
XFILLER_57_271 VPWR VGND sg13g2_decap_8
X_14711_ _06001_ _06000_ _05967_ VPWR VGND sg13g2_nand2b_1
X_11923_ VPWR _03344_ u_LMS.w\[1\]\[8\] VGND sg13g2_inv_1
X_15691_ net860 _06942_ net784 _06943_ VPWR VGND sg13g2_nand3_1
XFILLER_61_904 VPWR VGND sg13g2_fill_2
X_17430_ _08568_ _08444_ _08445_ VPWR VGND sg13g2_xnor2_1
X_14642_ _05933_ net769 net862 VPWR VGND sg13g2_nand2_1
X_11854_ VPWR _03275_ net702 VGND sg13g2_inv_1
XFILLER_72_274 VPWR VGND sg13g2_fill_2
X_23284__1326 VPWR VGND net1325 sg13g2_tiehi
XFILLER_72_296 VPWR VGND sg13g2_fill_1
XFILLER_14_831 VPWR VGND sg13g2_fill_2
X_17361_ _08404_ VPWR _08513_ VGND _08407_ _08468_ sg13g2_o21ai_1
X_14573_ _05866_ _05860_ _05864_ VPWR VGND sg13g2_xnor2_1
X_11785_ VPWR _03206_ u_s2p_input.reg_sh\[4\] VGND sg13g2_inv_1
XFILLER_82_86 VPWR VGND sg13g2_fill_1
XFILLER_41_650 VPWR VGND sg13g2_fill_2
X_19100_ _10187_ _10135_ _10136_ VPWR VGND sg13g2_xnor2_1
X_16312_ _07547_ _07516_ _07545_ VPWR VGND sg13g2_xnor2_1
X_13524_ _04857_ _04835_ _04855_ VPWR VGND sg13g2_xnor2_1
X_17292_ _08448_ _03351_ _08421_ VPWR VGND sg13g2_nand2_1
XFILLER_40_171 VPWR VGND sg13g2_decap_4
X_19031_ _10118_ net668 net253 VPWR VGND sg13g2_nand2_1
X_16243_ VGND VPWR net476 _07478_ _00199_ _07479_ sg13g2_a21oi_1
X_13455_ _04793_ _04785_ _04795_ VPWR VGND sg13g2_xor2_1
X_12406_ VGND VPWR _03745_ _03748_ _03784_ _03782_ sg13g2_a21oi_1
X_16174_ _07412_ _07411_ _07407_ VPWR VGND sg13g2_nand2b_1
X_13386_ _04729_ _04722_ _04727_ VPWR VGND sg13g2_xnor2_1
X_15125_ _06398_ _06397_ _06356_ VPWR VGND sg13g2_nand2b_1
XFILLER_5_540 VPWR VGND sg13g2_fill_2
XFILLER_115_917 VPWR VGND sg13g2_fill_1
X_12337_ net728 net811 _03716_ VPWR VGND sg13g2_and2_1
XFILLER_99_116 VPWR VGND sg13g2_fill_2
XFILLER_114_416 VPWR VGND sg13g2_decap_4
X_19933_ _10958_ _10973_ _10974_ VPWR VGND sg13g2_nor2b_1
X_15056_ _06331_ _06309_ _06329_ VPWR VGND sg13g2_xnor2_1
X_12268_ _03649_ _03647_ _03648_ VPWR VGND sg13g2_nand2b_1
X_14007_ net865 u_FIR.sum\[3\]\[3\] net766 _05321_ VPWR VGND sg13g2_nand3_1
XFILLER_68_503 VPWR VGND sg13g2_fill_1
XFILLER_123_972 VPWR VGND sg13g2_fill_2
X_19864_ VGND VPWR net53 _10912_ _10913_ net24 sg13g2_a21oi_1
X_23212__1460 VPWR VGND net1459 sg13g2_tiehi
X_12199_ _03584_ _03586_ _03583_ _03587_ VPWR VGND sg13g2_nand3_1
XFILLER_96_834 VPWR VGND sg13g2_fill_1
X_18815_ VPWR _09902_ _09901_ VGND sg13g2_inv_1
X_19795_ _10802_ _10801_ _10858_ VPWR VGND sg13g2_xor2_1
X_23040__1147 VPWR VGND net1146 sg13g2_tiehi
X_18746_ _09831_ _09832_ _09833_ VPWR VGND sg13g2_and2_1
X_15958_ net929 _07201_ _00192_ VPWR VGND sg13g2_nor2_1
XFILLER_83_539 VPWR VGND sg13g2_fill_2
X_23219__1447 VPWR VGND net1446 sg13g2_tiehi
XFILLER_95_399 VPWR VGND sg13g2_fill_1
XFILLER_49_794 VPWR VGND sg13g2_fill_2
XFILLER_48_282 VPWR VGND sg13g2_fill_2
X_14909_ _06180_ _06192_ _06193_ VPWR VGND sg13g2_nor2_1
XFILLER_37_967 VPWR VGND sg13g2_decap_8
X_18677_ _03253_ net98 _09764_ VPWR VGND sg13g2_nor2_1
X_15889_ _07130_ _07135_ _07136_ VPWR VGND sg13g2_nor2b_1
XFILLER_64_764 VPWR VGND sg13g2_decap_8
XFILLER_91_561 VPWR VGND sg13g2_fill_1
XFILLER_64_775 VPWR VGND sg13g2_fill_2
X_17628_ _08761_ _08758_ _08759_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_594 VPWR VGND sg13g2_decap_8
XFILLER_23_127 VPWR VGND sg13g2_fill_2
X_17559_ _08687_ _08686_ _08692_ VPWR VGND sg13g2_xor2_1
XFILLER_108_1053 VPWR VGND sg13g2_decap_8
X_20570_ _01210_ _01202_ _01208_ VPWR VGND sg13g2_xnor2_1
X_19229_ VGND VPWR _10305_ _10306_ _00358_ net927 sg13g2_a21oi_1
X_22240_ u_LMS.w\[8\]\[20\] u_LMS.w\[8\]\[21\] net60 _02834_ VPWR VGND sg13g2_a21o_1
X_22171_ _02765_ net2178 _02764_ VPWR VGND sg13g2_xnor2_1
XFILLER_118_799 VPWR VGND sg13g2_fill_1
XFILLER_127_49 VPWR VGND sg13g2_decap_8
XFILLER_132_213 VPWR VGND sg13g2_decap_8
X_21122_ net361 VPWR _01740_ VGND u_LMS.w\[6\]\[11\] net378 sg13g2_o21ai_1
XFILLER_99_650 VPWR VGND sg13g2_fill_2
XFILLER_28_1021 VPWR VGND sg13g2_fill_1
Xfanout302 net303 net302 VPWR VGND sg13g2_buf_1
XFILLER_87_812 VPWR VGND sg13g2_fill_2
X_21053_ VGND VPWR _01684_ _01686_ _00424_ net936 sg13g2_a21oi_1
Xfanout313 net314 net313 VPWR VGND sg13g2_buf_1
XFILLER_114_983 VPWR VGND sg13g2_decap_4
Xfanout324 _03573_ net324 VPWR VGND sg13g2_buf_1
XFILLER_59_514 VPWR VGND sg13g2_fill_2
Xfanout335 net337 net335 VPWR VGND sg13g2_buf_1
Xfanout346 net349 net346 VPWR VGND sg13g2_buf_1
X_20004_ _11043_ _11044_ _11045_ VPWR VGND sg13g2_nor2_1
Xfanout357 net360 net357 VPWR VGND sg13g2_buf_1
XFILLER_87_867 VPWR VGND sg13g2_fill_2
Xfanout368 _08492_ net368 VPWR VGND sg13g2_buf_1
Xfanout379 net380 net379 VPWR VGND sg13g2_buf_1
XFILLER_115_1057 VPWR VGND sg13g2_decap_4
XFILLER_28_901 VPWR VGND sg13g2_fill_1
XFILLER_36_24 VPWR VGND sg13g2_decap_8
X_21955_ _02534_ _02548_ _02549_ VPWR VGND sg13g2_nor2b_1
XFILLER_43_926 VPWR VGND sg13g2_decap_4
X_20906_ _01219_ _01229_ _01200_ _01546_ VPWR VGND sg13g2_nand3_1
XFILLER_70_712 VPWR VGND sg13g2_decap_8
X_21886_ VPWR _02480_ _02479_ VGND sg13g2_inv_1
XFILLER_54_296 VPWR VGND sg13g2_fill_1
X_23625_ net956 VGND VPWR _00687_ u_debug_unit.force_w8\[7\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
X_20837_ VPWR _01477_ _01476_ VGND sg13g2_inv_1
XFILLER_35_1025 VPWR VGND sg13g2_decap_4
X_23556_ net1010 VGND VPWR _00618_ coeff_force_packed\[2\] clknet_leaf_17_clkA sg13g2_dfrbpq_1
X_20768_ _01408_ _01403_ _01406_ VPWR VGND sg13g2_xnor2_1
XFILLER_23_694 VPWR VGND sg13g2_fill_1
XFILLER_11_834 VPWR VGND sg13g2_decap_8
XFILLER_122_1006 VPWR VGND sg13g2_decap_4
X_22507_ _03004_ _03003_ _00560_ VPWR VGND sg13g2_nor2b_1
XFILLER_11_856 VPWR VGND sg13g2_decap_8
X_23487_ net1458 VGND VPWR _00549_ u_LMS.x_r\[7\]\[6\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
X_20699_ _01339_ _01189_ _01325_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_304 VPWR VGND sg13g2_fill_1
XFILLER_11_889 VPWR VGND sg13g2_decap_8
X_13240_ _04585_ _04557_ _04587_ VPWR VGND sg13g2_xor2_1
X_22438_ VGND VPWR net443 _03250_ _00527_ _02968_ sg13g2_a21oi_1
X_13171_ _04493_ VPWR _04519_ VGND _04445_ _04485_ sg13g2_o21ai_1
X_22369_ net1027 VPWR _02934_ VGND net455 u_LMS.x_r\[0\]\[6\] sg13g2_o21ai_1
X_12122_ _03531_ _03532_ _03524_ _03533_ VPWR VGND sg13g2_nand3_1
XFILLER_124_747 VPWR VGND sg13g2_decap_8
X_16930_ _07999_ _07983_ _08086_ VPWR VGND sg13g2_xor2_1
X_12053_ _03467_ _03438_ u_debug_unit.error_signal_sync\[5\] _03407_ u_debug_unit.mon_w1_sync\[5\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_123_279 VPWR VGND sg13g2_fill_2
XFILLER_81_1056 VPWR VGND sg13g2_decap_4
XFILLER_78_856 VPWR VGND sg13g2_decap_8
X_16861_ _08000_ _08016_ _08017_ VPWR VGND sg13g2_nor2_1
Xfanout880 net885 net880 VPWR VGND sg13g2_buf_1
X_18600_ VGND VPWR _09701_ _09703_ _00332_ net919 sg13g2_a21oi_1
Xfanout891 u_FIR.x_reg\[1\] net891 VPWR VGND sg13g2_buf_1
X_15812_ _07059_ _07060_ _07061_ VPWR VGND sg13g2_nor2_1
X_19580_ _10644_ _10611_ _10617_ VPWR VGND sg13g2_xnor2_1
XFILLER_37_219 VPWR VGND sg13g2_decap_4
X_16792_ _07946_ _07947_ _07948_ VPWR VGND sg13g2_nor2b_1
X_18531_ u_LMS.w\[2\]\[11\] _09600_ _09641_ VPWR VGND sg13g2_nor2_1
XFILLER_18_433 VPWR VGND sg13g2_fill_2
X_15743_ _06988_ _06993_ _06994_ VPWR VGND sg13g2_nor2b_1
X_12955_ VGND VPWR _04283_ _04306_ _04313_ _04305_ sg13g2_a21oi_1
X_11906_ VPWR _03327_ u_LMS.w\[4\]\[14\] VGND sg13g2_inv_1
XFILLER_61_712 VPWR VGND sg13g2_decap_4
X_18462_ VGND VPWR _09242_ _09251_ _09572_ _09253_ sg13g2_a21oi_1
X_15674_ _06926_ _06918_ _06927_ VPWR VGND sg13g2_xor2_1
X_12886_ VGND VPWR _04247_ _04246_ _04245_ sg13g2_or2_1
XFILLER_45_296 VPWR VGND sg13g2_decap_4
X_17413_ _08552_ _08555_ _00293_ VPWR VGND sg13g2_nor2_1
X_14625_ _05917_ _05907_ _05915_ VPWR VGND sg13g2_xnor2_1
X_11837_ VPWR _03258_ net667 VGND sg13g2_inv_1
X_18393_ _09503_ net679 net254 VPWR VGND sg13g2_nand2_1
XFILLER_14_650 VPWR VGND sg13g2_decap_8
XFILLER_42_970 VPWR VGND sg13g2_decap_8
XFILLER_14_661 VPWR VGND sg13g2_fill_2
XFILLER_60_277 VPWR VGND sg13g2_decap_8
X_17344_ net567 net384 _08500_ VPWR VGND sg13g2_nor2_1
X_14556_ VGND VPWR _05850_ _05849_ _05822_ sg13g2_or2_1
XFILLER_20_119 VPWR VGND sg13g2_decap_4
XFILLER_13_182 VPWR VGND sg13g2_fill_2
X_13507_ _04840_ _04838_ _04839_ VPWR VGND sg13g2_nand2_1
X_17275_ _08431_ u_LMS.w\[0\]\[3\] _08430_ VPWR VGND sg13g2_nand2_1
X_14487_ _05782_ _05776_ _05784_ VPWR VGND sg13g2_xor2_1
X_19014_ _10101_ _10098_ _10100_ VPWR VGND sg13g2_nand2_1
X_16226_ VGND VPWR _07463_ _07418_ _07416_ sg13g2_or2_1
X_13438_ _04779_ _04759_ _04762_ _04778_ VPWR VGND sg13g2_and3_1
X_16157_ _07396_ _07364_ _07394_ VPWR VGND sg13g2_xnor2_1
X_13369_ VGND VPWR _04680_ _04684_ _04712_ _04683_ sg13g2_a21oi_1
XFILLER_6_871 VPWR VGND sg13g2_decap_8
XFILLER_127_596 VPWR VGND sg13g2_fill_1
XFILLER_115_736 VPWR VGND sg13g2_fill_1
X_15108_ _06379_ _06376_ _06381_ VPWR VGND sg13g2_xor2_1
X_16088_ _07307_ _07316_ _07328_ VPWR VGND sg13g2_and2_1
XFILLER_5_392 VPWR VGND sg13g2_decap_8
X_19916_ _10957_ _10950_ _10955_ VPWR VGND sg13g2_xnor2_1
X_15039_ VGND VPWR _06314_ _06312_ _06278_ sg13g2_or2_1
XFILLER_110_430 VPWR VGND sg13g2_fill_1
X_19847_ net26 VPWR _10900_ VGND net25 _10899_ sg13g2_o21ai_1
XFILLER_95_130 VPWR VGND sg13g2_decap_8
XFILLER_111_986 VPWR VGND sg13g2_decap_8
XFILLER_111_997 VPWR VGND sg13g2_fill_1
X_19778_ _10842_ _10839_ _10841_ VPWR VGND sg13g2_nand2_1
XFILLER_37_720 VPWR VGND sg13g2_decap_8
X_18729_ _09814_ _09815_ _09816_ VPWR VGND sg13g2_nor2b_1
XFILLER_3_1056 VPWR VGND sg13g2_decap_4
XFILLER_97_1052 VPWR VGND sg13g2_decap_8
X_21740_ _02333_ _02334_ _00463_ VPWR VGND sg13g2_nor2_1
XFILLER_51_211 VPWR VGND sg13g2_fill_1
X_21671_ net12 VPWR _02281_ VGND net11 _02280_ sg13g2_o21ai_1
X_23410_ net1118 VGND VPWR _00472_ u_LMS.w\[8\]\[20\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
X_20622_ _01260_ _01261_ _01262_ VPWR VGND sg13g2_nor2b_1
XFILLER_51_288 VPWR VGND sg13g2_decap_8
X_23341_ net1260 VGND VPWR _00403_ u_LMS.w\[5\]\[20\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
X_20553_ _01193_ _01192_ _01191_ VPWR VGND sg13g2_nand2b_1
XFILLER_20_686 VPWR VGND sg13g2_decap_8
X_23272_ net1349 VGND VPWR _00334_ u_LMS.w\[2\]\[20\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
X_20484_ net363 VPWR _01131_ VGND u_LMS.w\[5\]\[5\] net381 sg13g2_o21ai_1
X_22223_ VGND VPWR _02817_ _02762_ u_LMS.w\[8\]\[14\] sg13g2_or2_1
XFILLER_106_714 VPWR VGND sg13g2_decap_4
XFILLER_65_1007 VPWR VGND sg13g2_fill_1
XFILLER_105_235 VPWR VGND sg13g2_decap_8
XFILLER_106_758 VPWR VGND sg13g2_fill_1
X_22154_ _02748_ _02385_ _02747_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_717 VPWR VGND sg13g2_decap_8
X_21105_ VGND VPWR _01657_ _01726_ _01727_ net14 sg13g2_a21oi_1
XFILLER_121_728 VPWR VGND sg13g2_fill_1
X_22085_ net203 _02678_ net584 _02679_ VPWR VGND sg13g2_nand3_1
Xfanout110 net111 net110 VPWR VGND sg13g2_buf_2
Xfanout121 _08623_ net121 VPWR VGND sg13g2_buf_1
XFILLER_87_620 VPWR VGND sg13g2_fill_1
XFILLER_114_791 VPWR VGND sg13g2_fill_1
Xfanout132 net133 net132 VPWR VGND sg13g2_buf_2
X_21036_ net18 VPWR _01673_ VGND net16 _01672_ sg13g2_o21ai_1
Xfanout143 net143 net1664 VPWR VGND sg13g2_buf_4
XFILLER_87_642 VPWR VGND sg13g2_fill_2
XFILLER_120_249 VPWR VGND sg13g2_decap_8
XFILLER_102_964 VPWR VGND sg13g2_fill_2
Xfanout154 net156 net154 VPWR VGND sg13g2_buf_1
Xfanout165 net166 net165 VPWR VGND sg13g2_buf_2
Xfanout176 net177 net176 VPWR VGND sg13g2_buf_1
XFILLER_86_152 VPWR VGND sg13g2_fill_2
XFILLER_101_474 VPWR VGND sg13g2_decap_4
Xfanout187 net1654 net187 VPWR VGND sg13g2_buf_1
XFILLER_74_303 VPWR VGND sg13g2_fill_1
Xfanout198 net199 net198 VPWR VGND sg13g2_buf_1
XFILLER_59_388 VPWR VGND sg13g2_decap_4
XFILLER_28_731 VPWR VGND sg13g2_fill_1
X_23326__1276 VPWR VGND net1275 sg13g2_tiehi
XFILLER_74_347 VPWR VGND sg13g2_fill_2
X_22987_ net1225 VGND VPWR _00049_ u_LMS.mu\[4\] clknet_leaf_61_clkA sg13g2_dfrbpq_1
XFILLER_103_51 VPWR VGND sg13g2_fill_1
X_12740_ _04064_ _04103_ _04104_ VPWR VGND sg13g2_nor2_1
XFILLER_83_881 VPWR VGND sg13g2_fill_2
X_21938_ net577 net242 net575 _02532_ VPWR VGND net257 sg13g2_nand4_1
XFILLER_43_745 VPWR VGND sg13g2_fill_2
XFILLER_63_44 VPWR VGND sg13g2_decap_8
X_12671_ net842 net736 u_FIR.sum\[0\]\[5\] _04037_ VPWR VGND sg13g2_a21o_1
X_21869_ _02463_ _02462_ _02460_ VPWR VGND sg13g2_nand2b_1
X_14410_ VGND VPWR net512 _05711_ _00133_ _05712_ sg13g2_a21oi_1
X_23608_ net967 VGND VPWR _00670_ coeff_force_packed\[48\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
X_15390_ _06638_ _06655_ _06656_ VPWR VGND sg13g2_nor2b_1
XFILLER_24_992 VPWR VGND sg13g2_fill_2
XFILLER_8_28 VPWR VGND sg13g2_decap_8
XFILLER_23_491 VPWR VGND sg13g2_fill_1
X_14341_ _05646_ _05638_ _05644_ VPWR VGND sg13g2_xnor2_1
X_23539_ net1012 VGND VPWR _00601_ debug_load_bus\[1\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
X_17060_ _08216_ _08214_ _08215_ VPWR VGND sg13g2_xnor2_1
X_14272_ _05579_ _05571_ _05578_ VPWR VGND sg13g2_nand2_1
XFILLER_10_185 VPWR VGND sg13g2_fill_1
X_16011_ _07252_ _07250_ _07251_ VPWR VGND sg13g2_nand2_1
X_13223_ _04570_ net842 net742 net829 net744 VPWR VGND sg13g2_a22oi_1
XFILLER_128_70 VPWR VGND sg13g2_decap_8
X_13154_ _04503_ _04460_ _04501_ VPWR VGND sg13g2_xnor2_1
XFILLER_112_717 VPWR VGND sg13g2_decap_8
X_12105_ _03512_ _03513_ _03503_ _03517_ VPWR VGND _03516_ sg13g2_nand4_1
X_17962_ u_LMS.w\[1\]\[24\] net78 _09095_ VPWR VGND sg13g2_nor2_1
X_13085_ _04436_ _04408_ _04435_ VPWR VGND sg13g2_nand2_1
XFILLER_97_428 VPWR VGND sg13g2_decap_8
XFILLER_69_119 VPWR VGND sg13g2_fill_1
X_19701_ _10765_ u_LMS.w\[4\]\[6\] _10764_ VPWR VGND sg13g2_nand2_1
X_16913_ net418 net232 _08069_ VPWR VGND sg13g2_nor2_1
X_12036_ _03452_ _03422_ _03450_ _03385_ _03383_ VPWR VGND sg13g2_a22oi_1
XFILLER_78_642 VPWR VGND sg13g2_fill_1
X_17893_ _09026_ _09025_ _09000_ VPWR VGND sg13g2_nand2b_1
X_19632_ _10696_ net651 net241 VPWR VGND sg13g2_nand2_1
X_16844_ VGND VPWR _07984_ _07999_ _08000_ _07982_ sg13g2_a21oi_1
XFILLER_93_645 VPWR VGND sg13g2_fill_2
XFILLER_77_196 VPWR VGND sg13g2_decap_4
XFILLER_92_133 VPWR VGND sg13g2_decap_4
X_19563_ _10627_ _10605_ _10607_ VPWR VGND sg13g2_xnor2_1
X_16775_ _07905_ net2069 _07930_ _07931_ VPWR VGND sg13g2_a21o_1
XFILLER_19_764 VPWR VGND sg13g2_decap_4
X_13987_ _05303_ _05297_ _05302_ VPWR VGND sg13g2_xnor2_1
XFILLER_46_561 VPWR VGND sg13g2_fill_2
X_18514_ _09622_ _09623_ _09624_ VPWR VGND sg13g2_nor2_1
XFILLER_80_317 VPWR VGND sg13g2_fill_2
X_15726_ _06964_ VPWR _06977_ VGND _06960_ _06962_ sg13g2_o21ai_1
X_19494_ _10556_ _10557_ _10558_ VPWR VGND sg13g2_nor2b_1
X_12938_ _04297_ _04285_ _04296_ VPWR VGND sg13g2_xnor2_1
X_18445_ _09555_ _09553_ _09552_ VPWR VGND sg13g2_nand2b_1
X_15657_ _06910_ net788 net832 VPWR VGND sg13g2_nand2_1
X_12869_ _04184_ VPWR _04230_ VGND _04144_ _04182_ sg13g2_o21ai_1
XFILLER_33_266 VPWR VGND sg13g2_decap_4
X_14608_ _05900_ net770 net849 VPWR VGND sg13g2_nand2_1
X_18376_ _09463_ _09485_ _09486_ VPWR VGND sg13g2_nor2_1
XFILLER_18_1042 VPWR VGND sg13g2_decap_8
X_15588_ _06843_ _06841_ _06842_ VPWR VGND sg13g2_nand2_1
X_17327_ _08483_ u_LMS.w\[0\]\[22\] net71 VPWR VGND sg13g2_nand2_1
X_14539_ _05833_ _05827_ _05831_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_984 VPWR VGND sg13g2_fill_2
X_17258_ _03356_ _08413_ _08414_ VPWR VGND sg13g2_nor2_1
X_16209_ _07446_ _07409_ _07412_ VPWR VGND sg13g2_nand2_1
X_17189_ VGND VPWR _08319_ _08341_ _08345_ _08318_ sg13g2_a21oi_1
XFILLER_52_0 VPWR VGND sg13g2_fill_2
XFILLER_115_533 VPWR VGND sg13g2_decap_8
XFILLER_115_577 VPWR VGND sg13g2_fill_2
XFILLER_25_1002 VPWR VGND sg13g2_fill_2
XFILLER_25_1024 VPWR VGND sg13g2_fill_2
XFILLER_130_569 VPWR VGND sg13g2_decap_8
XFILLER_124_28 VPWR VGND sg13g2_decap_8
X_22910_ VGND VPWR net554 _03208_ _00784_ _03183_ sg13g2_a21oi_1
XFILLER_97_995 VPWR VGND sg13g2_fill_2
XFILLER_29_517 VPWR VGND sg13g2_decap_4
XFILLER_29_528 VPWR VGND sg13g2_fill_1
XFILLER_96_494 VPWR VGND sg13g2_fill_2
XFILLER_56_336 VPWR VGND sg13g2_fill_2
X_22841_ net552 net475 _03140_ VPWR VGND sg13g2_nor2_1
XFILLER_72_829 VPWR VGND sg13g2_decap_8
XFILLER_37_561 VPWR VGND sg13g2_decap_4
XFILLER_71_328 VPWR VGND sg13g2_fill_2
XFILLER_25_723 VPWR VGND sg13g2_decap_4
X_22772_ u_debug_unit.mon_w4_sync\[2\] net340 _03104_ VPWR VGND sg13g2_nor2_1
X_21723_ net366 VPWR _02322_ VGND u_LMS.w\[7\]\[7\] net377 sg13g2_o21ai_1
XFILLER_80_862 VPWR VGND sg13g2_fill_2
XFILLER_40_737 VPWR VGND sg13g2_fill_2
XFILLER_12_428 VPWR VGND sg13g2_fill_2
X_21654_ net13 VPWR _02267_ VGND _02252_ _02266_ sg13g2_o21ai_1
XFILLER_24_288 VPWR VGND sg13g2_fill_2
XFILLER_33_47 VPWR VGND sg13g2_fill_1
XFILLER_24_299 VPWR VGND sg13g2_fill_2
X_20605_ _01153_ _01151_ _01245_ VPWR VGND sg13g2_xor2_1
XFILLER_32_1006 VPWR VGND sg13g2_fill_2
XFILLER_130_7 VPWR VGND sg13g2_decap_8
X_21585_ _02202_ u_LMS.w\[7\]\[7\] _02180_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_1039 VPWR VGND sg13g2_fill_2
X_23324_ net1277 VGND VPWR _00386_ u_LMS.w\[4\]\[3\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
X_20536_ VPWR _01176_ _01175_ VGND sg13g2_inv_1
X_23255_ net1383 VGND VPWR _00317_ u_LMS.w\[1\]\[3\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
X_20467_ VGND VPWR u_LMS.w\[5\]\[24\] net319 _01118_ _01094_ sg13g2_a21oi_1
XFILLER_4_638 VPWR VGND sg13g2_fill_2
X_22206_ _02799_ VPWR _02800_ VGND _03293_ _02777_ sg13g2_o21ai_1
XFILLER_3_126 VPWR VGND sg13g2_decap_8
X_23186_ net1505 VGND VPWR _00248_ u_FIR.w\[4\]\[3\] clknet_leaf_36_clkA sg13g2_dfrbpq_1
XFILLER_3_148 VPWR VGND sg13g2_decap_8
X_20398_ VPWR _01061_ _01060_ VGND sg13g2_inv_1
X_22137_ VGND VPWR _02723_ _02724_ _02731_ _02730_ sg13g2_a21oi_1
X_22997__1211 VPWR VGND net1210 sg13g2_tiehi
XFILLER_0_844 VPWR VGND sg13g2_decap_8
X_22068_ _02659_ _02660_ net2169 _02662_ VPWR VGND sg13g2_nand3_1
XFILLER_88_973 VPWR VGND sg13g2_fill_2
XFILLER_59_152 VPWR VGND sg13g2_decap_8
XFILLER_47_303 VPWR VGND sg13g2_decap_4
X_21019_ _01659_ _03308_ _01653_ _01560_ VPWR VGND sg13g2_and3_2
X_13910_ VGND VPWR _05087_ _05187_ _05231_ _05219_ sg13g2_a21oi_1
X_14890_ _06173_ _06151_ _06175_ VPWR VGND sg13g2_xor2_1
XFILLER_47_336 VPWR VGND sg13g2_fill_1
X_13841_ _05165_ net282 _05163_ VPWR VGND sg13g2_xnor2_1
XFILLER_74_32 VPWR VGND sg13g2_fill_1
XFILLER_28_550 VPWR VGND sg13g2_decap_8
XFILLER_74_166 VPWR VGND sg13g2_fill_2
XFILLER_28_561 VPWR VGND sg13g2_fill_2
X_16560_ net982 VPWR _07762_ VGND net489 net779 sg13g2_o21ai_1
X_13772_ _05097_ net282 _05098_ VPWR VGND sg13g2_xor2_1
XFILLER_62_339 VPWR VGND sg13g2_decap_8
XFILLER_28_594 VPWR VGND sg13g2_fill_1
XFILLER_16_745 VPWR VGND sg13g2_decap_4
X_15511_ _06752_ VPWR _06769_ VGND _06753_ _06754_ sg13g2_o21ai_1
XFILLER_128_1012 VPWR VGND sg13g2_decap_8
X_12723_ net1037 VPWR _04088_ VGND net541 u_FIR.sum\[1\]\[6\] sg13g2_o21ai_1
X_16491_ u_LMS.w\[0\]\[20\] u_LMS.w\[0\]\[19\] u_LMS.w\[0\]\[18\] _07710_ VPWR VGND
+ sg13g2_nor3_1
XFILLER_71_873 VPWR VGND sg13g2_fill_2
XFILLER_15_255 VPWR VGND sg13g2_decap_4
X_18230_ _09332_ _09331_ _09340_ VPWR VGND sg13g2_xor2_1
X_15442_ _06687_ _06689_ _06705_ VPWR VGND sg13g2_nor2b_1
X_12654_ _03991_ _04019_ _04020_ VPWR VGND sg13g2_nor2_1
XFILLER_70_383 VPWR VGND sg13g2_fill_2
X_18161_ _09271_ net676 net106 VPWR VGND sg13g2_nand2_2
X_15373_ _06615_ VPWR _06639_ VGND net250 _06617_ sg13g2_o21ai_1
X_12585_ VPWR _03954_ _03953_ VGND sg13g2_inv_1
X_17112_ _08197_ _08266_ _08267_ _08268_ VPWR VGND sg13g2_nor3_1
XFILLER_11_472 VPWR VGND sg13g2_decap_8
X_14324_ _05600_ _05629_ _05630_ VPWR VGND sg13g2_nor2b_1
XFILLER_128_135 VPWR VGND sg13g2_fill_1
X_18092_ _09183_ VPWR _09202_ VGND _09180_ _09181_ sg13g2_o21ai_1
XFILLER_116_308 VPWR VGND sg13g2_fill_2
X_17043_ net417 net126 net125 _08199_ VGND VPWR net123 sg13g2_nor4_2
X_14255_ net929 _05562_ _00128_ VPWR VGND sg13g2_nor2_1
X_13206_ net1034 VPWR _04554_ VGND net533 u_FIR.sum\[2\]\[7\] sg13g2_o21ai_1
XFILLER_99_84 VPWR VGND sg13g2_fill_1
X_14186_ _05495_ _05489_ _05493_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_864 VPWR VGND sg13g2_decap_8
XFILLER_98_704 VPWR VGND sg13g2_decap_8
XFILLER_124_341 VPWR VGND sg13g2_fill_1
X_13137_ _04486_ _04444_ _04485_ VPWR VGND sg13g2_xnor2_1
X_18994_ _10079_ _10080_ _10081_ VPWR VGND sg13g2_nor2_1
XFILLER_98_759 VPWR VGND sg13g2_fill_2
XFILLER_97_247 VPWR VGND sg13g2_fill_2
X_17945_ VGND VPWR _09069_ _09070_ _09078_ _09077_ sg13g2_a21oi_1
X_13068_ _04417_ _04399_ _04419_ VPWR VGND sg13g2_xor2_1
X_23433__1050 VPWR VGND net1049 sg13g2_tiehi
X_12019_ _03399_ net326 _03436_ VPWR VGND sg13g2_nor2_1
X_17876_ u_LMS.w\[1\]\[2\] net259 net701 _09009_ VPWR VGND sg13g2_nand3_1
XFILLER_38_336 VPWR VGND sg13g2_decap_8
XFILLER_65_122 VPWR VGND sg13g2_fill_2
X_19615_ _10675_ _10677_ _10653_ _10679_ VPWR VGND sg13g2_nand3_1
XFILLER_38_347 VPWR VGND sg13g2_fill_1
X_16827_ _07981_ _07964_ _07983_ VPWR VGND sg13g2_xor2_1
X_23510__1377 VPWR VGND net1376 sg13g2_tiehi
Xclkbuf_leaf_12_clkA clknet_4_10_0_clkA clknet_leaf_12_clkA VPWR VGND sg13g2_buf_8
XFILLER_65_166 VPWR VGND sg13g2_decap_8
XFILLER_111_1060 VPWR VGND sg13g2_fill_1
XFILLER_80_103 VPWR VGND sg13g2_decap_8
XFILLER_47_881 VPWR VGND sg13g2_decap_4
X_19546_ _10608_ _10609_ _10610_ VPWR VGND sg13g2_nor2_1
XFILLER_65_188 VPWR VGND sg13g2_decap_8
X_16758_ net913 _07913_ _07914_ VPWR VGND sg13g2_and2_1
XFILLER_81_648 VPWR VGND sg13g2_decap_4
XFILLER_0_1048 VPWR VGND sg13g2_decap_8
XFILLER_0_84 VPWR VGND sg13g2_decap_8
XFILLER_0_1059 VPWR VGND sg13g2_fill_2
X_15709_ _06961_ u_FIR.sum\[6\]\[8\] net392 VPWR VGND sg13g2_nand2_1
XFILLER_62_862 VPWR VGND sg13g2_decap_8
X_19477_ net131 net648 _10539_ _10541_ VPWR VGND sg13g2_a21o_1
XFILLER_94_1055 VPWR VGND sg13g2_decap_4
X_16689_ VGND VPWR net521 _07856_ _00267_ _07857_ sg13g2_a21oi_1
XFILLER_21_203 VPWR VGND sg13g2_fill_2
X_18428_ VPWR _09538_ _09537_ VGND sg13g2_inv_1
XFILLER_22_759 VPWR VGND sg13g2_fill_1
X_18359_ _09462_ net2108 _09469_ VPWR VGND sg13g2_nor2_1
X_21370_ _01987_ _01982_ _01985_ VPWR VGND sg13g2_xnor2_1
XFILLER_107_308 VPWR VGND sg13g2_decap_8
X_20321_ _00984_ u_LMS.w\[5\]\[13\] net2130 VPWR VGND sg13g2_nand2_1
X_23040_ net1146 VGND VPWR _00102_ u_FIR.sum\[3\]\[2\] clknet_leaf_35_clkA sg13g2_dfrbpq_1
X_20252_ _03241_ net230 net198 _00911_ _00915_ VPWR VGND sg13g2_nor4_1
XFILLER_116_853 VPWR VGND sg13g2_fill_2
XFILLER_89_715 VPWR VGND sg13g2_fill_2
XFILLER_89_726 VPWR VGND sg13g2_decap_4
XFILLER_88_203 VPWR VGND sg13g2_decap_8
XFILLER_130_300 VPWR VGND sg13g2_decap_8
X_20183_ _00846_ _00840_ _00844_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_1040 VPWR VGND sg13g2_decap_8
XFILLER_103_569 VPWR VGND sg13g2_fill_1
X_23174__1527 VPWR VGND net1526 sg13g2_tiehi
X_23202__1478 VPWR VGND net1477 sg13g2_tiehi
XFILLER_57_623 VPWR VGND sg13g2_fill_2
XFILLER_97_792 VPWR VGND sg13g2_fill_2
XFILLER_85_943 VPWR VGND sg13g2_decap_8
X_22824_ u_debug_unit.mon_w8_sync\[0\] net338 _03130_ VPWR VGND sg13g2_nor2_1
XFILLER_72_637 VPWR VGND sg13g2_fill_2
XFILLER_44_339 VPWR VGND sg13g2_fill_2
XFILLER_53_840 VPWR VGND sg13g2_fill_2
X_22755_ VGND VPWR _07775_ net336 _00717_ _03095_ sg13g2_a21oi_1
XFILLER_52_361 VPWR VGND sg13g2_decap_4
X_21706_ VGND VPWR net49 _02308_ _02309_ net10 sg13g2_a21oi_1
X_22686_ coeff_force_packed\[52\] net467 _03068_ _00675_ VPWR VGND sg13g2_mux2_1
XFILLER_13_748 VPWR VGND sg13g2_fill_2
X_21637_ _02254_ net312 u_LMS.w\[7\]\[12\] coeff_force_packed\[49\] net563 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_12_269 VPWR VGND sg13g2_decap_8
XFILLER_60_45 VPWR VGND sg13g2_fill_1
X_12370_ VGND VPWR _03747_ _03748_ _03749_ net414 sg13g2_a21oi_1
X_21568_ _02095_ _02063_ _02185_ VPWR VGND sg13g2_xor2_1
XFILLER_5_903 VPWR VGND sg13g2_fill_1
XFILLER_126_606 VPWR VGND sg13g2_fill_2
XFILLER_126_617 VPWR VGND sg13g2_fill_1
X_23307_ net1294 VGND VPWR _00369_ u_LMS.w\[3\]\[9\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
XFILLER_5_914 VPWR VGND sg13g2_fill_1
X_20519_ _01159_ _01155_ _01158_ VPWR VGND sg13g2_nand2_1
X_21499_ _02116_ _02113_ _02114_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_127 VPWR VGND sg13g2_fill_1
XFILLER_4_424 VPWR VGND sg13g2_decap_8
X_14040_ _05330_ _05332_ _05353_ VPWR VGND sg13g2_and2_1
XFILLER_107_853 VPWR VGND sg13g2_decap_8
X_23238_ net1413 VGND VPWR _00300_ u_LMS.w\[0\]\[9\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
XFILLER_4_446 VPWR VGND sg13g2_fill_2
XFILLER_118_190 VPWR VGND sg13g2_decap_4
XFILLER_69_21 VPWR VGND sg13g2_decap_8
XFILLER_79_214 VPWR VGND sg13g2_decap_4
X_23169_ net1534 VGND VPWR _00231_ u_FIR.w\[2\]\[0\] clknet_leaf_51_clkA sg13g2_dfrbpq_1
XFILLER_69_65 VPWR VGND sg13g2_decap_8
XFILLER_69_76 VPWR VGND sg13g2_fill_2
XFILLER_79_236 VPWR VGND sg13g2_fill_2
XFILLER_121_355 VPWR VGND sg13g2_fill_1
X_15991_ net858 u_FIR.sum\[7\]\[3\] net801 _07232_ VPWR VGND sg13g2_nand3_1
XFILLER_122_889 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_35_clkA clknet_4_13_0_clkA clknet_leaf_35_clkA VPWR VGND sg13g2_buf_8
X_17730_ _08861_ _08862_ _08863_ VPWR VGND sg13g2_nor2_1
X_14942_ _06223_ VPWR _06224_ VGND _06022_ _06054_ sg13g2_o21ai_1
XFILLER_88_792 VPWR VGND sg13g2_fill_2
XFILLER_0_696 VPWR VGND sg13g2_decap_8
XFILLER_87_280 VPWR VGND sg13g2_fill_2
XFILLER_85_42 VPWR VGND sg13g2_decap_8
XFILLER_48_634 VPWR VGND sg13g2_fill_2
XFILLER_85_53 VPWR VGND sg13g2_fill_2
XFILLER_76_976 VPWR VGND sg13g2_fill_2
X_17661_ _08794_ _08772_ _08793_ VPWR VGND sg13g2_xnor2_1
XFILLER_75_453 VPWR VGND sg13g2_decap_8
X_14873_ net269 _06155_ _06158_ VPWR VGND sg13g2_and2_1
X_19400_ _10464_ _10461_ _10463_ VPWR VGND sg13g2_nand2_1
X_16612_ VGND VPWR net515 _07799_ _00247_ _07800_ sg13g2_a21oi_1
XFILLER_78_1039 VPWR VGND sg13g2_fill_1
XFILLER_75_486 VPWR VGND sg13g2_decap_4
X_13824_ net1035 VPWR _05149_ VGND net537 u_FIR.sum\[3\]\[11\] sg13g2_o21ai_1
XFILLER_47_188 VPWR VGND sg13g2_decap_4
X_23375__1224 VPWR VGND net1223 sg13g2_tiehi
X_17592_ _08720_ VPWR _08725_ VGND _08721_ _08724_ sg13g2_o21ai_1
XFILLER_91_968 VPWR VGND sg13g2_fill_1
XFILLER_62_136 VPWR VGND sg13g2_fill_2
X_19331_ net118 _10394_ _10395_ VPWR VGND sg13g2_nor2_1
X_16543_ u_LMS.w\[2\]\[19\] u_LMS.w\[2\]\[18\] u_LMS.w\[2\]\[20\] _07748_ VPWR VGND
+ sg13g2_nand3_1
XFILLER_44_862 VPWR VGND sg13g2_fill_1
X_13755_ VGND VPWR _05042_ _05072_ _05081_ _05071_ sg13g2_a21oi_1
XFILLER_31_501 VPWR VGND sg13g2_fill_2
X_19262_ net55 _10331_ _10213_ _10332_ VPWR VGND sg13g2_nand3_1
X_12706_ _04027_ _04029_ _04071_ VPWR VGND sg13g2_and2_1
X_16474_ _07698_ u_FIR.x\[3\] net525 VPWR VGND sg13g2_nand2_1
XFILLER_93_7 VPWR VGND sg13g2_fill_2
X_13686_ _05014_ net754 net809 VPWR VGND sg13g2_nand2_1
X_18213_ VGND VPWR _09319_ _09321_ _09323_ _09322_ sg13g2_a21oi_1
X_15425_ _06689_ _06688_ _06668_ VPWR VGND sg13g2_nand2b_1
X_19193_ _10177_ u_LMS.w\[3\]\[15\] _10277_ VPWR VGND sg13g2_xor2_1
X_12637_ _04004_ _04002_ _04003_ VPWR VGND sg13g2_nand2_1
XFILLER_12_781 VPWR VGND sg13g2_decap_8
X_18144_ _09254_ _09223_ _09252_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_741 VPWR VGND sg13g2_fill_1
X_15356_ _06623_ _06622_ _06588_ VPWR VGND sg13g2_nand2b_1
X_12568_ VGND VPWR net542 _03938_ _00064_ _03939_ sg13g2_a21oi_1
XFILLER_15_1056 VPWR VGND sg13g2_decap_4
X_23467__1529 VPWR VGND net1528 sg13g2_tiehi
XFILLER_117_617 VPWR VGND sg13g2_fill_1
X_14307_ _05613_ _05605_ _05612_ VPWR VGND sg13g2_nand2_1
XFILLER_102_1048 VPWR VGND sg13g2_decap_8
X_18075_ _09184_ _09178_ _09185_ VPWR VGND sg13g2_nor2b_1
XFILLER_102_1059 VPWR VGND sg13g2_fill_2
X_15287_ _06556_ _06552_ _06555_ VPWR VGND sg13g2_xnor2_1
X_12499_ _03872_ _03864_ _03874_ VPWR VGND sg13g2_xor2_1
XFILLER_116_138 VPWR VGND sg13g2_fill_2
X_17026_ _08182_ u_LMS.x_r\[0\]\[7\] net251 VPWR VGND sg13g2_nand2_1
X_14238_ VPWR _05546_ _05545_ VGND sg13g2_inv_1
X_23321__1281 VPWR VGND net1280 sg13g2_tiehi
X_14169_ _05445_ _05478_ _05479_ VPWR VGND sg13g2_nor2_1
Xfanout709 u_LMS.x_r\[0\]\[3\] net709 VPWR VGND sg13g2_buf_1
XFILLER_124_193 VPWR VGND sg13g2_fill_2
XFILLER_113_867 VPWR VGND sg13g2_fill_1
XFILLER_113_878 VPWR VGND sg13g2_decap_8
X_18977_ VGND VPWR _10062_ _10063_ _10064_ _10061_ sg13g2_a21oi_1
XFILLER_79_770 VPWR VGND sg13g2_fill_1
X_17928_ _08658_ _09060_ _08655_ _09061_ VPWR VGND sg13g2_nand3_1
XFILLER_39_634 VPWR VGND sg13g2_decap_4
XFILLER_15_0 VPWR VGND sg13g2_decap_4
XFILLER_39_667 VPWR VGND sg13g2_decap_8
XFILLER_27_807 VPWR VGND sg13g2_decap_4
X_17859_ _03349_ _08991_ _08992_ VPWR VGND sg13g2_nor2_1
XFILLER_94_773 VPWR VGND sg13g2_decap_8
XFILLER_94_784 VPWR VGND sg13g2_fill_2
XFILLER_26_317 VPWR VGND sg13g2_decap_8
X_20870_ _01510_ _01484_ _01509_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_18 VPWR VGND sg13g2_fill_2
XFILLER_82_968 VPWR VGND sg13g2_decap_4
X_19529_ VGND VPWR _10581_ net2205 _10593_ _10580_ sg13g2_a21oi_1
XFILLER_34_350 VPWR VGND sg13g2_fill_1
X_22540_ net952 VPWR _03026_ VGND u_LMS.count\[13\] _03024_ sg13g2_o21ai_1
XFILLER_50_854 VPWR VGND sg13g2_fill_2
XFILLER_22_567 VPWR VGND sg13g2_decap_8
XFILLER_10_718 VPWR VGND sg13g2_decap_8
X_22471_ net960 VPWR _02985_ VGND net448 net602 sg13g2_o21ai_1
XFILLER_50_898 VPWR VGND sg13g2_fill_2
X_21422_ _02039_ net604 net229 VPWR VGND sg13g2_nand2_1
XFILLER_108_617 VPWR VGND sg13g2_fill_2
XFILLER_108_639 VPWR VGND sg13g2_fill_1
X_21353_ VPWR _01970_ _01969_ VGND sg13g2_inv_1
X_20304_ _00967_ _00964_ _00966_ VPWR VGND sg13g2_xnor2_1
X_21284_ _01866_ _01864_ _01901_ VPWR VGND sg13g2_xor2_1
Xclkbuf_leaf_58_clkA clknet_4_1_0_clkA clknet_leaf_58_clkA VPWR VGND sg13g2_buf_8
X_23023_ net1171 VGND VPWR _00085_ u_FIR.sum\[2\]\[4\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
X_20235_ _00868_ _00897_ _00898_ VPWR VGND sg13g2_and2_1
XFILLER_115_160 VPWR VGND sg13g2_fill_1
XFILLER_1_438 VPWR VGND sg13g2_decap_8
XFILLER_104_856 VPWR VGND sg13g2_fill_2
XFILLER_39_13 VPWR VGND sg13g2_fill_2
XFILLER_115_193 VPWR VGND sg13g2_decap_8
X_20166_ _00827_ net2121 _00829_ VPWR VGND sg13g2_xor2_1
XFILLER_104_889 VPWR VGND sg13g2_decap_4
X_20097_ _11137_ VPWR _11138_ VGND _11133_ _11134_ sg13g2_o21ai_1
XFILLER_130_196 VPWR VGND sg13g2_decap_8
XFILLER_69_291 VPWR VGND sg13g2_fill_1
XFILLER_29_133 VPWR VGND sg13g2_decap_8
XFILLER_29_144 VPWR VGND sg13g2_fill_1
XFILLER_84_261 VPWR VGND sg13g2_decap_8
XFILLER_73_935 VPWR VGND sg13g2_fill_1
XFILLER_29_177 VPWR VGND sg13g2_decap_8
XFILLER_29_188 VPWR VGND sg13g2_fill_2
X_11870_ VPWR _03291_ u_LMS.w\[8\]\[10\] VGND sg13g2_inv_1
XFILLER_17_339 VPWR VGND sg13g2_decap_8
XFILLER_29_199 VPWR VGND sg13g2_fill_1
XFILLER_55_67 VPWR VGND sg13g2_decap_8
XFILLER_44_136 VPWR VGND sg13g2_fill_1
XFILLER_55_89 VPWR VGND sg13g2_fill_2
X_22807_ VGND VPWR _07844_ net350 _00743_ _03121_ sg13g2_a21oi_1
XFILLER_44_169 VPWR VGND sg13g2_fill_2
XFILLER_38_1012 VPWR VGND sg13g2_fill_1
XFILLER_111_40 VPWR VGND sg13g2_decap_4
X_20999_ VGND VPWR _01638_ _01639_ _01637_ _01566_ sg13g2_a21oi_2
X_13540_ net853 net756 u_FIR.sum\[2\]\[4\] _04872_ VPWR VGND sg13g2_a21o_1
X_22738_ u_debug_unit.mon_w1_sync\[6\] net331 _03087_ VPWR VGND sg13g2_nor2_1
X_23363__1239 VPWR VGND net1238 sg13g2_tiehi
XFILLER_40_320 VPWR VGND sg13g2_decap_8
XFILLER_125_1037 VPWR VGND sg13g2_decap_8
X_13471_ VGND VPWR net414 _03381_ _00097_ _04809_ sg13g2_a21oi_1
X_22669_ coeff_force_packed\[39\] net465 _03066_ _00660_ VPWR VGND sg13g2_mux2_1
XFILLER_41_887 VPWR VGND sg13g2_decap_8
X_15210_ _06481_ _06473_ _06480_ VPWR VGND sg13g2_xnor2_1
X_12422_ _03797_ _03798_ _03799_ VPWR VGND sg13g2_and2_1
X_16190_ _07428_ u_FIR.sum\[7\]\[8\] net386 VPWR VGND sg13g2_xnor2_1
X_15141_ _06398_ VPWR _06413_ VGND _06392_ _06396_ sg13g2_o21ai_1
X_12353_ _03732_ net726 net827 VPWR VGND sg13g2_nand2_1
XFILLER_127_959 VPWR VGND sg13g2_fill_2
XFILLER_4_210 VPWR VGND sg13g2_decap_8
X_15072_ _06346_ net780 net859 VPWR VGND sg13g2_nand2_1
X_12284_ _03665_ _03664_ _03631_ VPWR VGND sg13g2_nand2b_1
X_18900_ _09985_ VPWR _09987_ VGND _03255_ net177 sg13g2_o21ai_1
X_14023_ _05335_ _05336_ _05337_ VPWR VGND sg13g2_nor2b_1
XFILLER_106_160 VPWR VGND sg13g2_decap_8
X_19880_ VGND VPWR net54 _10924_ _10925_ net24 sg13g2_a21oi_1
XFILLER_45_1016 VPWR VGND sg13g2_decap_8
X_18831_ _09882_ _09880_ _09918_ VPWR VGND sg13g2_xor2_1
XFILLER_1_961 VPWR VGND sg13g2_decap_8
X_18762_ _09849_ net656 net165 VPWR VGND sg13g2_nand2_1
X_15974_ _07217_ _07202_ _07216_ VPWR VGND sg13g2_xnor2_1
X_17713_ _08846_ _08844_ _08845_ VPWR VGND sg13g2_xnor2_1
X_14925_ _06158_ _06188_ _06206_ _06208_ VPWR VGND sg13g2_or3_1
X_18693_ _09780_ _09773_ _09778_ VPWR VGND sg13g2_xnor2_1
XFILLER_75_250 VPWR VGND sg13g2_fill_1
XFILLER_49_987 VPWR VGND sg13g2_fill_2
X_17644_ net205 _08776_ net689 _08777_ VPWR VGND sg13g2_nand3_1
XFILLER_91_732 VPWR VGND sg13g2_decap_8
X_14856_ _06121_ _06141_ _06142_ VPWR VGND sg13g2_nor2b_1
XFILLER_91_765 VPWR VGND sg13g2_decap_8
X_13807_ _05131_ net282 _05132_ VPWR VGND sg13g2_xor2_1
XFILLER_63_467 VPWR VGND sg13g2_decap_4
X_17575_ _08708_ _08706_ _08707_ VPWR VGND sg13g2_nand2_1
XFILLER_23_309 VPWR VGND sg13g2_decap_8
X_14787_ _06067_ _06074_ _06075_ VPWR VGND sg13g2_nor2b_1
XFILLER_16_350 VPWR VGND sg13g2_fill_1
X_11999_ net327 _03415_ _03416_ VPWR VGND sg13g2_nor2_1
X_19314_ net114 _10376_ net641 _10378_ VPWR VGND sg13g2_nand3_1
X_16526_ VGND VPWR u_LMS.w\[1\]\[13\] _07733_ _07737_ _07734_ sg13g2_a21oi_1
X_13738_ _05065_ u_FIR.sum\[2\]\[9\] net404 VPWR VGND sg13g2_xnor2_1
X_23339__1263 VPWR VGND net1262 sg13g2_tiehi
X_19245_ _10319_ net371 _10265_ VPWR VGND sg13g2_nand2b_1
X_16457_ _07685_ u_FIR.sum\[7\]\[18\] _07668_ VPWR VGND sg13g2_xnor2_1
X_13669_ _04961_ _04997_ _04998_ VPWR VGND sg13g2_nor2b_1
XFILLER_31_375 VPWR VGND sg13g2_decap_8
X_15408_ _06646_ _06672_ _06673_ VPWR VGND sg13g2_nor2b_1
X_19176_ net67 _10258_ net717 _10263_ VPWR VGND _10259_ sg13g2_nand4_1
X_16388_ _07620_ _07611_ _07618_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_252 VPWR VGND sg13g2_decap_8
XFILLER_118_926 VPWR VGND sg13g2_fill_1
X_18127_ _09235_ _09223_ _09237_ VPWR VGND sg13g2_xor2_1
X_15339_ VGND VPWR _06573_ _06584_ _06606_ _06593_ sg13g2_a21oi_1
XFILLER_8_593 VPWR VGND sg13g2_decap_8
X_18058_ _09170_ net57 _09169_ VPWR VGND sg13g2_nand2_1
X_17009_ _08164_ VPWR _08165_ VGND _08131_ _08163_ sg13g2_o21ai_1
XFILLER_132_439 VPWR VGND sg13g2_decap_8
Xfanout506 net508 net506 VPWR VGND sg13g2_buf_1
X_20020_ _11061_ net197 net622 net229 net625 VPWR VGND sg13g2_a22oi_1
XFILLER_113_653 VPWR VGND sg13g2_decap_8
Xfanout517 net523 net517 VPWR VGND sg13g2_buf_1
Xfanout528 net530 net528 VPWR VGND sg13g2_buf_1
Xfanout539 net548 net539 VPWR VGND sg13g2_buf_1
XFILLER_100_303 VPWR VGND sg13g2_fill_1
XFILLER_113_697 VPWR VGND sg13g2_decap_8
XFILLER_100_325 VPWR VGND sg13g2_fill_1
XFILLER_6_1032 VPWR VGND sg13g2_decap_8
XFILLER_100_347 VPWR VGND sg13g2_decap_4
X_23257__1380 VPWR VGND net1379 sg13g2_tiehi
X_21971_ _02565_ net583 net130 VPWR VGND sg13g2_nand2_1
XFILLER_132_28 VPWR VGND sg13g2_decap_8
XFILLER_54_412 VPWR VGND sg13g2_fill_1
X_20922_ _01235_ _01237_ _01562_ VPWR VGND sg13g2_nor2_1
X_23710_ net1449 VGND VPWR _00772_ u_FIR.i_enable clknet_leaf_27_clkA sg13g2_dfrbpq_1
XFILLER_81_220 VPWR VGND sg13g2_decap_8
X_20853_ VGND VPWR _01491_ _01492_ _01493_ _01490_ sg13g2_a21oi_1
X_23641_ net974 VGND VPWR _00703_ u_debug_unit.mon_w1_sync\[0\] clknet_leaf_49_clkA
+ sg13g2_dfrbpq_1
XFILLER_70_927 VPWR VGND sg13g2_decap_8
XFILLER_25_37 VPWR VGND sg13g2_fill_1
X_23572_ net981 VGND VPWR _00634_ coeff_force_packed\[16\] clknet_leaf_53_clkA sg13g2_dfrbpq_1
XFILLER_23_843 VPWR VGND sg13g2_fill_2
X_20784_ _01424_ _01418_ _01417_ VPWR VGND sg13g2_nand2b_1
X_22523_ _03015_ u_LMS.count\[7\] _03014_ VPWR VGND sg13g2_xnor2_1
XFILLER_10_504 VPWR VGND sg13g2_decap_4
XFILLER_10_515 VPWR VGND sg13g2_decap_4
XFILLER_23_898 VPWR VGND sg13g2_fill_2
X_22454_ VGND VPWR net450 _03242_ _00535_ _02976_ sg13g2_a21oi_1
X_21405_ _02022_ net602 net191 VPWR VGND sg13g2_nand2_1
X_22385_ net962 VPWR _02942_ VGND net452 u_LMS.x_r\[1\]\[6\] sg13g2_o21ai_1
X_23005__1199 VPWR VGND net1198 sg13g2_tiehi
X_21336_ _01938_ _01952_ _01953_ VPWR VGND sg13g2_nor2b_1
XFILLER_123_406 VPWR VGND sg13g2_decap_8
X_21267_ net116 _01883_ _01884_ VPWR VGND sg13g2_nor2b_1
XFILLER_89_320 VPWR VGND sg13g2_decap_8
XFILLER_132_940 VPWR VGND sg13g2_decap_8
XFILLER_89_331 VPWR VGND sg13g2_decap_4
X_23006_ net1197 VGND VPWR _00068_ u_FIR.sum\[1\]\[3\] clknet_leaf_28_clkA sg13g2_dfrbpq_1
X_20218_ _00879_ _00878_ _00881_ VPWR VGND sg13g2_xor2_1
XFILLER_1_246 VPWR VGND sg13g2_decap_8
X_21198_ _01813_ _01814_ _01815_ VPWR VGND sg13g2_and2_1
XFILLER_104_686 VPWR VGND sg13g2_decap_4
XFILLER_103_163 VPWR VGND sg13g2_fill_1
X_20149_ _03240_ net180 _11190_ VPWR VGND sg13g2_nor2_1
XFILLER_106_84 VPWR VGND sg13g2_fill_1
XFILLER_66_33 VPWR VGND sg13g2_decap_8
XFILLER_44_1060 VPWR VGND sg13g2_fill_1
X_23512__1369 VPWR VGND net1368 sg13g2_tiehi
XFILLER_131_1030 VPWR VGND sg13g2_decap_8
XFILLER_92_518 VPWR VGND sg13g2_fill_1
XFILLER_46_913 VPWR VGND sg13g2_fill_1
XFILLER_18_604 VPWR VGND sg13g2_fill_2
X_12971_ _04323_ _04328_ _04329_ VPWR VGND sg13g2_nor2b_1
XFILLER_85_581 VPWR VGND sg13g2_fill_2
XFILLER_46_935 VPWR VGND sg13g2_fill_2
XFILLER_17_103 VPWR VGND sg13g2_decap_8
X_14710_ _05999_ _05968_ _06000_ VPWR VGND sg13g2_xor2_1
X_11922_ VPWR _03343_ u_LMS.w\[1\]\[10\] VGND sg13g2_inv_1
X_15690_ _03373_ net875 _06942_ VPWR VGND sg13g2_nor2_1
XFILLER_72_220 VPWR VGND sg13g2_decap_8
XFILLER_18_659 VPWR VGND sg13g2_fill_1
XFILLER_17_125 VPWR VGND sg13g2_fill_2
X_14641_ _05932_ _05894_ _05896_ VPWR VGND sg13g2_nand2_1
XFILLER_61_927 VPWR VGND sg13g2_decap_4
X_11853_ VPWR _03274_ net700 VGND sg13g2_inv_1
XFILLER_45_489 VPWR VGND sg13g2_decap_8
X_17360_ VGND VPWR _08511_ _08512_ _00283_ net934 sg13g2_a21oi_1
X_14572_ _05865_ _05864_ _05860_ VPWR VGND sg13g2_nand2b_1
X_11784_ VPWR _03205_ u_s2p_input.reg_sh\[5\] VGND sg13g2_inv_1
X_16311_ _07516_ _07545_ _07546_ VPWR VGND sg13g2_and2_1
X_13523_ _04856_ _04835_ _04855_ VPWR VGND sg13g2_nand2_1
XFILLER_15_70 VPWR VGND sg13g2_decap_4
X_17291_ _08423_ u_LMS.w\[0\]\[7\] _08446_ _08447_ VPWR VGND sg13g2_a21o_1
XFILLER_41_695 VPWR VGND sg13g2_fill_2
XFILLER_15_92 VPWR VGND sg13g2_fill_1
X_19030_ _10117_ _10109_ _10113_ VPWR VGND sg13g2_xnor2_1
XFILLER_51_1020 VPWR VGND sg13g2_fill_2
X_16242_ net978 VPWR _07479_ VGND net476 u_FIR.sum\[8\]\[9\] sg13g2_o21ai_1
X_13454_ _04785_ _04793_ _04794_ VPWR VGND sg13g2_and2_1
X_12405_ _03783_ _03745_ _03748_ _03782_ VPWR VGND sg13g2_and3_1
X_16173_ _07409_ _07410_ _07411_ VPWR VGND sg13g2_and2_1
X_13385_ _04722_ _04727_ _04728_ VPWR VGND sg13g2_nor2b_1
XFILLER_12_1048 VPWR VGND sg13g2_decap_8
XFILLER_12_1059 VPWR VGND sg13g2_fill_2
X_15124_ _06396_ _06392_ _06397_ VPWR VGND sg13g2_xor2_1
X_12336_ _03696_ VPWR _03715_ VGND _03697_ _03702_ sg13g2_o21ai_1
XFILLER_127_778 VPWR VGND sg13g2_decap_4
XFILLER_56_7 VPWR VGND sg13g2_decap_4
X_19932_ _10972_ _10962_ _10973_ VPWR VGND sg13g2_xor2_1
X_15055_ _06330_ _06329_ _06309_ VPWR VGND sg13g2_nand2b_1
X_12267_ _03648_ net728 net844 VPWR VGND sg13g2_nand2_1
XFILLER_5_596 VPWR VGND sg13g2_fill_1
X_14006_ VGND VPWR net492 _05319_ _00121_ _05320_ sg13g2_a21oi_1
XFILLER_123_962 VPWR VGND sg13g2_decap_4
X_19863_ _10912_ _10774_ _10775_ VPWR VGND sg13g2_xnor2_1
X_12198_ u_LMS.count\[14\] u_LMS.count\[13\] u_LMS.count\[12\] u_LMS.count\[11\] _03586_
+ VPWR VGND sg13g2_nor4_1
X_18814_ net119 _09900_ _09901_ VPWR VGND sg13g2_nor2b_1
X_19794_ VGND VPWR _10856_ _10857_ _00372_ net930 sg13g2_a21oi_1
XFILLER_95_334 VPWR VGND sg13g2_fill_2
XFILLER_96_868 VPWR VGND sg13g2_fill_2
X_18745_ _09830_ VPWR _09832_ VGND net423 net80 sg13g2_o21ai_1
X_15957_ _07200_ VPWR _07201_ VGND net499 u_FIR.sum\[7\]\[16\] sg13g2_o21ai_1
XFILLER_95_389 VPWR VGND sg13g2_decap_4
XFILLER_37_924 VPWR VGND sg13g2_decap_4
XFILLER_37_946 VPWR VGND sg13g2_decap_8
X_14908_ _06192_ _06181_ _06191_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_592 VPWR VGND sg13g2_fill_2
XFILLER_36_423 VPWR VGND sg13g2_fill_2
X_18676_ _09762_ _09760_ _09759_ _09763_ VPWR VGND sg13g2_a21o_1
X_15888_ _07135_ _07102_ _07133_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_540 VPWR VGND sg13g2_fill_2
XFILLER_37_979 VPWR VGND sg13g2_decap_4
X_17627_ _08760_ _08758_ _08759_ VPWR VGND sg13g2_nand2_1
X_14839_ _03367_ net824 _06125_ VPWR VGND sg13g2_nor2_1
XFILLER_63_264 VPWR VGND sg13g2_fill_1
XFILLER_24_629 VPWR VGND sg13g2_decap_8
X_17558_ _08691_ net121 _08689_ VPWR VGND sg13g2_xnor2_1
XFILLER_108_1032 VPWR VGND sg13g2_decap_8
X_16509_ net979 VPWR _07724_ VGND net483 net795 sg13g2_o21ai_1
XFILLER_32_662 VPWR VGND sg13g2_fill_1
XFILLER_20_813 VPWR VGND sg13g2_decap_8
X_17489_ _08622_ net700 net147 VPWR VGND sg13g2_nand2_1
XFILLER_82_0 VPWR VGND sg13g2_decap_8
X_19228_ VGND VPWR u_LMS.w\[3\]\[21\] net305 _10306_ _10292_ sg13g2_a21oi_1
XFILLER_20_846 VPWR VGND sg13g2_decap_4
X_19159_ VGND VPWR _10170_ _10243_ _10246_ _10245_ sg13g2_a21oi_1
X_22170_ VGND VPWR _02707_ _02717_ _02764_ _02715_ sg13g2_a21oi_1
XFILLER_106_929 VPWR VGND sg13g2_decap_8
XFILLER_127_28 VPWR VGND sg13g2_decap_8
XFILLER_117_266 VPWR VGND sg13g2_decap_8
X_21121_ VGND VPWR _01657_ _01738_ _01739_ net14 sg13g2_a21oi_1
XFILLER_67_1060 VPWR VGND sg13g2_fill_1
X_21052_ _01686_ net317 u_LMS.w\[6\]\[18\] coeff_force_packed\[48\] net567 VPWR VGND
+ sg13g2_a22oi_1
Xfanout303 net306 net303 VPWR VGND sg13g2_buf_1
XFILLER_132_269 VPWR VGND sg13g2_decap_8
Xfanout314 net320 net314 VPWR VGND sg13g2_buf_1
Xfanout325 _03573_ net325 VPWR VGND sg13g2_buf_1
XFILLER_114_995 VPWR VGND sg13g2_fill_2
X_20003_ _10957_ _10948_ _11044_ VPWR VGND sg13g2_xor2_1
Xfanout336 net337 net336 VPWR VGND sg13g2_buf_1
Xfanout347 net352 net347 VPWR VGND sg13g2_buf_1
Xfanout358 net360 net358 VPWR VGND sg13g2_buf_1
Xfanout369 _08492_ net369 VPWR VGND sg13g2_buf_1
XFILLER_86_345 VPWR VGND sg13g2_decap_8
X_23405__1134 VPWR VGND net1133 sg13g2_tiehi
XFILLER_101_689 VPWR VGND sg13g2_decap_4
X_23016__1183 VPWR VGND net1182 sg13g2_tiehi
XFILLER_36_14 VPWR VGND sg13g2_fill_1
XFILLER_39_294 VPWR VGND sg13g2_fill_2
X_21954_ _02548_ _02540_ _02546_ VPWR VGND sg13g2_xnor2_1
XFILLER_28_979 VPWR VGND sg13g2_decap_4
XFILLER_27_445 VPWR VGND sg13g2_decap_8
X_20905_ _01232_ VPWR _01545_ VGND _01199_ _01233_ sg13g2_o21ai_1
X_21885_ net115 _02478_ _02479_ VPWR VGND sg13g2_nor2b_1
X_23444__1600 VPWR VGND net1599 sg13g2_tiehi
XFILLER_82_584 VPWR VGND sg13g2_fill_1
XFILLER_54_275 VPWR VGND sg13g2_decap_4
XFILLER_43_949 VPWR VGND sg13g2_decap_4
XFILLER_82_595 VPWR VGND sg13g2_decap_4
X_20836_ _01476_ net617 net261 VPWR VGND sg13g2_nand2_1
X_23624_ net956 VGND VPWR _00686_ coeff_force_packed\[62\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
XFILLER_74_1053 VPWR VGND sg13g2_decap_8
XFILLER_35_1015 VPWR VGND sg13g2_decap_4
X_20767_ _01407_ _01406_ _01403_ VPWR VGND sg13g2_nand2b_1
X_23555_ net1015 VGND VPWR _00617_ coeff_force_packed\[1\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
XFILLER_52_79 VPWR VGND sg13g2_decap_4
XFILLER_35_1059 VPWR VGND sg13g2_fill_2
X_22506_ net952 VPWR _03004_ VGND u_LMS.count\[1\] _03002_ sg13g2_o21ai_1
X_23486_ net1462 VGND VPWR _00548_ u_LMS.x_r\[7\]\[5\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
XFILLER_122_1029 VPWR VGND sg13g2_decap_8
X_20698_ _01337_ VPWR _01338_ VGND _01313_ _01335_ sg13g2_o21ai_1
X_22437_ net968 VPWR _02968_ VGND net443 net638 sg13g2_o21ai_1
XFILLER_6_327 VPWR VGND sg13g2_fill_1
XFILLER_109_767 VPWR VGND sg13g2_fill_2
X_13170_ _04504_ VPWR _04518_ VGND _04455_ _04494_ sg13g2_o21ai_1
X_22368_ VGND VPWR net455 _03285_ _00492_ _02933_ sg13g2_a21oi_1
XFILLER_124_704 VPWR VGND sg13g2_decap_4
X_12121_ _03532_ net292 coeff_force_packed\[16\] _03404_ u_debug_unit.mon_w7_sync\[2\]
+ VPWR VGND sg13g2_a22oi_1
X_21319_ net595 net249 net593 _01936_ VPWR VGND net266 sg13g2_nand4_1
X_22299_ _02884_ _02882_ _02883_ VPWR VGND sg13g2_xnor2_1
XFILLER_2_533 VPWR VGND sg13g2_decap_4
X_12052_ _03466_ u_spi_slave.tx_shift\[13\] _03392_ VPWR VGND sg13g2_nand2_1
XFILLER_77_21 VPWR VGND sg13g2_fill_2
XFILLER_81_1024 VPWR VGND sg13g2_fill_2
XFILLER_78_824 VPWR VGND sg13g2_fill_1
XFILLER_77_301 VPWR VGND sg13g2_decap_4
Xrebuffer2090 net2099 net2089 VPWR VGND sg13g2_buf_1
XFILLER_2_599 VPWR VGND sg13g2_fill_1
XFILLER_104_494 VPWR VGND sg13g2_fill_1
X_16860_ _08016_ _08004_ _08015_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_87 VPWR VGND sg13g2_decap_8
Xfanout870 net871 net870 VPWR VGND sg13g2_buf_1
XFILLER_93_805 VPWR VGND sg13g2_decap_8
X_15811_ _07060_ net784 net820 VPWR VGND sg13g2_nand2_1
Xfanout881 net882 net881 VPWR VGND sg13g2_buf_1
XFILLER_19_913 VPWR VGND sg13g2_decap_8
Xfanout892 net893 net892 VPWR VGND sg13g2_buf_1
X_16791_ VGND VPWR u_FIR.sum\[8\]\[11\] _07893_ _07947_ _07894_ sg13g2_a21oi_1
XFILLER_93_838 VPWR VGND sg13g2_fill_1
XFILLER_46_721 VPWR VGND sg13g2_decap_8
XFILLER_19_935 VPWR VGND sg13g2_decap_8
X_18530_ VGND VPWR _09637_ _09638_ _09640_ _09603_ sg13g2_a21oi_1
X_15742_ _06993_ _06949_ _06992_ VPWR VGND sg13g2_xnor2_1
XFILLER_92_348 VPWR VGND sg13g2_fill_1
X_12954_ VGND VPWR _04281_ _04309_ _04312_ _04308_ sg13g2_a21oi_1
XFILLER_93_42 VPWR VGND sg13g2_fill_2
XFILLER_46_743 VPWR VGND sg13g2_decap_4
XFILLER_45_220 VPWR VGND sg13g2_decap_8
XFILLER_34_905 VPWR VGND sg13g2_fill_1
XFILLER_93_64 VPWR VGND sg13g2_fill_1
X_18461_ VGND VPWR _09221_ _09256_ _09571_ _09255_ sg13g2_a21oi_1
X_11905_ VPWR _03326_ u_LMS.w\[4\]\[18\] VGND sg13g2_inv_1
X_15673_ _06926_ _06919_ _06925_ VPWR VGND sg13g2_xnor2_1
X_12885_ VGND VPWR _04202_ _04206_ _04246_ _04244_ sg13g2_a21oi_1
XFILLER_93_97 VPWR VGND sg13g2_fill_2
X_17412_ net364 VPWR _08555_ VGND u_LMS.w\[0\]\[2\] net382 sg13g2_o21ai_1
X_14624_ _05916_ _05907_ _05915_ VPWR VGND sg13g2_nand2_1
X_18392_ VGND VPWR _09502_ _09501_ _09500_ sg13g2_or2_1
X_11836_ VPWR _03257_ net664 VGND sg13g2_inv_1
X_17343_ net45 VPWR _08499_ VGND _08496_ net43 sg13g2_o21ai_1
X_14555_ _05849_ _05820_ _05847_ VPWR VGND sg13g2_xnor2_1
XFILLER_42_993 VPWR VGND sg13g2_decap_4
X_13506_ net865 net755 u_FIR.sum\[2\]\[3\] _04839_ VPWR VGND sg13g2_a21o_1
X_17274_ _08335_ _08429_ _08430_ VPWR VGND sg13g2_nor2_1
X_14486_ _05783_ _05782_ _05776_ VPWR VGND sg13g2_nand2b_1
X_19013_ _10071_ _10099_ _10100_ VPWR VGND sg13g2_and2_1
X_16225_ _07462_ _07445_ _07461_ VPWR VGND sg13g2_xnor2_1
X_13437_ _04778_ _04765_ _04776_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_531 VPWR VGND sg13g2_decap_8
X_16156_ _07364_ _07394_ _07395_ VPWR VGND sg13g2_and2_1
X_13368_ _04687_ VPWR _04711_ VGND _04643_ _04688_ sg13g2_o21ai_1
XFILLER_5_360 VPWR VGND sg13g2_fill_1
X_15107_ _06380_ _06379_ _06376_ VPWR VGND sg13g2_nand2b_1
XFILLER_6_894 VPWR VGND sg13g2_fill_1
X_12319_ _03699_ net728 net828 VPWR VGND sg13g2_nand2_1
XFILLER_114_225 VPWR VGND sg13g2_decap_8
X_16087_ _07314_ VPWR _07327_ VGND _07309_ _07312_ sg13g2_o21ai_1
X_13299_ VPWR _04644_ _04643_ VGND sg13g2_inv_1
X_19915_ _10956_ _10955_ _10950_ VPWR VGND sg13g2_nand2b_1
X_15038_ _06313_ net780 net874 VPWR VGND sg13g2_nand2_1
XFILLER_111_910 VPWR VGND sg13g2_decap_8
XFILLER_69_846 VPWR VGND sg13g2_decap_4
X_19846_ _10898_ _10846_ _10899_ VPWR VGND sg13g2_xor2_1
XFILLER_96_643 VPWR VGND sg13g2_fill_1
XFILLER_96_676 VPWR VGND sg13g2_fill_1
XFILLER_3_84 VPWR VGND sg13g2_decap_8
X_19777_ VPWR _10841_ _10840_ VGND sg13g2_inv_1
X_16989_ _08145_ _08144_ _08141_ VPWR VGND sg13g2_nand2b_1
XFILLER_83_326 VPWR VGND sg13g2_decap_8
XFILLER_49_592 VPWR VGND sg13g2_decap_8
XFILLER_3_1035 VPWR VGND sg13g2_decap_8
X_18728_ _09811_ VPWR _09815_ VGND _09812_ _09813_ sg13g2_o21ai_1
XFILLER_37_743 VPWR VGND sg13g2_fill_1
XFILLER_83_359 VPWR VGND sg13g2_fill_1
XFILLER_36_253 VPWR VGND sg13g2_fill_1
X_18659_ _09748_ _09749_ _00345_ VPWR VGND sg13g2_nor2_1
XFILLER_58_1059 VPWR VGND sg13g2_fill_2
X_21670_ _02280_ _02155_ _02279_ VPWR VGND sg13g2_xnor2_1
X_20621_ _01261_ _01193_ _01195_ VPWR VGND sg13g2_xnor2_1
XFILLER_51_278 VPWR VGND sg13g2_fill_1
X_23340_ net1261 VGND VPWR _00402_ u_LMS.w\[5\]\[19\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
X_20552_ _01170_ net117 _01167_ _01192_ VPWR VGND sg13g2_nand3_1
X_23271_ net1351 VGND VPWR _00333_ u_LMS.w\[2\]\[19\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
X_20483_ VGND VPWR net51 _01129_ _01130_ net19 sg13g2_a21oi_1
X_22222_ _02766_ VPWR _02816_ VGND _02814_ _02815_ sg13g2_o21ai_1
XFILLER_118_575 VPWR VGND sg13g2_fill_2
X_22153_ _02743_ VPWR _02747_ VGND _02411_ _02746_ sg13g2_o21ai_1
X_21104_ _01726_ _01609_ _01610_ VPWR VGND sg13g2_xnor2_1
X_22084_ _02678_ net586 net240 VPWR VGND sg13g2_nand2_1
Xfanout100 net100 net104 VPWR VGND sg13g2_buf_4
XFILLER_87_610 VPWR VGND sg13g2_decap_4
Xfanout111 net1646 net111 VPWR VGND sg13g2_buf_2
XFILLER_102_932 VPWR VGND sg13g2_decap_8
Xfanout122 _08019_ net122 VPWR VGND sg13g2_buf_1
X_21035_ _01672_ _01632_ _01671_ VPWR VGND sg13g2_xnor2_1
Xfanout133 net137 net133 VPWR VGND sg13g2_buf_2
Xfanout144 net146 net144 VPWR VGND sg13g2_buf_1
XFILLER_59_334 VPWR VGND sg13g2_decap_4
XFILLER_101_442 VPWR VGND sg13g2_decap_8
Xfanout155 net156 net155 VPWR VGND sg13g2_buf_1
Xfanout166 net175 net166 VPWR VGND sg13g2_buf_1
XFILLER_102_987 VPWR VGND sg13g2_decap_4
Xfanout177 net178 net177 VPWR VGND sg13g2_buf_1
XFILLER_59_367 VPWR VGND sg13g2_decap_8
XFILLER_47_507 VPWR VGND sg13g2_decap_8
Xfanout188 net194 net188 VPWR VGND sg13g2_buf_1
X_23298__1304 VPWR VGND net1303 sg13g2_tiehi
Xfanout199 _08102_ net199 VPWR VGND sg13g2_buf_1
XFILLER_90_808 VPWR VGND sg13g2_fill_2
XFILLER_74_359 VPWR VGND sg13g2_fill_2
X_22986_ net1227 VGND VPWR _00048_ u_LMS.mu\[2\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
XFILLER_27_242 VPWR VGND sg13g2_decap_8
XFILLER_27_253 VPWR VGND sg13g2_fill_1
X_21937_ _02531_ net257 net575 net242 net577 VPWR VGND sg13g2_a22oi_1
XFILLER_15_415 VPWR VGND sg13g2_fill_2
X_12670_ net842 u_FIR.sum\[0\]\[5\] net736 _04036_ VPWR VGND sg13g2_nand3_1
XFILLER_43_768 VPWR VGND sg13g2_decap_4
X_21868_ _02459_ _02461_ _02462_ VPWR VGND sg13g2_nor2_1
XFILLER_31_919 VPWR VGND sg13g2_fill_2
XFILLER_43_779 VPWR VGND sg13g2_fill_1
X_23607_ net1016 VGND VPWR _00669_ coeff_force_packed\[47\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
X_20819_ net210 _01458_ net617 _01459_ VPWR VGND sg13g2_nand3_1
X_21799_ _02389_ VPWR _02393_ VGND _02390_ _02391_ sg13g2_o21ai_1
X_14340_ _05645_ _05644_ _05638_ VPWR VGND sg13g2_nand2b_1
X_23538_ net1012 VGND VPWR _00600_ debug_load_bus\[0\] clknet_leaf_37_clkA sg13g2_dfrbpq_1
X_22986__1228 VPWR VGND net1227 sg13g2_tiehi
XFILLER_11_665 VPWR VGND sg13g2_decap_8
XFILLER_11_676 VPWR VGND sg13g2_fill_1
XFILLER_10_153 VPWR VGND sg13g2_fill_2
X_14271_ _05578_ _05572_ _05576_ VPWR VGND sg13g2_xnor2_1
X_23469_ net1521 VGND VPWR _00531_ u_LMS.x_r\[5\]\[4\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
XFILLER_11_698 VPWR VGND sg13g2_decap_8
X_16010_ net845 net802 u_FIR.sum\[7\]\[4\] _07251_ VPWR VGND sg13g2_a21o_1
X_13222_ _03362_ net409 _04529_ _04569_ VPWR VGND sg13g2_nor3_1
XFILLER_109_586 VPWR VGND sg13g2_decap_8
XFILLER_6_179 VPWR VGND sg13g2_fill_1
XFILLER_109_597 VPWR VGND sg13g2_fill_2
XFILLER_124_523 VPWR VGND sg13g2_fill_2
X_13153_ _04502_ _04501_ _04460_ VPWR VGND sg13g2_nand2b_1
X_12104_ VPWR VGND coeff_force_packed\[3\] _03515_ net290 coeff_force_packed\[45\]
+ _03516_ net291 sg13g2_a221oi_1
X_17961_ _08494_ _09092_ _09094_ VPWR VGND sg13g2_nor2_1
X_13084_ _04435_ _04413_ _04433_ VPWR VGND sg13g2_xnor2_1
XFILLER_3_897 VPWR VGND sg13g2_fill_1
XFILLER_105_792 VPWR VGND sg13g2_decap_8
X_19700_ _10711_ _10704_ _10764_ VPWR VGND sg13g2_xor2_1
X_16912_ _08068_ net2073 _07925_ VPWR VGND sg13g2_xnor2_1
X_12035_ net945 _03385_ _03451_ VPWR VGND sg13g2_nor2_1
XFILLER_111_239 VPWR VGND sg13g2_decap_8
X_17892_ _09025_ _03344_ _08999_ VPWR VGND sg13g2_nand2_1
XFILLER_104_291 VPWR VGND sg13g2_fill_1
X_23069__1103 VPWR VGND net1102 sg13g2_tiehi
XFILLER_77_153 VPWR VGND sg13g2_fill_2
X_19631_ _10675_ _10694_ _10695_ VPWR VGND sg13g2_nor2_1
X_16843_ _07999_ _07988_ _07997_ VPWR VGND sg13g2_xnor2_1
XFILLER_66_827 VPWR VGND sg13g2_decap_8
XFILLER_65_304 VPWR VGND sg13g2_fill_1
XFILLER_77_175 VPWR VGND sg13g2_decap_8
XFILLER_19_7 VPWR VGND sg13g2_decap_8
X_19562_ VGND VPWR _10626_ _10625_ _10624_ sg13g2_or2_1
X_16774_ VGND VPWR u_FIR.sum\[8\]\[10\] _07893_ _07930_ _07894_ sg13g2_a21oi_1
XFILLER_19_743 VPWR VGND sg13g2_decap_8
X_13986_ _05300_ _05293_ _05302_ VPWR VGND sg13g2_xor2_1
XFILLER_19_754 VPWR VGND sg13g2_fill_2
X_18513_ _09623_ _03340_ _09610_ VPWR VGND sg13g2_xnor2_1
X_15725_ _06967_ VPWR _06976_ VGND _06937_ _06968_ sg13g2_o21ai_1
XFILLER_18_253 VPWR VGND sg13g2_decap_4
X_19493_ _10524_ _10518_ _10557_ VPWR VGND sg13g2_xor2_1
X_12937_ _04296_ _04217_ _04294_ VPWR VGND sg13g2_xnor2_1
X_18444_ _09554_ _09552_ _09553_ VPWR VGND sg13g2_nand2b_1
X_15656_ _06909_ _06901_ _06908_ VPWR VGND sg13g2_xnor2_1
X_23136__1586 VPWR VGND net1585 sg13g2_tiehi
X_12868_ _04229_ _04212_ _04228_ VPWR VGND sg13g2_xnor2_1
XFILLER_33_245 VPWR VGND sg13g2_decap_8
XFILLER_61_565 VPWR VGND sg13g2_decap_8
XFILLER_18_1010 VPWR VGND sg13g2_fill_2
X_14607_ _05899_ net772 net836 VPWR VGND sg13g2_nand2_1
XFILLER_21_418 VPWR VGND sg13g2_fill_2
X_18375_ _09485_ net164 net682 net182 net680 VPWR VGND sg13g2_a22oi_1
X_11819_ VPWR _03240_ net631 VGND sg13g2_inv_1
X_15587_ net833 net792 u_FIR.sum\[6\]\[5\] _06842_ VPWR VGND sg13g2_a21o_1
XFILLER_61_598 VPWR VGND sg13g2_fill_1
X_12799_ _04160_ _04133_ _04162_ VPWR VGND sg13g2_xor2_1
XFILLER_30_930 VPWR VGND sg13g2_fill_1
X_17326_ _08482_ _08479_ _08481_ VPWR VGND sg13g2_nand2_1
X_14538_ _05832_ _05831_ _05827_ VPWR VGND sg13g2_nand2b_1
XFILLER_119_328 VPWR VGND sg13g2_fill_2
X_17257_ _08413_ _08354_ _08364_ VPWR VGND sg13g2_xnor2_1
X_14469_ _05767_ VPWR _05768_ VGND _05751_ _05753_ sg13g2_o21ai_1
X_16208_ _07413_ _07406_ _07421_ _07445_ VPWR VGND sg13g2_a21o_1
X_17188_ VPWR _08344_ _08343_ VGND sg13g2_inv_1
XFILLER_127_372 VPWR VGND sg13g2_decap_8
X_16139_ net817 _07377_ net800 _07378_ VPWR VGND sg13g2_nand3_1
XFILLER_89_919 VPWR VGND sg13g2_fill_1
XFILLER_102_206 VPWR VGND sg13g2_fill_2
XFILLER_69_621 VPWR VGND sg13g2_fill_1
XFILLER_64_1052 VPWR VGND sg13g2_decap_8
XFILLER_130_548 VPWR VGND sg13g2_decap_8
XFILLER_25_1036 VPWR VGND sg13g2_fill_1
X_19829_ net65 u_LMS.w\[4\]\[20\] _10885_ VPWR VGND sg13g2_xor2_1
X_23494__1434 VPWR VGND net1433 sg13g2_tiehi
XFILLER_84_613 VPWR VGND sg13g2_fill_1
XFILLER_68_164 VPWR VGND sg13g2_fill_2
XFILLER_111_784 VPWR VGND sg13g2_fill_2
XFILLER_96_484 VPWR VGND sg13g2_decap_8
XFILLER_110_272 VPWR VGND sg13g2_decap_8
X_23529__1306 VPWR VGND net1305 sg13g2_tiehi
X_22840_ u_p2s_output.reg_done net556 _03139_ VPWR VGND sg13g2_nor2b_1
XFILLER_72_808 VPWR VGND sg13g2_fill_1
XFILLER_71_307 VPWR VGND sg13g2_fill_1
X_22771_ VGND VPWR _07797_ net341 _00725_ _03103_ sg13g2_a21oi_1
X_23294__1310 VPWR VGND net1309 sg13g2_tiehi
XFILLER_80_841 VPWR VGND sg13g2_decap_8
X_21722_ VGND VPWR net49 _02320_ _02321_ net10 sg13g2_a21oi_1
XFILLER_24_256 VPWR VGND sg13g2_decap_4
XFILLER_40_716 VPWR VGND sg13g2_decap_8
X_21653_ _02226_ _02265_ _02266_ VPWR VGND sg13g2_nor2b_1
XFILLER_33_790 VPWR VGND sg13g2_decap_8
X_20604_ _01240_ VPWR _01244_ VGND _01241_ _01242_ sg13g2_o21ai_1
X_21584_ _02182_ VPWR _02201_ VGND _02198_ _02199_ sg13g2_o21ai_1
X_20535_ _01174_ _01164_ _01175_ VPWR VGND sg13g2_xor2_1
X_23323_ net1278 VGND VPWR _00385_ u_LMS.w\[4\]\[2\] clknet_leaf_1_clkA sg13g2_dfrbpq_1
XFILLER_123_7 VPWR VGND sg13g2_decap_8
XFILLER_119_840 VPWR VGND sg13g2_decap_8
X_20466_ _01116_ VPWR _01117_ VGND _01068_ _01069_ sg13g2_o21ai_1
X_23254_ net1385 VGND VPWR _00316_ u_LMS.w\[1\]\[2\] clknet_leaf_2_clkA sg13g2_dfrbpq_1
XFILLER_3_105 VPWR VGND sg13g2_decap_8
X_22205_ _02799_ _02797_ _02798_ VPWR VGND sg13g2_nand2b_1
X_23185_ net1506 VGND VPWR _00247_ u_FIR.w\[4\]\[2\] clknet_leaf_36_clkA sg13g2_dfrbpq_1
X_20397_ _01060_ _01058_ _01059_ VPWR VGND sg13g2_nand2_1
X_22136_ _02730_ _02726_ _02729_ VPWR VGND sg13g2_nand2_1
XFILLER_0_801 VPWR VGND sg13g2_fill_1
XFILLER_0_834 VPWR VGND sg13g2_fill_1
XFILLER_121_548 VPWR VGND sg13g2_decap_8
X_22067_ _02661_ _02635_ _02660_ VPWR VGND sg13g2_nand2_1
XFILLER_88_963 VPWR VGND sg13g2_fill_1
XFILLER_87_451 VPWR VGND sg13g2_fill_1
X_21018_ _08494_ _01656_ _01658_ VPWR VGND sg13g2_nor2_1
XFILLER_87_484 VPWR VGND sg13g2_fill_2
XFILLER_48_849 VPWR VGND sg13g2_fill_2
X_13840_ VPWR _05164_ _05163_ VGND sg13g2_inv_1
X_23247__1398 VPWR VGND net1397 sg13g2_tiehi
XFILLER_47_359 VPWR VGND sg13g2_fill_2
XFILLER_75_679 VPWR VGND sg13g2_decap_8
XFILLER_63_819 VPWR VGND sg13g2_decap_8
XFILLER_62_318 VPWR VGND sg13g2_decap_8
XFILLER_16_713 VPWR VGND sg13g2_decap_4
X_13771_ _05097_ _05088_ _05095_ VPWR VGND sg13g2_xnor2_1
XFILLER_74_189 VPWR VGND sg13g2_decap_8
XFILLER_55_381 VPWR VGND sg13g2_decap_4
XFILLER_16_735 VPWR VGND sg13g2_decap_4
X_15510_ _06768_ _06762_ _06767_ VPWR VGND sg13g2_xnor2_1
X_12722_ _04085_ _04052_ _04087_ VPWR VGND sg13g2_xor2_1
XFILLER_71_852 VPWR VGND sg13g2_decap_8
X_16490_ u_LMS.w\[0\]\[23\] u_LMS.w\[0\]\[22\] u_LMS.w\[0\]\[24\] _07709_ VPWR VGND
+ u_LMS.w\[0\]\[21\] sg13g2_nand4_1
XFILLER_71_885 VPWR VGND sg13g2_decap_8
X_15441_ _06699_ _06701_ _06704_ VPWR VGND sg13g2_nor2_1
X_12653_ _04019_ net730 net897 VPWR VGND sg13g2_nand2_1
XFILLER_30_226 VPWR VGND sg13g2_fill_2
X_18160_ _09270_ _09268_ _09269_ VPWR VGND sg13g2_xnor2_1
X_15372_ VGND VPWR _06607_ _06618_ _06638_ _06625_ sg13g2_a21oi_1
XFILLER_90_76 VPWR VGND sg13g2_decap_8
X_23132__1592 VPWR VGND net1591 sg13g2_tiehi
X_12584_ VGND VPWR _03953_ _03952_ _03944_ sg13g2_or2_1
XFILLER_30_259 VPWR VGND sg13g2_decap_4
XFILLER_8_923 VPWR VGND sg13g2_fill_1
X_17111_ _08256_ _08259_ _08267_ VPWR VGND sg13g2_and2_1
X_14323_ _05627_ _05601_ _05629_ VPWR VGND sg13g2_xor2_1
XFILLER_23_70 VPWR VGND sg13g2_decap_4
X_18091_ VPWR _09201_ _09200_ VGND sg13g2_inv_1
XFILLER_23_92 VPWR VGND sg13g2_fill_2
X_17042_ _08172_ VPWR _08198_ VGND _08167_ _08168_ sg13g2_o21ai_1
XFILLER_7_455 VPWR VGND sg13g2_decap_4
XFILLER_128_169 VPWR VGND sg13g2_decap_4
X_14254_ _05561_ VPWR _05562_ VGND net507 u_FIR.sum\[4\]\[9\] sg13g2_o21ai_1
XFILLER_109_361 VPWR VGND sg13g2_fill_2
X_13205_ _04551_ _04515_ _04553_ VPWR VGND sg13g2_xor2_1
X_14185_ _05494_ _05493_ _05489_ VPWR VGND sg13g2_nand2b_1
X_13136_ _04483_ _04480_ _04485_ VPWR VGND sg13g2_xor2_1
XFILLER_112_526 VPWR VGND sg13g2_fill_2
X_18993_ _10080_ _10049_ _10057_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_386 VPWR VGND sg13g2_decap_8
XFILLER_112_559 VPWR VGND sg13g2_fill_2
X_17944_ _09074_ _09076_ _09071_ _09077_ VPWR VGND sg13g2_nand3_1
X_13067_ VGND VPWR _04418_ _04416_ _04376_ sg13g2_or2_1
XFILLER_79_974 VPWR VGND sg13g2_decap_8
X_12018_ net326 _03433_ _03435_ VPWR VGND sg13g2_nor2_1
X_17875_ _09008_ u_LMS.w\[1\]\[3\] _09007_ VPWR VGND sg13g2_nand2_1
XFILLER_94_933 VPWR VGND sg13g2_decap_4
X_19614_ _10678_ _10653_ _10677_ VPWR VGND sg13g2_nand2_1
X_16826_ _07981_ _07964_ _07982_ VPWR VGND sg13g2_nor2b_1
XFILLER_54_808 VPWR VGND sg13g2_fill_2
XFILLER_93_465 VPWR VGND sg13g2_fill_1
X_19545_ _10576_ _10569_ _10609_ VPWR VGND sg13g2_xor2_1
X_16757_ VGND VPWR _07900_ _07902_ _07913_ net2068 sg13g2_a21oi_1
XFILLER_0_1027 VPWR VGND sg13g2_decap_8
X_13969_ _05287_ u_FIR.sum\[2\]\[18\] _05269_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_63 VPWR VGND sg13g2_decap_8
XFILLER_19_595 VPWR VGND sg13g2_decap_8
X_15708_ VPWR _06960_ _06959_ VGND sg13g2_inv_1
XFILLER_62_852 VPWR VGND sg13g2_fill_2
X_19476_ net131 _10539_ net648 _10540_ VPWR VGND sg13g2_nand3_1
X_16688_ net1026 VPWR _07857_ VGND net521 net735 sg13g2_o21ai_1
XFILLER_22_727 VPWR VGND sg13g2_fill_2
X_18427_ _09531_ _09536_ _09537_ VPWR VGND sg13g2_nor2_1
X_15639_ VGND VPWR _06852_ _06855_ _06893_ _06891_ sg13g2_a21oi_1
XFILLER_15_790 VPWR VGND sg13g2_decap_4
X_18358_ _09468_ _09463_ _09467_ VPWR VGND sg13g2_xnor2_1
X_17309_ VGND VPWR _08465_ _08408_ u_LMS.w\[0\]\[14\] sg13g2_or2_1
XFILLER_119_114 VPWR VGND sg13g2_fill_2
X_18289_ _09392_ _09398_ _09399_ VPWR VGND sg13g2_nor2b_1
XFILLER_30_793 VPWR VGND sg13g2_fill_1
X_20320_ _00983_ _00982_ _00944_ VPWR VGND sg13g2_xnor2_1
XFILLER_116_821 VPWR VGND sg13g2_fill_2
XFILLER_116_832 VPWR VGND sg13g2_fill_2
X_20251_ _00912_ _00874_ _00914_ VPWR VGND sg13g2_xor2_1
XFILLER_116_865 VPWR VGND sg13g2_fill_1
XFILLER_116_887 VPWR VGND sg13g2_decap_8
X_20182_ _00845_ _00844_ _00840_ VPWR VGND sg13g2_nand2b_1
XFILLER_0_119 VPWR VGND sg13g2_decap_8
XFILLER_88_237 VPWR VGND sg13g2_decap_8
XFILLER_130_323 VPWR VGND sg13g2_decap_8
XFILLER_85_900 VPWR VGND sg13g2_decap_8
XFILLER_130_389 VPWR VGND sg13g2_decap_4
XFILLER_85_933 VPWR VGND sg13g2_fill_2
XFILLER_28_37 VPWR VGND sg13g2_fill_1
XFILLER_28_48 VPWR VGND sg13g2_decap_4
XFILLER_72_616 VPWR VGND sg13g2_decap_8
X_22823_ VGND VPWR _03301_ net342 _00751_ _03129_ sg13g2_a21oi_1
XFILLER_84_498 VPWR VGND sg13g2_decap_8
XFILLER_72_649 VPWR VGND sg13g2_fill_2
X_22754_ u_debug_unit.mon_w3_sync\[0\] net336 _03095_ VPWR VGND sg13g2_nor2_1
XFILLER_52_351 VPWR VGND sg13g2_fill_1
XFILLER_25_576 VPWR VGND sg13g2_decap_8
X_21705_ _02308_ _02189_ _02191_ VPWR VGND sg13g2_xnor2_1
XFILLER_12_204 VPWR VGND sg13g2_fill_1
X_22685_ coeff_force_packed\[51\] net468 _03068_ _00674_ VPWR VGND sg13g2_mux2_1
X_21636_ net12 VPWR _02253_ VGND _02250_ net11 sg13g2_o21ai_1
XFILLER_21_782 VPWR VGND sg13g2_fill_2
X_21567_ _03300_ _02183_ _02184_ VPWR VGND sg13g2_nor2_1
XFILLER_20_281 VPWR VGND sg13g2_fill_2
X_23306_ net1295 VGND VPWR _00368_ u_LMS.w\[3\]\[8\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
X_20518_ _01157_ _01156_ _01158_ VPWR VGND sg13g2_xor2_1
X_21498_ _02113_ _02114_ _02115_ VPWR VGND sg13g2_nor2b_1
X_20449_ VGND VPWR _01102_ _01103_ _00403_ net940 sg13g2_a21oi_1
X_23237_ net1414 VGND VPWR _00299_ u_LMS.w\[0\]\[8\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
XFILLER_107_887 VPWR VGND sg13g2_decap_8
X_23168_ net1536 VGND VPWR _00230_ u_FIR.w\[1\]\[6\] clknet_leaf_49_clkA sg13g2_dfrbpq_1
X_22119_ _02713_ _02708_ _02712_ VPWR VGND sg13g2_xnor2_1
X_23099_ net1057 VGND VPWR _00161_ u_FIR.sum\[6\]\[4\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
X_15990_ VPWR _07231_ _07230_ VGND sg13g2_inv_1
XFILLER_0_664 VPWR VGND sg13g2_decap_4
XFILLER_76_911 VPWR VGND sg13g2_decap_8
X_14941_ net396 u_FIR.sum\[4\]\[16\] _06223_ VPWR VGND sg13g2_xor2_1
XFILLER_76_922 VPWR VGND sg13g2_fill_2
XFILLER_87_270 VPWR VGND sg13g2_fill_1
XFILLER_87_292 VPWR VGND sg13g2_decap_8
X_17660_ _08793_ _08790_ _08791_ VPWR VGND sg13g2_xnor2_1
X_14872_ _06091_ _06156_ _06157_ VPWR VGND sg13g2_nor2_1
XFILLER_78_1007 VPWR VGND sg13g2_decap_8
X_16611_ net1022 VPWR _07800_ VGND net515 net762 sg13g2_o21ai_1
X_13823_ _05146_ _05117_ _05148_ VPWR VGND sg13g2_xor2_1
X_17591_ _08722_ net121 _08724_ VPWR VGND sg13g2_xor2_1
XFILLER_28_370 VPWR VGND sg13g2_decap_8
XFILLER_56_690 VPWR VGND sg13g2_fill_2
XFILLER_90_446 VPWR VGND sg13g2_decap_8
X_19330_ _10362_ _10370_ _10394_ VPWR VGND sg13g2_nor2_1
X_16542_ VGND VPWR _03347_ net480 _00230_ _07747_ sg13g2_a21oi_1
X_13754_ _05074_ _05077_ _05080_ VPWR VGND sg13g2_nor2_1
XFILLER_43_340 VPWR VGND sg13g2_decap_8
XFILLER_71_660 VPWR VGND sg13g2_decap_8
X_19261_ _10331_ _10211_ _10212_ VPWR VGND sg13g2_nand2b_1
X_12705_ _04069_ _04031_ _04070_ VPWR VGND sg13g2_xor2_1
X_16473_ VGND VPWR _07696_ _07697_ _00211_ net938 sg13g2_a21oi_1
X_13685_ _05013_ _05005_ _05012_ VPWR VGND sg13g2_xnor2_1
XFILLER_70_170 VPWR VGND sg13g2_fill_1
XFILLER_31_535 VPWR VGND sg13g2_fill_1
X_18212_ _09322_ _09282_ _09289_ VPWR VGND sg13g2_xnor2_1
X_15424_ _06688_ net276 _06686_ VPWR VGND sg13g2_xnor2_1
X_19192_ VGND VPWR _10275_ _10276_ _00351_ net927 sg13g2_a21oi_1
X_12636_ net855 net736 u_FIR.sum\[0\]\[4\] _04003_ VPWR VGND sg13g2_a21o_1
XFILLER_31_568 VPWR VGND sg13g2_fill_1
XFILLER_15_1002 VPWR VGND sg13g2_decap_8
XFILLER_86_7 VPWR VGND sg13g2_fill_2
X_18143_ _09223_ _09252_ _09253_ VPWR VGND sg13g2_nor2b_1
XFILLER_15_1035 VPWR VGND sg13g2_decap_8
X_15355_ _06622_ net276 _06621_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_731 VPWR VGND sg13g2_fill_2
X_12567_ net1038 VPWR _03939_ VGND net542 u_FIR.sum\[0\]\[14\] sg13g2_o21ai_1
XFILLER_11_270 VPWR VGND sg13g2_decap_8
XFILLER_102_1027 VPWR VGND sg13g2_fill_1
X_14306_ _05612_ _05606_ _05611_ VPWR VGND sg13g2_xnor2_1
X_18074_ _09184_ _09179_ _09182_ VPWR VGND sg13g2_xnor2_1
X_15286_ _06555_ u_FIR.sum\[5\]\[10\] net395 VPWR VGND sg13g2_xnor2_1
X_12498_ _03873_ _03864_ _03872_ VPWR VGND sg13g2_nand2_1
X_17025_ _08181_ net705 net212 VPWR VGND sg13g2_nand2_1
X_14237_ VGND VPWR _05545_ _05500_ _05498_ sg13g2_or2_1
XFILLER_113_802 VPWR VGND sg13g2_fill_1
XFILLER_131_109 VPWR VGND sg13g2_fill_2
XFILLER_113_813 VPWR VGND sg13g2_decap_8
X_14168_ _05478_ _05446_ _05476_ VPWR VGND sg13g2_xnor2_1
X_13119_ _04467_ _04431_ _04469_ VPWR VGND sg13g2_xor2_1
XFILLER_86_708 VPWR VGND sg13g2_fill_1
X_18976_ _10060_ _10059_ _10063_ VPWR VGND sg13g2_xor2_1
X_14099_ _03365_ net904 _05410_ VPWR VGND sg13g2_nor2_1
XFILLER_61_1000 VPWR VGND sg13g2_decap_8
XFILLER_61_1033 VPWR VGND sg13g2_fill_1
X_17927_ _08654_ _09059_ _08636_ _09060_ VPWR VGND sg13g2_nand3_1
XFILLER_38_112 VPWR VGND sg13g2_fill_1
XFILLER_94_741 VPWR VGND sg13g2_fill_1
XFILLER_38_123 VPWR VGND sg13g2_decap_8
XFILLER_38_134 VPWR VGND sg13g2_fill_2
X_17858_ _08991_ _08830_ _08959_ VPWR VGND sg13g2_xnor2_1
XFILLER_82_903 VPWR VGND sg13g2_fill_2
XFILLER_27_819 VPWR VGND sg13g2_fill_1
XFILLER_82_936 VPWR VGND sg13g2_decap_4
X_23170__1534 VPWR VGND net1533 sg13g2_tiehi
X_16809_ VGND VPWR _07931_ net2153 _07965_ _07948_ sg13g2_a21oi_1
XFILLER_53_104 VPWR VGND sg13g2_decap_8
X_17789_ _08908_ _08912_ _08886_ _08922_ VPWR VGND sg13g2_nand3_1
XFILLER_53_137 VPWR VGND sg13g2_decap_8
XFILLER_53_148 VPWR VGND sg13g2_fill_1
X_19528_ _10591_ _10586_ _10592_ VPWR VGND sg13g2_xor2_1
XFILLER_90_991 VPWR VGND sg13g2_decap_8
X_19459_ _10523_ _10519_ _10522_ VPWR VGND sg13g2_nand2_1
XFILLER_22_546 VPWR VGND sg13g2_decap_8
XFILLER_14_39 VPWR VGND sg13g2_fill_2
XFILLER_50_866 VPWR VGND sg13g2_decap_8
X_22470_ VGND VPWR net448 _03234_ _00543_ _02984_ sg13g2_a21oi_1
X_21421_ _02036_ _02037_ _02038_ VPWR VGND sg13g2_nor2b_1
X_21352_ _01951_ VPWR _01969_ VGND _01936_ _01943_ sg13g2_o21ai_1
X_20303_ VGND VPWR _10962_ _11012_ _00966_ _00965_ sg13g2_a21oi_1
XFILLER_107_139 VPWR VGND sg13g2_fill_1
X_21283_ _01896_ VPWR _01900_ VGND _01897_ _01899_ sg13g2_o21ai_1
X_20234_ net213 net632 _00867_ _00897_ VPWR VGND sg13g2_a21o_1
X_23022_ net1173 VGND VPWR _00084_ u_FIR.sum\[2\]\[3\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
X_20165_ net2121 _00827_ _00828_ VPWR VGND sg13g2_nor2_1
XFILLER_118_1045 VPWR VGND sg13g2_decap_8
XFILLER_58_900 VPWR VGND sg13g2_decap_8
XFILLER_130_164 VPWR VGND sg13g2_decap_4
X_20096_ net209 _11136_ u_LMS.x_r\[5\]\[5\] _11137_ VPWR VGND sg13g2_nand3_1
XFILLER_29_112 VPWR VGND sg13g2_fill_1
XFILLER_69_281 VPWR VGND sg13g2_fill_2
XFILLER_73_925 VPWR VGND sg13g2_decap_4
XFILLER_84_284 VPWR VGND sg13g2_fill_1
XFILLER_55_46 VPWR VGND sg13g2_decap_8
XFILLER_72_446 VPWR VGND sg13g2_fill_2
XFILLER_26_841 VPWR VGND sg13g2_fill_1
X_22806_ u_debug_unit.mon_w6_sync\[5\] net350 _03121_ VPWR VGND sg13g2_nor2_1
XFILLER_44_148 VPWR VGND sg13g2_decap_8
XFILLER_77_1051 VPWR VGND sg13g2_decap_8
XFILLER_60_608 VPWR VGND sg13g2_fill_1
X_20998_ _01638_ u_LMS.w\[6\]\[18\] net73 VPWR VGND sg13g2_xnor2_1
XFILLER_26_896 VPWR VGND sg13g2_decap_8
XFILLER_111_63 VPWR VGND sg13g2_decap_8
X_22737_ VGND VPWR _07745_ net330 _00708_ _03086_ sg13g2_a21oi_1
X_23371__1231 VPWR VGND net1230 sg13g2_tiehi
XFILLER_52_192 VPWR VGND sg13g2_fill_2
XFILLER_13_546 VPWR VGND sg13g2_fill_2
XFILLER_125_1016 VPWR VGND sg13g2_decap_8
XFILLER_111_96 VPWR VGND sg13g2_decap_8
X_13470_ net1039 VPWR _04809_ VGND net414 _04808_ sg13g2_o21ai_1
X_22668_ coeff_force_packed\[38\] net467 _03066_ _00659_ VPWR VGND sg13g2_mux2_1
XFILLER_40_354 VPWR VGND sg13g2_decap_8
X_12421_ net854 net719 _03796_ _03798_ VPWR VGND sg13g2_a21o_1
X_21619_ _02236_ u_LMS.w\[7\]\[21\] net62 VPWR VGND sg13g2_nand2_1
X_22599_ net460 u_debug_unit.sw_reset\[6\] _03058_ _00598_ VPWR VGND sg13g2_mux2_1
X_15140_ VGND VPWR _06374_ _06403_ _06412_ _06402_ sg13g2_a21oi_1
X_12352_ _03731_ _03723_ _03730_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_701 VPWR VGND sg13g2_decap_8
XFILLER_5_712 VPWR VGND sg13g2_fill_2
X_23750__1371 VPWR VGND net1370 sg13g2_tiehi
XFILLER_5_723 VPWR VGND sg13g2_decap_8
XFILLER_112_0 VPWR VGND sg13g2_decap_8
XFILLER_5_734 VPWR VGND sg13g2_decap_8
X_15071_ _06345_ net778 net859 VPWR VGND sg13g2_nand2_1
XFILLER_126_459 VPWR VGND sg13g2_fill_1
X_12283_ _03662_ _03656_ _03664_ VPWR VGND sg13g2_xor2_1
XFILLER_101_1060 VPWR VGND sg13g2_fill_1
X_14022_ _05315_ _05309_ _05313_ _05336_ VPWR VGND sg13g2_a21o_1
XFILLER_122_610 VPWR VGND sg13g2_fill_1
X_23524__1322 VPWR VGND net1321 sg13g2_tiehi
XFILLER_122_621 VPWR VGND sg13g2_decap_4
X_18830_ _09913_ VPWR _09917_ VGND _09914_ _09916_ sg13g2_o21ai_1
XFILLER_1_940 VPWR VGND sg13g2_decap_8
XFILLER_96_42 VPWR VGND sg13g2_fill_1
XFILLER_121_142 VPWR VGND sg13g2_decap_4
X_18761_ net183 _09846_ net655 _09848_ VPWR VGND sg13g2_nand3_1
X_15973_ _07216_ _07214_ _07215_ VPWR VGND sg13g2_nand2_1
XFILLER_96_75 VPWR VGND sg13g2_fill_2
XFILLER_103_890 VPWR VGND sg13g2_decap_8
XFILLER_49_944 VPWR VGND sg13g2_fill_1
XFILLER_121_186 VPWR VGND sg13g2_fill_1
XFILLER_0_494 VPWR VGND sg13g2_fill_1
X_17712_ _08845_ net685 _08814_ VPWR VGND sg13g2_xnor2_1
X_14924_ _06206_ VPWR _06207_ VGND _06158_ _06188_ sg13g2_o21ai_1
XFILLER_48_454 VPWR VGND sg13g2_decap_8
X_18692_ _09779_ _09778_ _09773_ VPWR VGND sg13g2_nand2b_1
XFILLER_48_465 VPWR VGND sg13g2_fill_1
X_17643_ _08774_ _08773_ _08776_ VPWR VGND sg13g2_xor2_1
X_14855_ _06141_ _06134_ _06139_ VPWR VGND sg13g2_xnor2_1
XFILLER_35_115 VPWR VGND sg13g2_fill_1
XFILLER_63_435 VPWR VGND sg13g2_decap_8
X_13806_ _05131_ _05122_ _05129_ VPWR VGND sg13g2_xnor2_1
X_17574_ _08707_ _08674_ _08676_ VPWR VGND sg13g2_xnor2_1
XFILLER_91_777 VPWR VGND sg13g2_decap_4
X_14786_ _06074_ _06031_ _06072_ VPWR VGND sg13g2_xnor2_1
X_11998_ _03408_ spi_addr\[3\] _03415_ VPWR VGND spi_addr\[2\] sg13g2_nand3b_1
Xclkbuf_4_7_0_clkA clknet_0_clkA clknet_4_7_0_clkA VPWR VGND sg13g2_buf_8
X_19313_ net424 _03244_ net133 net101 _10377_ VPWR VGND sg13g2_nor4_1
X_16525_ VGND VPWR net482 _07735_ _00224_ _07736_ sg13g2_a21oi_1
XFILLER_50_118 VPWR VGND sg13g2_decap_8
X_13737_ _05064_ u_FIR.sum\[2\]\[9\] net404 VPWR VGND sg13g2_nand2_1
XFILLER_50_129 VPWR VGND sg13g2_fill_2
XFILLER_31_310 VPWR VGND sg13g2_decap_4
XFILLER_32_855 VPWR VGND sg13g2_decap_4
X_19244_ net368 _10265_ _10318_ VPWR VGND sg13g2_nor2_1
X_16456_ _07671_ VPWR _07684_ VGND net270 _07669_ sg13g2_o21ai_1
X_13668_ _04995_ _04962_ _04997_ VPWR VGND sg13g2_xor2_1
X_15407_ _06672_ _06649_ _06670_ VPWR VGND sg13g2_xnor2_1
X_19175_ _10257_ _10260_ _10261_ _10262_ VPWR VGND sg13g2_nor3_2
X_12619_ _03987_ _03984_ _03986_ VPWR VGND sg13g2_nand2_1
X_16387_ _07611_ _07618_ _07619_ VPWR VGND sg13g2_nor2b_1
X_13599_ _04929_ _04889_ _04927_ VPWR VGND sg13g2_xnor2_1
X_18126_ _09236_ _09235_ _09223_ VPWR VGND sg13g2_nand2b_1
X_15338_ _06591_ VPWR _06605_ VGND _06586_ _06589_ sg13g2_o21ai_1
X_18057_ _09169_ _09030_ _09032_ VPWR VGND sg13g2_xnor2_1
X_15269_ _03372_ _06537_ _06538_ VPWR VGND sg13g2_nor2_1
XFILLER_126_960 VPWR VGND sg13g2_fill_1
X_17008_ _08128_ _08130_ _08100_ _08164_ VPWR VGND sg13g2_nand3_1
XFILLER_6_84 VPWR VGND sg13g2_decap_8
XFILLER_125_481 VPWR VGND sg13g2_decap_8
Xfanout507 net508 net507 VPWR VGND sg13g2_buf_1
Xfanout518 net519 net518 VPWR VGND sg13g2_buf_1
Xfanout529 net530 net529 VPWR VGND sg13g2_buf_1
XFILLER_98_354 VPWR VGND sg13g2_fill_1
XFILLER_98_398 VPWR VGND sg13g2_fill_1
XFILLER_6_1011 VPWR VGND sg13g2_decap_8
X_18959_ _10046_ _10045_ _10041_ VPWR VGND sg13g2_nand2b_1
XFILLER_112_197 VPWR VGND sg13g2_decap_8
XFILLER_100_359 VPWR VGND sg13g2_decap_4
X_21970_ _02547_ VPWR _02564_ VGND _02532_ _02539_ sg13g2_o21ai_1
XFILLER_82_700 VPWR VGND sg13g2_decap_8
XFILLER_82_711 VPWR VGND sg13g2_fill_1
X_23085__1079 VPWR VGND net1078 sg13g2_tiehi
XFILLER_55_936 VPWR VGND sg13g2_decap_8
X_20921_ net73 u_LMS.w\[6\]\[19\] _01561_ VPWR VGND sg13g2_xor2_1
XFILLER_55_947 VPWR VGND sg13g2_fill_2
XFILLER_66_284 VPWR VGND sg13g2_decap_8
XFILLER_66_295 VPWR VGND sg13g2_fill_1
X_23640_ net986 VGND VPWR _00702_ u_debug_unit.mon_w0_sync\[6\] clknet_leaf_54_clkA
+ sg13g2_dfrbpq_1
XFILLER_42_608 VPWR VGND sg13g2_decap_8
X_20852_ _01489_ _01475_ _01492_ VPWR VGND sg13g2_xor2_1
XFILLER_35_660 VPWR VGND sg13g2_fill_1
XFILLER_41_118 VPWR VGND sg13g2_fill_2
XFILLER_35_671 VPWR VGND sg13g2_fill_1
X_23571_ net981 VGND VPWR _00633_ coeff_force_packed\[15\] clknet_leaf_53_clkA sg13g2_dfrbpq_1
X_20783_ _01421_ net2075 _01423_ VPWR VGND sg13g2_nor2_1
XFILLER_34_181 VPWR VGND sg13g2_decap_4
X_22522_ _03000_ _03013_ _03014_ _00565_ VPWR VGND sg13g2_nor3_1
X_22453_ net960 VPWR _02976_ VGND net450 net621 sg13g2_o21ai_1
Xclkbuf_leaf_25_clkA clknet_4_11_0_clkA clknet_leaf_25_clkA VPWR VGND sg13g2_buf_8
XFILLER_41_48 VPWR VGND sg13g2_fill_1
X_21404_ _02021_ _02012_ _02020_ VPWR VGND sg13g2_xnor2_1
XFILLER_108_415 VPWR VGND sg13g2_decap_8
XFILLER_108_426 VPWR VGND sg13g2_fill_1
X_22384_ VGND VPWR net452 _03277_ _00500_ _02941_ sg13g2_a21oi_1
X_21335_ _01952_ _01944_ _01950_ VPWR VGND sg13g2_xnor2_1
XFILLER_68_1028 VPWR VGND sg13g2_fill_1
X_23712__1439 VPWR VGND net1438 sg13g2_tiehi
X_21266_ _01874_ VPWR _01883_ VGND _01871_ _01875_ sg13g2_o21ai_1
X_23005_ net1198 VGND VPWR _00067_ u_FIR.sum\[1\]\[2\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
X_20217_ _00872_ VPWR _00880_ VGND _00873_ net2123 sg13g2_o21ai_1
X_21197_ _01812_ VPWR _01814_ VGND net427 net83 sg13g2_o21ai_1
XFILLER_89_365 VPWR VGND sg13g2_decap_8
XFILLER_77_516 VPWR VGND sg13g2_decap_4
XFILLER_132_996 VPWR VGND sg13g2_decap_8
X_20148_ VPWR _11189_ _11188_ VGND sg13g2_inv_1
XFILLER_66_23 VPWR VGND sg13g2_fill_1
XFILLER_106_96 VPWR VGND sg13g2_fill_1
X_20079_ _11120_ _11117_ _11118_ VPWR VGND sg13g2_xnor2_1
X_12970_ _04328_ _04298_ _04326_ VPWR VGND sg13g2_xnor2_1
XFILLER_73_700 VPWR VGND sg13g2_decap_4
X_11921_ VPWR _03342_ u_LMS.w\[2\]\[12\] VGND sg13g2_inv_1
XFILLER_72_210 VPWR VGND sg13g2_fill_1
X_14640_ _05905_ VPWR _05931_ VGND _05857_ _05897_ sg13g2_o21ai_1
XFILLER_61_906 VPWR VGND sg13g2_fill_1
X_11852_ VPWR _03273_ net698 VGND sg13g2_inv_1
XFILLER_122_73 VPWR VGND sg13g2_decap_8
XFILLER_82_22 VPWR VGND sg13g2_fill_1
XFILLER_73_788 VPWR VGND sg13g2_fill_2
XFILLER_73_799 VPWR VGND sg13g2_fill_2
XFILLER_82_44 VPWR VGND sg13g2_decap_8
XFILLER_60_416 VPWR VGND sg13g2_decap_4
X_14571_ _05862_ _05828_ _05864_ VPWR VGND sg13g2_xor2_1
XFILLER_32_129 VPWR VGND sg13g2_decap_8
XFILLER_14_833 VPWR VGND sg13g2_fill_1
X_23769_ net988 VGND VPWR _00002_ u_spi_slave.rx_shift\[11\] clknet_3_3__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_11783_ VPWR _00037_ net944 VGND sg13g2_inv_1
XFILLER_25_181 VPWR VGND sg13g2_decap_4
X_16310_ _07543_ _07517_ _07545_ VPWR VGND sg13g2_xor2_1
XFILLER_14_855 VPWR VGND sg13g2_decap_4
X_13522_ _04855_ _04852_ _04853_ VPWR VGND sg13g2_xnor2_1
X_17290_ _08445_ _08444_ _08446_ VPWR VGND sg13g2_nor2b_1
XFILLER_9_303 VPWR VGND sg13g2_decap_8
XFILLER_14_888 VPWR VGND sg13g2_decap_8
XFILLER_14_899 VPWR VGND sg13g2_fill_2
X_16241_ _07478_ _07441_ _07476_ VPWR VGND sg13g2_xnor2_1
XFILLER_13_387 VPWR VGND sg13g2_fill_2
X_13453_ _04793_ _04792_ _04791_ VPWR VGND sg13g2_nand2b_1
X_12404_ _03782_ _03751_ _03780_ VPWR VGND sg13g2_xnor2_1
XFILLER_127_713 VPWR VGND sg13g2_fill_1
X_16172_ net860 net793 _07408_ _07410_ VPWR VGND sg13g2_a21o_1
X_13384_ _04727_ _04692_ _04725_ VPWR VGND sg13g2_xnor2_1
XFILLER_12_1027 VPWR VGND sg13g2_decap_8
Xclkbuf_4_15_0_clkA clknet_0_clkA clknet_4_15_0_clkA VPWR VGND sg13g2_buf_8
X_15123_ _06396_ u_FIR.w\[2\]\[6\] _06395_ VPWR VGND sg13g2_xnor2_1
X_12335_ VGND VPWR net718 _03701_ _03714_ _03700_ sg13g2_a21oi_1
XFILLER_115_908 VPWR VGND sg13g2_fill_2
XFILLER_108_960 VPWR VGND sg13g2_fill_2
XFILLER_5_553 VPWR VGND sg13g2_decap_8
X_19931_ _10972_ _10963_ _10970_ VPWR VGND sg13g2_xnor2_1
X_15054_ _06328_ _06301_ _06329_ VPWR VGND sg13g2_xor2_1
XFILLER_99_118 VPWR VGND sg13g2_fill_1
XFILLER_126_289 VPWR VGND sg13g2_fill_1
X_12266_ _03627_ VPWR _03647_ VGND _03624_ _03628_ sg13g2_o21ai_1
XFILLER_49_7 VPWR VGND sg13g2_decap_8
X_14005_ net997 VPWR _05320_ VGND net492 u_FIR.sum\[4\]\[2\] sg13g2_o21ai_1
X_19862_ _10910_ _10911_ _00386_ VPWR VGND sg13g2_nor2_1
X_12197_ VGND VPWR _03585_ u_LMS.count\[15\] u_LMS.count\[16\] sg13g2_or2_1
X_18813_ _09891_ VPWR _09900_ VGND _09888_ _09892_ sg13g2_o21ai_1
XFILLER_95_313 VPWR VGND sg13g2_decap_8
XFILLER_122_473 VPWR VGND sg13g2_decap_4
XFILLER_122_484 VPWR VGND sg13g2_decap_8
X_19793_ _10857_ net311 u_LMS.w\[4\]\[12\] coeff_force_packed\[28\] net562 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_122_495 VPWR VGND sg13g2_fill_2
XFILLER_0_291 VPWR VGND sg13g2_decap_8
X_18744_ net654 net146 net653 _09831_ VPWR VGND net90 sg13g2_nand4_1
XFILLER_110_679 VPWR VGND sg13g2_fill_2
X_15956_ net501 VPWR _07200_ VGND _07198_ _07199_ sg13g2_o21ai_1
X_14907_ _06191_ _06182_ _06189_ VPWR VGND sg13g2_xnor2_1
X_18675_ _09759_ _09761_ _09762_ VPWR VGND sg13g2_nor2_1
X_15887_ _07134_ _07133_ _07102_ VPWR VGND sg13g2_nand2b_1
X_17626_ _08724_ _08721_ _08759_ VPWR VGND sg13g2_xor2_1
XFILLER_24_608 VPWR VGND sg13g2_decap_4
X_14838_ _06124_ net768 net806 VPWR VGND sg13g2_nand2_1
XFILLER_45_980 VPWR VGND sg13g2_decap_8
XFILLER_63_287 VPWR VGND sg13g2_fill_1
XFILLER_17_682 VPWR VGND sg13g2_decap_8
X_23081__1085 VPWR VGND net1084 sg13g2_tiehi
XFILLER_108_1000 VPWR VGND sg13g2_fill_1
Xclkbuf_leaf_48_clkA clknet_4_4_0_clkA clknet_leaf_48_clkA VPWR VGND sg13g2_buf_8
X_17557_ _08690_ _08689_ net121 VPWR VGND sg13g2_nand2b_1
X_14769_ _06057_ net769 net823 VPWR VGND sg13g2_nand2_1
XFILLER_16_181 VPWR VGND sg13g2_fill_1
X_16508_ VGND VPWR u_LMS.w\[0\]\[16\] _07713_ _07723_ _07714_ sg13g2_a21oi_1
X_17488_ _08605_ _08620_ _08621_ VPWR VGND sg13g2_nor2_1
XFILLER_60_983 VPWR VGND sg13g2_fill_1
X_19227_ net30 VPWR _10305_ VGND net28 _10304_ sg13g2_o21ai_1
X_16439_ _07668_ net388 u_FIR.sum\[7\]\[17\] VPWR VGND sg13g2_nand2b_1
X_23096__1063 VPWR VGND net1062 sg13g2_tiehi
XFILLER_20_869 VPWR VGND sg13g2_decap_8
XFILLER_75_0 VPWR VGND sg13g2_decap_8
XFILLER_9_870 VPWR VGND sg13g2_decap_4
X_19158_ VPWR _10245_ _10244_ VGND sg13g2_inv_1
XFILLER_118_724 VPWR VGND sg13g2_fill_2
XFILLER_118_746 VPWR VGND sg13g2_decap_8
XFILLER_8_380 VPWR VGND sg13g2_decap_4
X_18109_ _09212_ _09196_ _09219_ VPWR VGND sg13g2_xor2_1
X_19089_ _10176_ u_LMS.w\[3\]\[16\] _10174_ VPWR VGND sg13g2_xnor2_1
XFILLER_105_429 VPWR VGND sg13g2_decap_4
X_21120_ _01738_ _01621_ _01623_ VPWR VGND sg13g2_xnor2_1
XFILLER_117_289 VPWR VGND sg13g2_fill_2
XFILLER_99_630 VPWR VGND sg13g2_fill_1
X_21051_ VGND VPWR net567 coeff_force_packed\[48\] _01685_ net314 sg13g2_a21oi_1
XFILLER_132_248 VPWR VGND sg13g2_decap_8
Xfanout304 net306 net304 VPWR VGND sg13g2_buf_1
Xfanout315 net319 net315 VPWR VGND sg13g2_buf_1
XFILLER_98_151 VPWR VGND sg13g2_decap_8
XFILLER_101_602 VPWR VGND sg13g2_decap_8
X_20002_ VGND VPWR _11033_ _11034_ _11043_ _11042_ sg13g2_a21oi_1
Xfanout326 _03423_ net326 VPWR VGND sg13g2_buf_1
XFILLER_87_825 VPWR VGND sg13g2_decap_8
XFILLER_115_1004 VPWR VGND sg13g2_fill_2
XFILLER_101_613 VPWR VGND sg13g2_fill_2
Xfanout337 _03070_ net337 VPWR VGND sg13g2_buf_1
XFILLER_59_527 VPWR VGND sg13g2_decap_4
Xfanout348 net349 net348 VPWR VGND sg13g2_buf_1
XFILLER_100_112 VPWR VGND sg13g2_decap_8
Xfanout359 net360 net359 VPWR VGND sg13g2_buf_1
XFILLER_115_1037 VPWR VGND sg13g2_fill_1
XFILLER_55_700 VPWR VGND sg13g2_fill_1
X_21953_ _02547_ _02546_ _02540_ VPWR VGND sg13g2_nand2b_1
XFILLER_54_221 VPWR VGND sg13g2_fill_2
XFILLER_28_958 VPWR VGND sg13g2_decap_8
XFILLER_55_766 VPWR VGND sg13g2_decap_8
X_20904_ _01236_ VPWR _01544_ VGND _01270_ _01543_ sg13g2_o21ai_1
XFILLER_43_917 VPWR VGND sg13g2_decap_4
X_21884_ _02471_ VPWR _02478_ VGND _02436_ _02469_ sg13g2_o21ai_1
XFILLER_70_725 VPWR VGND sg13g2_decap_4
X_23623_ net955 VGND VPWR _00685_ coeff_force_packed\[61\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_20835_ _01475_ _01465_ _01466_ VPWR VGND sg13g2_xnor2_1
X_23462__1546 VPWR VGND net1545 sg13g2_tiehi
XFILLER_70_769 VPWR VGND sg13g2_decap_8
X_23554_ net1015 VGND VPWR _00616_ coeff_force_packed\[0\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
X_20766_ _01405_ _01372_ _01406_ VPWR VGND sg13g2_xor2_1
X_22505_ _03003_ u_LMS.count\[1\] _03002_ VPWR VGND sg13g2_nand2_1
X_23280__1334 VPWR VGND net1333 sg13g2_tiehi
X_23485_ net1465 VGND VPWR _00547_ u_LMS.x_r\[7\]\[4\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
X_20697_ net136 _01336_ net616 _01337_ VPWR VGND sg13g2_nand3_1
XFILLER_7_818 VPWR VGND sg13g2_fill_1
X_22436_ VGND VPWR net437 _03251_ _00526_ _02967_ sg13g2_a21oi_1
XFILLER_109_735 VPWR VGND sg13g2_fill_2
XFILLER_108_234 VPWR VGND sg13g2_fill_1
X_22367_ net1027 VPWR _02933_ VGND net455 u_LMS.x_r\[0\]\[5\] sg13g2_o21ai_1
X_12120_ _03531_ net289 coeff_force_packed\[23\] _03410_ u_debug_unit.mon_w4_sync\[2\]
+ VPWR VGND sg13g2_a22oi_1
X_21318_ _01935_ net266 net593 net249 net595 VPWR VGND sg13g2_a22oi_1
X_22298_ _02883_ _02830_ _02878_ VPWR VGND sg13g2_nand2_1
XFILLER_117_790 VPWR VGND sg13g2_decap_8
XFILLER_105_952 VPWR VGND sg13g2_decap_8
X_12051_ _03465_ VPWR _00046_ VGND _03383_ _03393_ sg13g2_o21ai_1
X_21249_ _01863_ _01865_ _01866_ VPWR VGND sg13g2_nor2_1
XFILLER_77_11 VPWR VGND sg13g2_fill_1
XFILLER_89_151 VPWR VGND sg13g2_fill_2
XFILLER_120_900 VPWR VGND sg13g2_fill_1
XFILLER_77_33 VPWR VGND sg13g2_fill_2
XFILLER_2_578 VPWR VGND sg13g2_fill_1
XFILLER_117_84 VPWR VGND sg13g2_fill_2
XFILLER_105_996 VPWR VGND sg13g2_decap_8
Xrebuffer2080 net2080 net2079 VPWR VGND sg13g2_buf_1
XFILLER_89_162 VPWR VGND sg13g2_fill_2
Xrebuffer2091 net2099 net2090 VPWR VGND sg13g2_buf_1
XFILLER_132_793 VPWR VGND sg13g2_fill_2
XFILLER_77_335 VPWR VGND sg13g2_decap_8
Xfanout860 net861 net860 VPWR VGND sg13g2_buf_1
XFILLER_120_966 VPWR VGND sg13g2_decap_8
Xfanout871 u_FIR.x_reg\[3\] net871 VPWR VGND sg13g2_buf_1
X_15810_ _07059_ u_FIR.w\[1\]\[6\] net834 VPWR VGND sg13g2_nand2b_1
Xfanout882 net885 net882 VPWR VGND sg13g2_buf_1
X_16790_ VGND VPWR net2069 _07944_ _07946_ net2207 sg13g2_a21oi_1
Xfanout893 net898 net893 VPWR VGND sg13g2_buf_1
X_15741_ VGND VPWR net819 _06990_ _06992_ _06989_ sg13g2_a21oi_1
X_12953_ VGND VPWR net546 _04310_ _00077_ _04311_ sg13g2_a21oi_1
XFILLER_58_593 VPWR VGND sg13g2_decap_8
X_11904_ VPWR _03325_ u_LMS.w\[4\]\[23\] VGND sg13g2_inv_1
X_18460_ _09569_ VPWR _09570_ VGND _09260_ _09568_ sg13g2_o21ai_1
X_15672_ _06925_ _06920_ _06923_ VPWR VGND sg13g2_xnor2_1
X_12884_ _04245_ _04202_ _04206_ _04244_ VPWR VGND sg13g2_and3_1
XFILLER_34_928 VPWR VGND sg13g2_fill_2
XFILLER_73_585 VPWR VGND sg13g2_decap_8
X_23187__1504 VPWR VGND net1503 sg13g2_tiehi
X_17411_ _08554_ net952 net558 VPWR VGND sg13g2_nand2b_1
X_14623_ _05915_ _05872_ _05913_ VPWR VGND sg13g2_xnor2_1
X_23215__1455 VPWR VGND net1454 sg13g2_tiehi
X_18391_ _09501_ net683 net202 VPWR VGND sg13g2_nand2_1
X_11835_ VPWR _03256_ net662 VGND sg13g2_inv_1
XFILLER_33_438 VPWR VGND sg13g2_fill_1
XFILLER_26_70 VPWR VGND sg13g2_fill_2
XFILLER_42_950 VPWR VGND sg13g2_decap_8
X_17342_ _08498_ net59 _08497_ VPWR VGND sg13g2_nand2_1
X_14554_ _05848_ _05820_ _05847_ VPWR VGND sg13g2_nand2_1
X_13505_ net865 u_FIR.sum\[2\]\[3\] net756 _04838_ VPWR VGND sg13g2_nand3_1
X_17273_ _08429_ net263 net713 net248 net714 VPWR VGND sg13g2_a22oi_1
X_14485_ _05780_ _05781_ _05782_ VPWR VGND sg13g2_nor2_1
XFILLER_9_144 VPWR VGND sg13g2_decap_8
X_19012_ net202 net663 _10070_ _10099_ VPWR VGND sg13g2_a21o_1
X_16224_ _07461_ _07454_ _07459_ VPWR VGND sg13g2_xnor2_1
X_13436_ _04765_ _04776_ _04777_ VPWR VGND sg13g2_nor2_1
XFILLER_127_510 VPWR VGND sg13g2_decap_8
XFILLER_9_199 VPWR VGND sg13g2_decap_4
X_16155_ _07393_ _07365_ _07394_ VPWR VGND sg13g2_xor2_1
X_13367_ VGND VPWR _04678_ _04689_ _04710_ _04697_ sg13g2_a21oi_1
X_15106_ _06379_ _06339_ _06377_ VPWR VGND sg13g2_xnor2_1
X_12318_ _03661_ VPWR _03698_ VGND _03626_ _03659_ sg13g2_o21ai_1
X_16086_ VGND VPWR _07292_ _07319_ _07326_ _07318_ sg13g2_a21oi_1
XFILLER_108_790 VPWR VGND sg13g2_decap_8
X_13298_ _04643_ _04641_ _04642_ VPWR VGND sg13g2_nand2_1
X_19914_ _10953_ _10951_ _10955_ VPWR VGND sg13g2_xor2_1
X_15037_ _06312_ net779 net874 VPWR VGND sg13g2_nand2_1
X_12249_ _03631_ _03630_ _03623_ VPWR VGND sg13g2_nand2b_1
XFILLER_110_410 VPWR VGND sg13g2_fill_2
X_19845_ _10843_ VPWR _10898_ VGND _10842_ _10845_ sg13g2_o21ai_1
XFILLER_68_324 VPWR VGND sg13g2_decap_8
XFILLER_68_335 VPWR VGND sg13g2_fill_1
XFILLER_3_63 VPWR VGND sg13g2_decap_8
XFILLER_68_357 VPWR VGND sg13g2_fill_2
XFILLER_110_454 VPWR VGND sg13g2_decap_8
XFILLER_95_154 VPWR VGND sg13g2_decap_4
X_19776_ VGND VPWR u_LMS.w\[4\]\[21\] u_LMS.w\[4\]\[20\] _10840_ net65 sg13g2_a21oi_1
X_16988_ _08143_ _08113_ _08144_ VPWR VGND sg13g2_xor2_1
XFILLER_3_1014 VPWR VGND sg13g2_decap_8
X_18727_ _09811_ _09812_ _09813_ _09814_ VPWR VGND sg13g2_nor3_1
XFILLER_95_198 VPWR VGND sg13g2_decap_8
X_15939_ net1001 VPWR _07184_ VGND net498 u_FIR.sum\[7\]\[15\] sg13g2_o21ai_1
XFILLER_83_349 VPWR VGND sg13g2_decap_4
XFILLER_37_755 VPWR VGND sg13g2_decap_8
XFILLER_64_552 VPWR VGND sg13g2_fill_1
X_18658_ net356 VPWR _09749_ VGND u_LMS.w\[2\]\[8\] net372 sg13g2_o21ai_1
XFILLER_64_574 VPWR VGND sg13g2_fill_1
XFILLER_37_799 VPWR VGND sg13g2_decap_4
X_17609_ _08742_ net693 net167 VPWR VGND sg13g2_nand2_1
X_18589_ _09694_ net33 net36 _09695_ VPWR VGND sg13g2_a21o_1
X_20620_ VGND VPWR _01258_ _01259_ _01260_ _01255_ sg13g2_a21oi_1
X_20551_ VGND VPWR _01167_ _01170_ _01191_ net117 sg13g2_a21oi_1
XFILLER_32_493 VPWR VGND sg13g2_decap_8
XFILLER_22_39 VPWR VGND sg13g2_decap_8
X_23270_ net1353 VGND VPWR _00332_ u_LMS.w\[2\]\[18\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
XFILLER_118_510 VPWR VGND sg13g2_fill_1
X_20482_ _01129_ _01010_ _01011_ VPWR VGND sg13g2_xnor2_1
X_22221_ _02815_ u_LMS.w\[8\]\[13\] _02765_ VPWR VGND sg13g2_xnor2_1
XFILLER_121_1052 VPWR VGND sg13g2_decap_8
XFILLER_118_565 VPWR VGND sg13g2_fill_2
XFILLER_106_727 VPWR VGND sg13g2_fill_2
X_22152_ _02746_ _02408_ _02745_ VPWR VGND sg13g2_nand2_1
X_21103_ _01724_ _01725_ _00435_ VPWR VGND sg13g2_nor2_1
XFILLER_121_708 VPWR VGND sg13g2_fill_2
X_22083_ _02659_ _02676_ _02677_ VPWR VGND sg13g2_nor2_1
Xfanout101 net104 net101 VPWR VGND sg13g2_buf_2
Xfanout112 net114 net112 VPWR VGND sg13g2_buf_2
XFILLER_59_302 VPWR VGND sg13g2_fill_1
X_21034_ _01671_ _01573_ _01572_ VPWR VGND sg13g2_nand2b_1
Xfanout123 net123 _07973_ VPWR VGND sg13g2_buf_4
XFILLER_102_944 VPWR VGND sg13g2_decap_4
Xfanout134 net137 net134 VPWR VGND sg13g2_buf_1
Xfanout145 net146 net145 VPWR VGND sg13g2_buf_1
XFILLER_87_644 VPWR VGND sg13g2_fill_1
XFILLER_86_121 VPWR VGND sg13g2_fill_1
Xfanout156 net157 net156 VPWR VGND sg13g2_buf_1
Xfanout167 net175 net167 VPWR VGND sg13g2_buf_1
XFILLER_47_14 VPWR VGND sg13g2_decap_4
Xfanout178 _07929_ net178 VPWR VGND sg13g2_buf_2
Xfanout189 net194 net189 VPWR VGND sg13g2_buf_1
XFILLER_41_1020 VPWR VGND sg13g2_decap_8
XFILLER_101_498 VPWR VGND sg13g2_decap_8
X_22985_ net998 VGND VPWR _00047_ u_spi_slave.tx_shift\[15\] net1635 sg13g2_dfrbpq_1
XFILLER_74_349 VPWR VGND sg13g2_fill_1
XFILLER_55_530 VPWR VGND sg13g2_fill_1
XFILLER_83_850 VPWR VGND sg13g2_fill_1
X_21936_ _02530_ net577 net255 VPWR VGND sg13g2_nand2_1
XFILLER_83_883 VPWR VGND sg13g2_fill_1
XFILLER_43_714 VPWR VGND sg13g2_fill_1
XFILLER_103_64 VPWR VGND sg13g2_fill_1
XFILLER_42_202 VPWR VGND sg13g2_fill_2
XFILLER_28_799 VPWR VGND sg13g2_fill_2
XFILLER_103_75 VPWR VGND sg13g2_decap_8
XFILLER_70_522 VPWR VGND sg13g2_decap_8
XFILLER_70_533 VPWR VGND sg13g2_fill_1
X_21867_ _02461_ net196 net570 net222 net574 VPWR VGND sg13g2_a22oi_1
XFILLER_70_544 VPWR VGND sg13g2_fill_1
XFILLER_63_57 VPWR VGND sg13g2_fill_2
XFILLER_24_950 VPWR VGND sg13g2_decap_4
X_23606_ net1015 VGND VPWR _00668_ coeff_force_packed\[46\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
X_20818_ _01457_ _01432_ _01458_ VPWR VGND sg13g2_xor2_1
X_21798_ _02389_ _02390_ _02391_ _02392_ VPWR VGND sg13g2_nor3_1
XFILLER_51_780 VPWR VGND sg13g2_fill_1
X_23537_ net955 VGND VPWR _00599_ u_debug_unit.sw_reset\[7\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
X_20749_ _01389_ net88 net620 net111 net618 VPWR VGND sg13g2_a22oi_1
XFILLER_10_121 VPWR VGND sg13g2_fill_2
X_14270_ _05577_ _05576_ _05572_ VPWR VGND sg13g2_nand2b_1
X_23468_ net1525 VGND VPWR _00530_ u_LMS.x_r\[5\]\[3\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
XFILLER_7_648 VPWR VGND sg13g2_decap_8
XFILLER_6_114 VPWR VGND sg13g2_decap_8
X_13221_ _04568_ u_FIR.w\[6\]\[1\] net813 VPWR VGND sg13g2_nand2_1
XFILLER_6_136 VPWR VGND sg13g2_fill_1
X_22419_ net948 VPWR _02959_ VGND net432 net653 sg13g2_o21ai_1
XFILLER_109_565 VPWR VGND sg13g2_fill_1
X_23399_ net1151 VGND VPWR _00461_ u_LMS.w\[7\]\[9\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
XFILLER_6_169 VPWR VGND sg13g2_fill_2
X_13152_ _04500_ _04496_ _04501_ VPWR VGND sg13g2_xor2_1
X_23054__1126 VPWR VGND net1125 sg13g2_tiehi
XFILLER_88_21 VPWR VGND sg13g2_decap_8
X_12103_ _03506_ _03514_ _03505_ _03515_ VPWR VGND sg13g2_nand3_1
XFILLER_88_54 VPWR VGND sg13g2_fill_2
XFILLER_5_0 VPWR VGND sg13g2_decap_8
X_17960_ _09088_ _09091_ _09087_ _09093_ VPWR VGND sg13g2_nand3_1
X_13083_ _04434_ _04433_ _04413_ VPWR VGND sg13g2_nand2b_1
XFILLER_78_600 VPWR VGND sg13g2_fill_2
X_16911_ _07925_ net2073 _08067_ VPWR VGND sg13g2_xor2_1
X_12034_ VGND VPWR _03385_ _03389_ _00019_ net945 sg13g2_a21oi_1
X_17891_ _09001_ u_LMS.w\[1\]\[7\] _09023_ _09024_ VPWR VGND sg13g2_a21o_1
XFILLER_120_752 VPWR VGND sg13g2_decap_8
X_19630_ _10694_ net256 net646 net241 net647 VPWR VGND sg13g2_a22oi_1
X_16842_ _07998_ _07997_ _07988_ VPWR VGND sg13g2_nand2b_1
Xfanout690 u_LMS.x_r\[1\]\[5\] net690 VPWR VGND sg13g2_buf_1
XFILLER_120_796 VPWR VGND sg13g2_fill_2
XFILLER_65_327 VPWR VGND sg13g2_decap_4
X_19561_ _10625_ _10596_ _10597_ VPWR VGND sg13g2_xnor2_1
XFILLER_93_647 VPWR VGND sg13g2_fill_1
X_16773_ _07912_ net1665 _07929_ VPWR VGND sg13g2_xor2_1
X_13985_ _05301_ _05300_ _05293_ VPWR VGND sg13g2_nand2b_1
X_18512_ VGND VPWR u_LMS.w\[2\]\[4\] _09612_ _09622_ _09621_ sg13g2_a21oi_1
XFILLER_92_157 VPWR VGND sg13g2_decap_8
X_15724_ VGND VPWR net486 _06974_ _00184_ _06975_ sg13g2_a21oi_1
X_12936_ VPWR _04295_ _04294_ VGND sg13g2_inv_1
X_19492_ VGND VPWR _10548_ _10555_ _10556_ _10547_ sg13g2_a21oi_1
X_18443_ _09354_ _09349_ _09553_ VPWR VGND sg13g2_xor2_1
XFILLER_33_224 VPWR VGND sg13g2_decap_4
X_15655_ _06908_ _06902_ _06906_ VPWR VGND sg13g2_xnor2_1
X_12867_ _04227_ _04217_ _04228_ VPWR VGND sg13g2_xor2_1
XFILLER_61_544 VPWR VGND sg13g2_decap_4
X_14606_ _05898_ _05856_ _05897_ VPWR VGND sg13g2_xnor2_1
X_11818_ VPWR _03239_ net629 VGND sg13g2_inv_1
X_18374_ _09483_ VPWR _09484_ VGND _09456_ _09481_ sg13g2_o21ai_1
X_15586_ net833 u_FIR.sum\[6\]\[5\] net792 _06841_ VPWR VGND sg13g2_nand3_1
X_12798_ _04161_ _04133_ _04160_ VPWR VGND sg13g2_nand2b_1
XFILLER_14_471 VPWR VGND sg13g2_decap_8
XFILLER_14_482 VPWR VGND sg13g2_fill_1
XFILLER_105_1003 VPWR VGND sg13g2_decap_4
X_17325_ VPWR _08481_ _08480_ VGND sg13g2_inv_1
X_14537_ _05829_ _05811_ _05831_ VPWR VGND sg13g2_xor2_1
XFILLER_53_90 VPWR VGND sg13g2_decap_8
X_17256_ _08412_ u_LMS.w\[0\]\[13\] _08411_ VPWR VGND sg13g2_nand2_1
X_14468_ VPWR _05767_ _05766_ VGND sg13g2_inv_1
X_16207_ VGND VPWR _07424_ _07431_ _07444_ _07423_ sg13g2_a21oi_1
X_13419_ _04733_ _04735_ _04760_ _04761_ VPWR VGND sg13g2_nor3_1
X_17187_ _08342_ _08339_ _08343_ VPWR VGND sg13g2_nor2b_1
X_14399_ _05702_ _05679_ _05700_ VPWR VGND sg13g2_xnor2_1
X_16138_ _07376_ _07337_ _07377_ VPWR VGND sg13g2_xor2_1
XFILLER_127_395 VPWR VGND sg13g2_decap_8
X_16069_ net832 u_FIR.sum\[7\]\[5\] net802 _07310_ VPWR VGND sg13g2_nand3_1
XFILLER_69_600 VPWR VGND sg13g2_fill_1
XFILLER_102_218 VPWR VGND sg13g2_fill_2
XFILLER_130_527 VPWR VGND sg13g2_decap_8
XFILLER_102_229 VPWR VGND sg13g2_fill_2
XFILLER_38_0 VPWR VGND sg13g2_decap_4
XFILLER_25_1004 VPWR VGND sg13g2_fill_1
X_19828_ VGND VPWR _10883_ _10884_ _00379_ net931 sg13g2_a21oi_1
XFILLER_25_1059 VPWR VGND sg13g2_fill_2
XFILLER_112_1018 VPWR VGND sg13g2_decap_8
XFILLER_96_474 VPWR VGND sg13g2_fill_2
XFILLER_112_1029 VPWR VGND sg13g2_fill_1
XFILLER_68_187 VPWR VGND sg13g2_decap_8
XFILLER_110_295 VPWR VGND sg13g2_decap_8
X_19759_ _10822_ _10819_ _10823_ VPWR VGND sg13g2_xor2_1
XFILLER_25_703 VPWR VGND sg13g2_fill_1
X_22770_ u_debug_unit.mon_w4_sync\[1\] net341 _03103_ VPWR VGND sg13g2_nor2_1
X_21721_ _02320_ _02201_ _02202_ VPWR VGND sg13g2_xnor2_1
XFILLER_80_853 VPWR VGND sg13g2_fill_1
XFILLER_24_268 VPWR VGND sg13g2_fill_2
X_21652_ _02162_ VPWR _02265_ VGND _02164_ net2142 sg13g2_o21ai_1
X_20603_ _01239_ _01242_ _01243_ VPWR VGND sg13g2_nor2_1
X_21583_ _02181_ u_LMS.w\[7\]\[6\] _02200_ VPWR VGND sg13g2_xor2_1
X_23322_ net1279 VGND VPWR _00384_ u_LMS.w\[4\]\[24\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
X_20534_ _01174_ _01165_ _01173_ VPWR VGND sg13g2_nand2b_1
XFILLER_20_496 VPWR VGND sg13g2_fill_2
X_23253_ net1386 VGND VPWR _00315_ u_LMS.w\[1\]\[24\] clknet_leaf_56_clkA sg13g2_dfrbpq_1
X_20465_ VGND VPWR _03315_ net76 _01116_ _08494_ sg13g2_a21oi_1
X_22204_ _02798_ _03293_ _02777_ VPWR VGND sg13g2_xnor2_1
XFILLER_118_373 VPWR VGND sg13g2_decap_8
XFILLER_118_384 VPWR VGND sg13g2_decap_4
X_23184_ net1508 VGND VPWR _00246_ u_FIR.w\[4\]\[1\] clknet_leaf_35_clkA sg13g2_dfrbpq_1
X_20396_ _01059_ net75 u_LMS.w\[5\]\[20\] VPWR VGND sg13g2_nand2b_1
X_22135_ _02487_ _02488_ _02729_ VPWR VGND sg13g2_nor2b_1
XFILLER_0_813 VPWR VGND sg13g2_decap_4
XFILLER_121_527 VPWR VGND sg13g2_decap_4
X_22066_ _02655_ VPWR _02660_ VGND _03225_ net178 sg13g2_o21ai_1
X_23050__1132 VPWR VGND net1131 sg13g2_tiehi
XFILLER_102_741 VPWR VGND sg13g2_decap_4
XFILLER_59_143 VPWR VGND sg13g2_fill_1
XFILLER_48_806 VPWR VGND sg13g2_fill_2
X_21017_ net2070 _01654_ _01655_ _01657_ VPWR VGND sg13g2_or3_1
XFILLER_88_997 VPWR VGND sg13g2_fill_1
XFILLER_101_273 VPWR VGND sg13g2_decap_4
XFILLER_75_636 VPWR VGND sg13g2_fill_1
XFILLER_47_349 VPWR VGND sg13g2_decap_4
XFILLER_74_23 VPWR VGND sg13g2_decap_8
XFILLER_90_606 VPWR VGND sg13g2_decap_8
X_13770_ _05096_ _05088_ _05095_ VPWR VGND sg13g2_nand2_1
XFILLER_90_639 VPWR VGND sg13g2_fill_1
XFILLER_28_585 VPWR VGND sg13g2_decap_4
X_12721_ _04052_ _04085_ _04086_ VPWR VGND sg13g2_nor2b_1
XFILLER_71_831 VPWR VGND sg13g2_fill_1
X_21919_ _02513_ _02509_ _02512_ VPWR VGND sg13g2_nand2_1
X_22899_ _03178_ net297 u_FIR.x\[6\] net298 u_s2p_input.reg_sh\[5\] VPWR VGND sg13g2_a22oi_1
XFILLER_71_875 VPWR VGND sg13g2_fill_1
X_15440_ VGND VPWR net500 _06702_ _00172_ _06703_ sg13g2_a21oi_1
X_12652_ _04006_ VPWR _04018_ VGND _04001_ _04004_ sg13g2_o21ai_1
XFILLER_128_1047 VPWR VGND sg13g2_decap_8
XFILLER_130_84 VPWR VGND sg13g2_decap_8
X_15371_ _06623_ VPWR _06637_ VGND _06586_ _06621_ sg13g2_o21ai_1
X_12583_ _03952_ net733 net896 VPWR VGND sg13g2_nand2_1
XFILLER_11_430 VPWR VGND sg13g2_fill_1
X_17110_ _08266_ net135 net715 net173 net712 VPWR VGND sg13g2_a22oi_1
X_14322_ _05601_ _05627_ _05628_ VPWR VGND sg13g2_nor2_1
X_18090_ _09198_ _09188_ _09200_ VPWR VGND sg13g2_xor2_1
XFILLER_23_60 VPWR VGND sg13g2_decap_4
XFILLER_8_946 VPWR VGND sg13g2_fill_1
XFILLER_8_957 VPWR VGND sg13g2_fill_1
X_17041_ _03281_ net417 net160 _08197_ VGND VPWR net141 sg13g2_nor4_2
X_14253_ net507 VPWR _05561_ VGND _05559_ _05560_ sg13g2_o21ai_1
XFILLER_128_159 VPWR VGND sg13g2_decap_4
X_13204_ _04515_ _04551_ _04552_ VPWR VGND sg13g2_nor2b_1
XFILLER_99_64 VPWR VGND sg13g2_fill_1
X_14184_ _05491_ _05492_ _05493_ VPWR VGND sg13g2_and2_1
XFILLER_99_75 VPWR VGND sg13g2_decap_8
XFILLER_48_1026 VPWR VGND sg13g2_fill_2
X_13135_ _04484_ _04483_ _04480_ VPWR VGND sg13g2_nand2b_1
X_18992_ _10079_ _10077_ _10078_ VPWR VGND sg13g2_nand2_1
XFILLER_98_739 VPWR VGND sg13g2_decap_8
X_17943_ _09076_ u_LMS.w\[1\]\[21\] net77 VPWR VGND sg13g2_nand2_1
X_13066_ _04417_ net744 net883 VPWR VGND sg13g2_nand2_1
XFILLER_31_7 VPWR VGND sg13g2_decap_8
XFILLER_97_249 VPWR VGND sg13g2_fill_1
XFILLER_78_430 VPWR VGND sg13g2_decap_8
XFILLER_78_441 VPWR VGND sg13g2_fill_2
X_12017_ _03397_ _03433_ _03434_ VPWR VGND sg13g2_nor2_1
X_17874_ VGND VPWR _08928_ _09006_ _09007_ _08940_ sg13g2_a21oi_1
XFILLER_66_625 VPWR VGND sg13g2_decap_8
X_19613_ _10676_ VPWR _10677_ VGND _03250_ net178 sg13g2_o21ai_1
X_16825_ _07981_ _07976_ _07979_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_967 VPWR VGND sg13g2_decap_4
XFILLER_94_989 VPWR VGND sg13g2_fill_1
X_19544_ _10608_ _10607_ _10605_ VPWR VGND sg13g2_nand2b_1
XFILLER_0_1006 VPWR VGND sg13g2_decap_8
XFILLER_0_42 VPWR VGND sg13g2_decap_8
X_16756_ _07909_ _07911_ _07912_ VPWR VGND sg13g2_nor2b_1
X_13968_ _05285_ VPWR _05286_ VGND net281 _05270_ sg13g2_o21ai_1
XFILLER_62_820 VPWR VGND sg13g2_fill_1
XFILLER_47_894 VPWR VGND sg13g2_decap_4
X_15707_ _06912_ VPWR _06959_ VGND _06869_ _06910_ sg13g2_o21ai_1
X_19475_ _10538_ _10509_ _10539_ VPWR VGND sg13g2_xor2_1
X_12919_ _04279_ _04278_ _04277_ VPWR VGND sg13g2_nand2b_1
X_16687_ VGND VPWR u_LMS.w\[7\]\[13\] _07852_ _07856_ _07853_ sg13g2_a21oi_1
X_13899_ _05213_ _05220_ _05221_ VPWR VGND sg13g2_nor2b_1
X_18426_ _09536_ _09535_ net195 _09534_ _09504_ VPWR VGND sg13g2_a22oi_1
X_15638_ _06892_ _06852_ _06855_ _06891_ VPWR VGND sg13g2_and3_1
XFILLER_61_385 VPWR VGND sg13g2_decap_4
X_18357_ _09467_ _09465_ _09466_ VPWR VGND sg13g2_xnor2_1
X_15569_ _06824_ net785 net889 VPWR VGND sg13g2_nand2_1
X_17308_ _08412_ VPWR _08464_ VGND _08462_ _08463_ sg13g2_o21ai_1
X_18288_ _09398_ _09393_ _09396_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_783 VPWR VGND sg13g2_fill_1
X_17239_ VPWR _08395_ net71 VGND sg13g2_inv_1
XFILLER_128_660 VPWR VGND sg13g2_decap_8
X_23325__1277 VPWR VGND net1276 sg13g2_tiehi
X_20250_ _00913_ net634 net247 VPWR VGND sg13g2_nand2_1
XFILLER_115_321 VPWR VGND sg13g2_fill_2
XFILLER_127_192 VPWR VGND sg13g2_decap_8
XFILLER_115_332 VPWR VGND sg13g2_decap_4
X_20181_ _00842_ _00843_ _00844_ VPWR VGND sg13g2_nor2_1
XFILLER_103_505 VPWR VGND sg13g2_decap_8
XFILLER_103_516 VPWR VGND sg13g2_fill_1
XFILLER_103_527 VPWR VGND sg13g2_fill_2
XFILLER_131_836 VPWR VGND sg13g2_decap_4
XFILLER_130_368 VPWR VGND sg13g2_decap_8
XFILLER_57_603 VPWR VGND sg13g2_decap_8
XFILLER_57_614 VPWR VGND sg13g2_fill_1
X_22822_ u_debug_unit.mon_w7_sync\[6\] net342 _03129_ VPWR VGND sg13g2_nor2_1
XFILLER_44_308 VPWR VGND sg13g2_decap_4
XFILLER_44_319 VPWR VGND sg13g2_decap_8
XFILLER_65_691 VPWR VGND sg13g2_decap_4
XFILLER_71_138 VPWR VGND sg13g2_fill_1
X_22753_ VGND VPWR _03341_ net331 _00716_ _03094_ sg13g2_a21oi_1
XFILLER_53_853 VPWR VGND sg13g2_decap_4
X_21704_ _02306_ _02307_ _00454_ VPWR VGND sg13g2_nor2_1
X_22684_ coeff_force_packed\[50\] net471 _03068_ _00673_ VPWR VGND sg13g2_mux2_1
XFILLER_52_385 VPWR VGND sg13g2_decap_8
X_21635_ _02252_ net50 _02251_ VPWR VGND sg13g2_nand2_2
XFILLER_100_76 VPWR VGND sg13g2_decap_8
XFILLER_100_98 VPWR VGND sg13g2_decap_8
X_21566_ _02183_ _02091_ _02096_ VPWR VGND sg13g2_xnor2_1
XFILLER_60_58 VPWR VGND sg13g2_decap_8
X_23305_ net1296 VGND VPWR _00367_ u_LMS.w\[3\]\[7\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
X_20517_ _01157_ net608 net136 VPWR VGND sg13g2_nand2_1
X_21497_ _01919_ _01913_ _02114_ VPWR VGND sg13g2_xor2_1
XFILLER_114_4 VPWR VGND sg13g2_fill_1
X_23236_ net1416 VGND VPWR _00298_ u_LMS.w\[0\]\[7\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
XFILLER_106_321 VPWR VGND sg13g2_fill_1
X_20448_ VGND VPWR u_LMS.w\[5\]\[20\] net318 _01103_ _01094_ sg13g2_a21oi_1
X_23109__1628 VPWR VGND net1627 sg13g2_tiehi
X_23167_ net1538 VGND VPWR _00229_ u_FIR.w\[1\]\[5\] clknet_leaf_49_clkA sg13g2_dfrbpq_1
X_20379_ _00979_ VPWR _01042_ VGND _01040_ _01039_ sg13g2_o21ai_1
XFILLER_121_302 VPWR VGND sg13g2_fill_2
XFILLER_106_387 VPWR VGND sg13g2_decap_8
X_22118_ _02712_ _02709_ _02710_ VPWR VGND sg13g2_xnor2_1
XFILLER_122_847 VPWR VGND sg13g2_fill_2
X_23098_ net1059 VGND VPWR _00160_ u_FIR.sum\[6\]\[3\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
XFILLER_121_368 VPWR VGND sg13g2_fill_1
X_22049_ net2169 _02642_ _02643_ VPWR VGND sg13g2_nor2b_1
X_14940_ net268 _06221_ _06222_ VPWR VGND sg13g2_nor2b_1
XFILLER_0_687 VPWR VGND sg13g2_decap_4
XFILLER_88_794 VPWR VGND sg13g2_fill_1
XFILLER_48_636 VPWR VGND sg13g2_fill_1
X_14871_ _06124_ VPWR _06156_ VGND _03367_ net806 sg13g2_o21ai_1
X_16610_ VGND VPWR u_LMS.w\[4\]\[14\] _07793_ _07799_ _07794_ sg13g2_a21oi_1
X_13822_ _05117_ _05146_ _05147_ VPWR VGND sg13g2_nor2b_1
X_17590_ net121 _08722_ _08723_ VPWR VGND sg13g2_nor2b_1
XFILLER_90_425 VPWR VGND sg13g2_decap_8
X_16541_ net975 VPWR _07747_ VGND net481 u_FIR.w\[1\]\[6\] sg13g2_o21ai_1
X_13753_ VGND VPWR net535 _05078_ _00109_ _05079_ sg13g2_a21oi_1
X_12704_ _04069_ _04062_ _04067_ VPWR VGND sg13g2_xnor2_1
X_19260_ VPWR VGND _10330_ _08554_ net27 _03332_ _00365_ net368 sg13g2_a221oi_1
XFILLER_31_503 VPWR VGND sg13g2_fill_1
X_16472_ _07697_ net413 net881 VPWR VGND sg13g2_nand2_1
X_13684_ _05012_ _05006_ _05010_ VPWR VGND sg13g2_xnor2_1
XFILLER_71_694 VPWR VGND sg13g2_decap_8
XFILLER_16_599 VPWR VGND sg13g2_fill_2
X_18211_ _09321_ _09315_ _09320_ VPWR VGND sg13g2_nand2_1
XFILLER_93_9 VPWR VGND sg13g2_fill_1
XFILLER_54_1030 VPWR VGND sg13g2_fill_2
X_15423_ _06586_ _06686_ _06687_ VPWR VGND sg13g2_nor2_1
X_12635_ net855 u_FIR.sum\[0\]\[4\] net736 _04002_ VPWR VGND sg13g2_nand3_1
X_19191_ _10276_ net309 u_LMS.w\[3\]\[14\] coeff_force_packed\[23\] net559 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_31_558 VPWR VGND sg13g2_fill_1
XFILLER_34_92 VPWR VGND sg13g2_fill_1
X_18142_ _09251_ _09242_ _09252_ VPWR VGND sg13g2_xor2_1
X_15354_ _06621_ u_FIR.sum\[5\]\[12\] net394 VPWR VGND sg13g2_xnor2_1
X_12566_ _03937_ VPWR _03938_ VGND _03913_ _03929_ sg13g2_o21ai_1
X_14305_ _05611_ _05610_ _05609_ VPWR VGND sg13g2_nand2b_1
X_18073_ _09183_ _09179_ _09182_ VPWR VGND sg13g2_nand2_1
X_15285_ _06554_ u_FIR.sum\[5\]\[10\] net395 VPWR VGND sg13g2_nand2_1
X_12497_ _03872_ _03865_ _03870_ VPWR VGND sg13g2_xnor2_1
X_17024_ _08180_ _08173_ _08179_ VPWR VGND sg13g2_nand2_1
X_14236_ _05544_ _05527_ _05543_ VPWR VGND sg13g2_xnor2_1
X_14167_ _05446_ _05476_ _05477_ VPWR VGND sg13g2_and2_1
XFILLER_112_313 VPWR VGND sg13g2_fill_1
X_13118_ _04431_ _04467_ _04468_ VPWR VGND sg13g2_nor2_1
XFILLER_113_847 VPWR VGND sg13g2_decap_8
X_18975_ _10055_ VPWR _10062_ VGND _10051_ _10056_ sg13g2_o21ai_1
X_14098_ _05409_ net760 net878 VPWR VGND sg13g2_nand2_1
XFILLER_3_492 VPWR VGND sg13g2_decap_8
XFILLER_124_195 VPWR VGND sg13g2_fill_1
XFILLER_79_750 VPWR VGND sg13g2_fill_2
X_17926_ _09059_ net684 net158 VPWR VGND sg13g2_nand2_1
X_13049_ VGND VPWR _04401_ _04400_ _04376_ sg13g2_or2_1
XFILLER_78_271 VPWR VGND sg13g2_fill_1
XFILLER_38_102 VPWR VGND sg13g2_fill_2
XFILLER_67_956 VPWR VGND sg13g2_decap_8
X_17857_ _08990_ u_LMS.w\[1\]\[13\] _08989_ VPWR VGND sg13g2_nand2_1
XFILLER_82_915 VPWR VGND sg13g2_fill_2
X_16808_ _07963_ _07961_ _07943_ _07964_ VPWR VGND sg13g2_a21o_1
X_17788_ _08919_ _08906_ _08921_ VPWR VGND sg13g2_xor2_1
X_19527_ _10591_ _10587_ _10589_ VPWR VGND sg13g2_xnor2_1
X_16739_ u_FIR.sum\[8\]\[6\] _03378_ net1644 _07895_ VPWR VGND sg13g2_mux2_1
XFILLER_62_661 VPWR VGND sg13g2_decap_4
XFILLER_35_886 VPWR VGND sg13g2_fill_2
X_19458_ VGND VPWR net96 _10520_ _10522_ net118 sg13g2_a21oi_1
XFILLER_22_514 VPWR VGND sg13g2_decap_4
XFILLER_62_694 VPWR VGND sg13g2_decap_4
XFILLER_61_182 VPWR VGND sg13g2_decap_8
XFILLER_34_396 VPWR VGND sg13g2_decap_4
X_18409_ _09517_ _09518_ _09519_ VPWR VGND sg13g2_nor2_1
X_19389_ _10453_ _10452_ _10451_ VPWR VGND sg13g2_nand2b_1
X_21420_ _02037_ _01991_ _01992_ VPWR VGND sg13g2_xnor2_1
XFILLER_30_591 VPWR VGND sg13g2_decap_8
X_23228__1431 VPWR VGND net1430 sg13g2_tiehi
X_21351_ VPWR _01968_ _01967_ VGND sg13g2_inv_1
X_20302_ _10962_ _11013_ _00965_ VPWR VGND sg13g2_nor2_1
X_21282_ _01899_ _01896_ _01898_ VPWR VGND sg13g2_nand2_1
XFILLER_2_908 VPWR VGND sg13g2_fill_2
X_23021_ net1174 VGND VPWR _00083_ u_FIR.sum\[2\]\[2\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
X_20233_ _00895_ _00893_ _00896_ VPWR VGND sg13g2_xor2_1
XFILLER_118_1024 VPWR VGND sg13g2_decap_8
XFILLER_39_15 VPWR VGND sg13g2_fill_1
X_20164_ _00827_ _00825_ _00826_ VPWR VGND sg13g2_xnor2_1
XFILLER_77_709 VPWR VGND sg13g2_decap_8
XFILLER_39_59 VPWR VGND sg13g2_fill_2
X_20095_ _11134_ _11133_ _11136_ VPWR VGND sg13g2_xor2_1
XFILLER_57_400 VPWR VGND sg13g2_fill_1
XFILLER_97_580 VPWR VGND sg13g2_fill_1
XFILLER_84_241 VPWR VGND sg13g2_fill_2
XFILLER_85_797 VPWR VGND sg13g2_decap_8
X_22805_ VGND VPWR _07842_ net351 _00742_ _03120_ sg13g2_a21oi_1
XFILLER_26_853 VPWR VGND sg13g2_decap_8
X_20997_ _01635_ _01569_ _01636_ _01637_ VPWR VGND sg13g2_a21o_1
XFILLER_53_650 VPWR VGND sg13g2_fill_1
XFILLER_41_801 VPWR VGND sg13g2_fill_2
X_22736_ u_debug_unit.mon_w1_sync\[5\] net330 _03086_ VPWR VGND sg13g2_nor2_1
XFILLER_40_300 VPWR VGND sg13g2_decap_4
XFILLER_80_480 VPWR VGND sg13g2_fill_1
XFILLER_53_694 VPWR VGND sg13g2_fill_2
XFILLER_38_1058 VPWR VGND sg13g2_fill_2
XFILLER_40_333 VPWR VGND sg13g2_decap_8
X_22667_ coeff_force_packed\[37\] net468 _03066_ _00658_ VPWR VGND sg13g2_mux2_1
X_12420_ net854 _03796_ net719 _03797_ VPWR VGND sg13g2_nand3_1
X_21618_ _02235_ u_LMS.w\[7\]\[20\] net62 VPWR VGND sg13g2_nand2_1
X_22598_ net462 u_debug_unit.sw_reset\[5\] _03058_ _00597_ VPWR VGND sg13g2_mux2_1
XFILLER_127_917 VPWR VGND sg13g2_fill_2
X_12351_ _03730_ _03724_ _03728_ VPWR VGND sg13g2_xnor2_1
X_21549_ u_LMS.w\[7\]\[14\] _02165_ _02166_ VPWR VGND sg13g2_and2_1
X_15070_ _06344_ net781 net846 VPWR VGND sg13g2_nand2_1
XFILLER_107_630 VPWR VGND sg13g2_decap_8
X_12282_ _03663_ _03656_ _03662_ VPWR VGND sg13g2_nand2_1
XFILLER_105_0 VPWR VGND sg13g2_fill_2
X_14021_ _05335_ _05326_ _05333_ VPWR VGND sg13g2_xnor2_1
X_23219_ net1446 VGND VPWR _00281_ u_LMS.w\[0\]\[13\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
XFILLER_5_779 VPWR VGND sg13g2_fill_1
XFILLER_122_633 VPWR VGND sg13g2_decap_8
XFILLER_122_644 VPWR VGND sg13g2_fill_2
XFILLER_122_655 VPWR VGND sg13g2_fill_2
XFILLER_95_506 VPWR VGND sg13g2_decap_8
XFILLER_49_901 VPWR VGND sg13g2_fill_2
X_23496__1427 VPWR VGND net1426 sg13g2_tiehi
X_18760_ net423 _03252_ net177 net218 _09847_ VPWR VGND sg13g2_nor4_1
XFILLER_110_839 VPWR VGND sg13g2_fill_1
X_15972_ _07204_ _07193_ _07213_ _07215_ VPWR VGND sg13g2_a21o_1
XFILLER_88_580 VPWR VGND sg13g2_decap_8
XFILLER_1_996 VPWR VGND sg13g2_decap_8
XFILLER_48_422 VPWR VGND sg13g2_decap_8
X_17711_ _08834_ VPWR _08844_ VGND _08801_ _08832_ sg13g2_o21ai_1
X_14923_ _06206_ _06159_ _06204_ VPWR VGND sg13g2_xnor2_1
X_18691_ _09775_ _09777_ _09778_ VPWR VGND sg13g2_nor2_1
XFILLER_49_989 VPWR VGND sg13g2_fill_1
X_17642_ _08775_ net689 net205 VPWR VGND sg13g2_nand2_1
X_14854_ _06134_ _06139_ _06140_ VPWR VGND sg13g2_nor2b_1
XFILLER_75_274 VPWR VGND sg13g2_fill_1
X_13805_ _05130_ _05122_ _05129_ VPWR VGND sg13g2_nand2_1
XFILLER_17_842 VPWR VGND sg13g2_fill_2
X_17573_ _08706_ _08705_ _08701_ VPWR VGND sg13g2_nand2b_1
X_14785_ _06073_ _06072_ _06031_ VPWR VGND sg13g2_nand2b_1
X_11997_ VPWR _03414_ _03413_ VGND sg13g2_inv_1
X_19312_ net424 net133 _10376_ VPWR VGND sg13g2_nor2_1
X_16524_ net975 VPWR _07736_ VGND net479 net791 sg13g2_o21ai_1
X_13736_ VPWR _05063_ _05062_ VGND sg13g2_inv_1
XFILLER_91_1016 VPWR VGND sg13g2_fill_2
XFILLER_17_897 VPWR VGND sg13g2_fill_2
XFILLER_16_374 VPWR VGND sg13g2_fill_1
X_19243_ VGND VPWR _10316_ _10317_ _00361_ net920 sg13g2_a21oi_1
XFILLER_43_193 VPWR VGND sg13g2_decap_4
X_16455_ _07683_ _07673_ _07682_ VPWR VGND sg13g2_nand2_1
X_13667_ _04962_ _04995_ _04996_ VPWR VGND sg13g2_nor2_1
X_15406_ _06671_ _06670_ _06649_ VPWR VGND sg13g2_nand2b_1
X_19174_ _10261_ net717 net67 VPWR VGND sg13g2_nand2_1
X_12618_ _03963_ _03983_ _03960_ _03986_ VPWR VGND sg13g2_nand3_1
X_16386_ _07618_ _07591_ _07616_ VPWR VGND sg13g2_xnor2_1
X_13598_ _04928_ _04927_ _04889_ VPWR VGND sg13g2_nand2b_1
X_23173__1528 VPWR VGND net1527 sg13g2_tiehi
X_23201__1479 VPWR VGND net1478 sg13g2_tiehi
X_18125_ _09234_ _09224_ _09235_ VPWR VGND sg13g2_xor2_1
X_15337_ VGND VPWR _06571_ _06596_ _06604_ _06595_ sg13g2_a21oi_1
X_12549_ _03920_ _03832_ _03922_ VPWR VGND sg13g2_xor2_1
XFILLER_117_405 VPWR VGND sg13g2_fill_2
XFILLER_118_939 VPWR VGND sg13g2_fill_1
XFILLER_8_584 VPWR VGND sg13g2_decap_4
XANTENNA_1 VPWR VGND u_FIR.x_reg\[2\] sg13g2_antennanp
X_18056_ VGND VPWR net37 _09167_ _00323_ _09168_ sg13g2_a21oi_1
X_15268_ _06537_ _06506_ _06536_ VPWR VGND sg13g2_nand2b_1
XFILLER_6_63 VPWR VGND sg13g2_decap_8
X_17007_ _08132_ _08162_ _08163_ VPWR VGND sg13g2_nor2_1
X_14219_ _05495_ _05488_ _05503_ _05527_ VPWR VGND sg13g2_a21o_1
XFILLER_132_419 VPWR VGND sg13g2_decap_8
X_15199_ _06463_ _06469_ _06470_ VPWR VGND sg13g2_nor2b_1
XFILLER_125_460 VPWR VGND sg13g2_fill_2
XFILLER_113_622 VPWR VGND sg13g2_decap_8
XFILLER_113_633 VPWR VGND sg13g2_fill_2
XFILLER_113_644 VPWR VGND sg13g2_decap_4
Xfanout508 net514 net508 VPWR VGND sg13g2_buf_1
XFILLER_112_132 VPWR VGND sg13g2_fill_2
Xfanout519 net520 net519 VPWR VGND sg13g2_buf_1
XFILLER_112_143 VPWR VGND sg13g2_fill_1
XFILLER_99_889 VPWR VGND sg13g2_decap_8
X_18958_ _10043_ _10044_ _10045_ VPWR VGND sg13g2_nor2_1
XFILLER_100_316 VPWR VGND sg13g2_decap_8
XFILLER_86_539 VPWR VGND sg13g2_decap_8
XFILLER_20_0 VPWR VGND sg13g2_decap_8
XFILLER_79_591 VPWR VGND sg13g2_fill_2
X_17909_ _09042_ _03348_ _08986_ VPWR VGND sg13g2_nand2_1
X_18889_ _09975_ _09974_ _09976_ VPWR VGND sg13g2_nor2b_1
XFILLER_55_915 VPWR VGND sg13g2_decap_8
X_20920_ VPWR _01560_ net74 VGND sg13g2_inv_1
XFILLER_54_403 VPWR VGND sg13g2_fill_2
XFILLER_26_105 VPWR VGND sg13g2_decap_8
XFILLER_27_639 VPWR VGND sg13g2_decap_4
XFILLER_82_745 VPWR VGND sg13g2_fill_1
X_20851_ _01482_ VPWR _01491_ VGND _01483_ _01485_ sg13g2_o21ai_1
XFILLER_35_650 VPWR VGND sg13g2_fill_1
XFILLER_41_108 VPWR VGND sg13g2_decap_4
X_23570_ net986 VGND VPWR _00632_ coeff_force_packed\[14\] clknet_leaf_54_clkA sg13g2_dfrbpq_1
X_20782_ _01422_ _01393_ _01382_ VPWR VGND sg13g2_xnor2_1
XFILLER_81_299 VPWR VGND sg13g2_fill_1
X_22521_ _03014_ u_LMS.count\[6\] u_LMS.count\[5\] _03009_ VPWR VGND sg13g2_and3_1
X_22452_ VGND VPWR net444 _03243_ _00534_ _02975_ sg13g2_a21oi_1
XFILLER_50_697 VPWR VGND sg13g2_fill_1
X_21403_ _01934_ _02019_ _02020_ VPWR VGND sg13g2_nor2b_1
XFILLER_109_939 VPWR VGND sg13g2_decap_8
X_22383_ net962 VPWR _02941_ VGND net452 net690 sg13g2_o21ai_1
X_21334_ _01951_ _01950_ _01944_ VPWR VGND sg13g2_nand2b_1
X_23402__1143 VPWR VGND net1142 sg13g2_tiehi
X_21265_ _01882_ _01879_ _01880_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_7 VPWR VGND sg13g2_decap_8
X_23004_ net1200 VGND VPWR _00066_ u_FIR.sum\[1\]\[1\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
X_20216_ _00879_ _00848_ _00856_ VPWR VGND sg13g2_xnor2_1
X_21196_ net591 net149 net589 _01813_ VPWR VGND net93 sg13g2_nand4_1
X_23435__1044 VPWR VGND net sg13g2_tiehi
XFILLER_132_975 VPWR VGND sg13g2_decap_8
X_20147_ _11188_ _11153_ _11186_ VPWR VGND sg13g2_xnor2_1
XFILLER_106_64 VPWR VGND sg13g2_decap_4
XFILLER_103_198 VPWR VGND sg13g2_decap_8
X_20078_ _11119_ _11117_ _11118_ VPWR VGND sg13g2_nand2_1
XFILLER_46_904 VPWR VGND sg13g2_decap_8
X_11920_ VPWR _03341_ u_LMS.w\[2\]\[24\] VGND sg13g2_inv_1
XFILLER_46_937 VPWR VGND sg13g2_fill_1
XFILLER_18_628 VPWR VGND sg13g2_decap_4
XFILLER_85_583 VPWR VGND sg13g2_fill_1
XFILLER_57_285 VPWR VGND sg13g2_decap_8
XFILLER_45_425 VPWR VGND sg13g2_decap_4
XFILLER_57_296 VPWR VGND sg13g2_fill_2
XFILLER_17_127 VPWR VGND sg13g2_fill_1
X_11851_ VPWR _03272_ net696 VGND sg13g2_inv_1
XFILLER_17_149 VPWR VGND sg13g2_decap_4
XFILLER_72_244 VPWR VGND sg13g2_decap_8
X_14570_ VGND VPWR _05863_ _05861_ _05829_ sg13g2_or2_1
XFILLER_54_981 VPWR VGND sg13g2_fill_2
X_23768_ net994 VGND VPWR _00001_ u_spi_slave.rx_shift\[10\] clknet_3_2__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_25_160 VPWR VGND sg13g2_decap_4
XFILLER_82_67 VPWR VGND sg13g2_fill_2
XFILLER_60_439 VPWR VGND sg13g2_fill_2
X_23320__1282 VPWR VGND net1281 sg13g2_tiehi
X_13521_ _04852_ _04853_ _04854_ VPWR VGND sg13g2_nor2b_1
X_22719_ VGND VPWR _07721_ net336 _00699_ _03077_ sg13g2_a21oi_1
X_23699_ net1523 VGND VPWR _00761_ u_p2s_output.reg_sh\[0\] clknet_leaf_59_clkA sg13g2_dfrbpq_1
XFILLER_13_355 VPWR VGND sg13g2_decap_8
XFILLER_13_366 VPWR VGND sg13g2_fill_1
XFILLER_41_686 VPWR VGND sg13g2_decap_4
X_16240_ _07441_ _07476_ _07477_ VPWR VGND sg13g2_nor2_1
X_13452_ _04744_ _04790_ _04643_ _04792_ VPWR VGND sg13g2_nand3_1
XFILLER_41_697 VPWR VGND sg13g2_fill_1
X_12403_ _03751_ _03780_ _03781_ VPWR VGND sg13g2_and2_1
XFILLER_51_1055 VPWR VGND sg13g2_fill_2
X_16171_ net860 _07408_ net793 _07409_ VPWR VGND sg13g2_nand3_1
X_13383_ _04726_ _04725_ _04692_ VPWR VGND sg13g2_nand2b_1
XFILLER_127_736 VPWR VGND sg13g2_decap_8
X_15122_ _06393_ _06394_ _06395_ VPWR VGND sg13g2_nor2_1
X_12334_ VGND VPWR _03650_ _03705_ _03713_ _03704_ sg13g2_a21oi_1
XFILLER_31_71 VPWR VGND sg13g2_fill_2
XFILLER_31_93 VPWR VGND sg13g2_decap_8
X_19930_ _10971_ _10963_ _10970_ VPWR VGND sg13g2_nand2_1
X_15053_ _06328_ _06319_ _06326_ VPWR VGND sg13g2_xnor2_1
X_12265_ VGND VPWR _03609_ _03640_ _03646_ _03639_ sg13g2_a21oi_1
X_14004_ _05317_ _05316_ _05319_ VPWR VGND sg13g2_xor2_1
X_19861_ net358 VPWR _10911_ VGND u_LMS.w\[4\]\[3\] net373 sg13g2_o21ai_1
X_12196_ u_LMS.count\[26\] u_LMS.count\[25\] u_LMS.count\[24\] u_LMS.count\[23\] _03584_
+ VPWR VGND sg13g2_nor4_1
XFILLER_96_804 VPWR VGND sg13g2_fill_2
X_18812_ _09899_ _09896_ _09897_ VPWR VGND sg13g2_xnor2_1
XFILLER_122_463 VPWR VGND sg13g2_decap_4
X_19792_ net26 VPWR _10856_ VGND _10853_ net25 sg13g2_o21ai_1
XFILLER_95_336 VPWR VGND sg13g2_fill_1
XFILLER_49_731 VPWR VGND sg13g2_fill_2
XFILLER_0_270 VPWR VGND sg13g2_decap_8
X_18743_ _09830_ net654 net146 VPWR VGND sg13g2_nand2_1
X_15955_ VGND VPWR _07179_ _07182_ _07199_ _07197_ sg13g2_a21oi_1
XFILLER_49_786 VPWR VGND sg13g2_fill_1
X_14906_ _06182_ _06189_ _06190_ VPWR VGND sg13g2_nor2b_1
XFILLER_36_403 VPWR VGND sg13g2_fill_2
X_18674_ _09761_ net165 net655 net176 net653 VPWR VGND sg13g2_a22oi_1
XFILLER_36_414 VPWR VGND sg13g2_fill_1
X_15886_ _07132_ net274 _07133_ VPWR VGND sg13g2_xor2_1
XFILLER_63_222 VPWR VGND sg13g2_decap_4
X_17625_ _08750_ VPWR _08758_ VGND _08751_ _08757_ sg13g2_o21ai_1
XFILLER_91_542 VPWR VGND sg13g2_fill_1
X_14837_ VGND VPWR _06091_ _06095_ _06123_ _06094_ sg13g2_a21oi_1
XFILLER_63_244 VPWR VGND sg13g2_fill_1
XFILLER_52_929 VPWR VGND sg13g2_fill_2
XFILLER_17_661 VPWR VGND sg13g2_fill_1
X_17556_ _08682_ VPWR _08689_ VGND _08597_ _08683_ sg13g2_o21ai_1
XFILLER_16_160 VPWR VGND sg13g2_fill_2
X_14768_ _06056_ _06014_ _06017_ VPWR VGND sg13g2_nand2_1
XFILLER_32_631 VPWR VGND sg13g2_fill_2
X_16507_ VGND VPWR net475 _07721_ _00220_ _07722_ sg13g2_a21oi_1
XFILLER_32_642 VPWR VGND sg13g2_fill_2
X_13719_ _05046_ net750 net839 VPWR VGND sg13g2_nand2_1
XFILLER_60_962 VPWR VGND sg13g2_decap_8
X_17487_ _08620_ _08608_ _08619_ VPWR VGND sg13g2_xnor2_1
X_14699_ _05989_ _05970_ _05987_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_675 VPWR VGND sg13g2_decap_8
X_19226_ _10304_ _10302_ _10303_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_686 VPWR VGND sg13g2_fill_1
X_16438_ VGND VPWR _07629_ _07651_ _07667_ _07650_ sg13g2_a21oi_1
X_19157_ net68 VPWR _10244_ VGND u_LMS.w\[3\]\[19\] u_LMS.w\[3\]\[18\] sg13g2_o21ai_1
X_16369_ _07602_ _07583_ _07600_ VPWR VGND sg13g2_xnor2_1
X_18108_ _09216_ _09217_ _09218_ VPWR VGND sg13g2_nor2b_1
XFILLER_117_224 VPWR VGND sg13g2_decap_8
XFILLER_68_0 VPWR VGND sg13g2_fill_1
XFILLER_117_235 VPWR VGND sg13g2_fill_1
X_19088_ u_LMS.w\[3\]\[16\] _10174_ _10175_ VPWR VGND sg13g2_and2_1
X_23119__1611 VPWR VGND net1610 sg13g2_tiehi
X_18039_ VGND VPWR _09147_ _09155_ _00318_ _09156_ sg13g2_a21oi_1
XFILLER_67_1040 VPWR VGND sg13g2_fill_2
XFILLER_132_227 VPWR VGND sg13g2_decap_8
X_21050_ net17 VPWR _01684_ VGND net15 _01683_ sg13g2_o21ai_1
Xfanout305 net306 net305 VPWR VGND sg13g2_buf_1
Xfanout316 net319 net316 VPWR VGND sg13g2_buf_1
X_20001_ _11035_ _11041_ _11042_ VPWR VGND sg13g2_nor2b_1
XFILLER_113_463 VPWR VGND sg13g2_fill_2
Xfanout327 _03397_ net327 VPWR VGND sg13g2_buf_1
Xfanout338 net353 net338 VPWR VGND sg13g2_buf_1
Xfanout349 net352 net349 VPWR VGND sg13g2_buf_1
XFILLER_115_1027 VPWR VGND sg13g2_fill_2
XFILLER_101_636 VPWR VGND sg13g2_decap_8
XFILLER_113_496 VPWR VGND sg13g2_decap_8
XFILLER_100_135 VPWR VGND sg13g2_fill_2
XFILLER_100_157 VPWR VGND sg13g2_decap_8
XFILLER_67_550 VPWR VGND sg13g2_decap_4
XFILLER_67_572 VPWR VGND sg13g2_decap_4
XFILLER_55_712 VPWR VGND sg13g2_fill_1
X_21952_ _02546_ _02541_ _02544_ VPWR VGND sg13g2_xnor2_1
XFILLER_54_200 VPWR VGND sg13g2_fill_2
X_23377__1218 VPWR VGND net1217 sg13g2_tiehi
X_20903_ VPWR VGND _01539_ _01541_ _01535_ _01266_ _01543_ _01268_ sg13g2_a221oi_1
X_21883_ _02477_ _02474_ _02475_ VPWR VGND sg13g2_xnor2_1
XFILLER_54_255 VPWR VGND sg13g2_decap_4
XFILLER_82_575 VPWR VGND sg13g2_decap_8
X_23622_ net955 VGND VPWR _00684_ coeff_force_packed\[60\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
XFILLER_14_108 VPWR VGND sg13g2_fill_1
X_20834_ _01474_ _01473_ _01472_ VPWR VGND sg13g2_nand2b_1
XFILLER_42_428 VPWR VGND sg13g2_decap_8
XFILLER_23_642 VPWR VGND sg13g2_fill_2
X_23553_ net1010 VGND VPWR _00615_ sys_enable_bus\[7\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
XFILLER_52_26 VPWR VGND sg13g2_decap_8
X_20765_ _01405_ net613 net209 VPWR VGND sg13g2_nand2_1
XFILLER_22_130 VPWR VGND sg13g2_decap_4
X_22504_ _03000_ _03001_ _03002_ _00559_ VPWR VGND sg13g2_nor3_1
XFILLER_51_995 VPWR VGND sg13g2_fill_2
XFILLER_50_472 VPWR VGND sg13g2_fill_2
X_23484_ net1469 VGND VPWR _00546_ u_LMS.x_r\[7\]\[3\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
XFILLER_11_848 VPWR VGND sg13g2_decap_4
X_20696_ _01335_ _01313_ _01336_ VPWR VGND sg13g2_xor2_1
XFILLER_109_703 VPWR VGND sg13g2_fill_2
XFILLER_109_714 VPWR VGND sg13g2_decap_8
X_22435_ net957 VPWR _02967_ VGND net437 net640 sg13g2_o21ai_1
X_22366_ VGND VPWR net455 _03286_ _00491_ _02932_ sg13g2_a21oi_1
XFILLER_108_257 VPWR VGND sg13g2_decap_4
X_21317_ _01934_ net594 net266 VPWR VGND sg13g2_nand2_1
X_22297_ _02882_ u_LMS.w\[8\]\[21\] net2166 VPWR VGND sg13g2_xnor2_1
XFILLER_117_30 VPWR VGND sg13g2_fill_2
X_12050_ _03463_ _03422_ _03464_ _03465_ VPWR VGND sg13g2_a21o_1
X_21248_ _01865_ net199 net589 net225 net592 VPWR VGND sg13g2_a22oi_1
XFILLER_117_52 VPWR VGND sg13g2_decap_8
XFILLER_104_441 VPWR VGND sg13g2_fill_1
XFILLER_117_63 VPWR VGND sg13g2_fill_2
XFILLER_105_975 VPWR VGND sg13g2_fill_2
Xrebuffer2070 net2155 net2069 VPWR VGND sg13g2_buf_2
XFILLER_81_1026 VPWR VGND sg13g2_fill_1
XFILLER_104_463 VPWR VGND sg13g2_decap_8
Xrebuffer2081 _10168_ net2080 VPWR VGND sg13g2_buf_2
XFILLER_132_772 VPWR VGND sg13g2_decap_8
X_21179_ _01796_ net83 net591 net100 net589 VPWR VGND sg13g2_a22oi_1
Xrebuffer2092 _09658_ net2091 VPWR VGND sg13g2_buf_1
XFILLER_120_934 VPWR VGND sg13g2_decap_4
X_23338__1264 VPWR VGND net1263 sg13g2_tiehi
XFILLER_131_271 VPWR VGND sg13g2_decap_8
Xfanout850 u_FIR.x_reg\[4\] net850 VPWR VGND sg13g2_buf_1
XFILLER_131_282 VPWR VGND sg13g2_decap_8
Xfanout861 net871 net861 VPWR VGND sg13g2_buf_1
Xfanout872 net874 net872 VPWR VGND sg13g2_buf_1
Xfanout883 net884 net883 VPWR VGND sg13g2_buf_1
XFILLER_120_989 VPWR VGND sg13g2_decap_8
Xfanout894 net895 net894 VPWR VGND sg13g2_buf_1
XFILLER_92_317 VPWR VGND sg13g2_fill_2
X_15740_ _06991_ net819 _06990_ VPWR VGND sg13g2_nand2_1
X_12952_ net1040 VPWR _04311_ VGND net546 u_FIR.sum\[1\]\[12\] sg13g2_o21ai_1
X_11903_ VPWR _03324_ u_LMS.w\[4\]\[24\] VGND sg13g2_inv_1
XFILLER_46_767 VPWR VGND sg13g2_fill_2
X_15671_ _06923_ _06920_ _06924_ VPWR VGND sg13g2_nor2b_1
XFILLER_46_778 VPWR VGND sg13g2_fill_2
X_12883_ VPWR _04244_ _04243_ VGND sg13g2_inv_1
XFILLER_45_255 VPWR VGND sg13g2_fill_1
X_17410_ net567 net933 _08553_ VPWR VGND sg13g2_nor2_1
XFILLER_60_203 VPWR VGND sg13g2_fill_1
X_14622_ _05914_ _05913_ _05872_ VPWR VGND sg13g2_nand2b_1
XFILLER_93_99 VPWR VGND sg13g2_fill_1
X_18390_ _09500_ net681 net218 VPWR VGND sg13g2_nand2_1
X_11834_ VPWR _03255_ net660 VGND sg13g2_inv_1
XFILLER_26_93 VPWR VGND sg13g2_decap_4
X_17341_ _08395_ _08487_ _03353_ _08497_ VPWR VGND sg13g2_nand3_1
X_14553_ _05847_ _05825_ _05845_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_101 VPWR VGND sg13g2_fill_2
XFILLER_41_461 VPWR VGND sg13g2_decap_8
X_13504_ VGND VPWR net516 _04836_ _00102_ _04837_ sg13g2_a21oi_1
X_17272_ _08428_ _08306_ _08334_ VPWR VGND sg13g2_xnor2_1
XFILLER_14_697 VPWR VGND sg13g2_fill_2
X_14484_ VGND VPWR net773 net890 _05781_ u_FIR.sum\[4\]\[1\] sg13g2_a21oi_1
X_19011_ _10097_ _10095_ _10098_ VPWR VGND sg13g2_xor2_1
X_16223_ _07454_ _07459_ _07460_ VPWR VGND sg13g2_nor2b_1
X_13435_ _04776_ _04766_ _04775_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_178 VPWR VGND sg13g2_decap_8
XFILLER_10_870 VPWR VGND sg13g2_fill_1
X_16154_ _07392_ _07384_ _07393_ VPWR VGND sg13g2_xor2_1
X_13366_ _04695_ VPWR _04709_ VGND net283 _04693_ sg13g2_o21ai_1
XFILLER_61_7 VPWR VGND sg13g2_decap_4
X_15105_ _06378_ _06377_ _06339_ VPWR VGND sg13g2_nand2b_1
XFILLER_5_351 VPWR VGND sg13g2_fill_2
X_12317_ _03697_ _03663_ _03695_ VPWR VGND sg13g2_xnor2_1
X_16085_ _07321_ VPWR _07325_ VGND _07290_ _07322_ sg13g2_o21ai_1
X_13297_ net813 _04609_ u_FIR.w\[6\]\[1\] _04642_ VPWR VGND _04639_ sg13g2_nand4_1
X_19913_ _10954_ net86 _10952_ VPWR VGND sg13g2_nand2b_1
X_15036_ _06311_ net781 net859 VPWR VGND sg13g2_nand2_1
X_12248_ _03630_ _03624_ _03629_ VPWR VGND sg13g2_xnor2_1
XFILLER_69_815 VPWR VGND sg13g2_fill_2
XFILLER_123_761 VPWR VGND sg13g2_decap_8
X_19844_ VGND VPWR _10896_ _10897_ _00382_ net931 sg13g2_a21oi_1
X_12179_ net944 u_spi_slave.rx_shift\[9\] _00001_ VPWR VGND sg13g2_nor2b_1
XFILLER_3_42 VPWR VGND sg13g2_decap_8
XFILLER_123_794 VPWR VGND sg13g2_decap_8
XFILLER_122_271 VPWR VGND sg13g2_fill_2
X_19775_ _10838_ VPWR _10839_ VGND _10832_ _10833_ sg13g2_o21ai_1
X_16987_ _08143_ net706 net172 VPWR VGND sg13g2_nand2_1
Xclkbuf_leaf_15_clkA clknet_4_9_0_clkA clknet_leaf_15_clkA VPWR VGND sg13g2_buf_8
XFILLER_83_306 VPWR VGND sg13g2_fill_1
XFILLER_77_870 VPWR VGND sg13g2_decap_8
X_18726_ _09813_ net80 net654 net98 net653 VPWR VGND sg13g2_a22oi_1
XFILLER_114_1060 VPWR VGND sg13g2_fill_1
XFILLER_110_499 VPWR VGND sg13g2_fill_2
X_15938_ _07183_ _07182_ _07181_ VPWR VGND sg13g2_nand2b_1
XFILLER_97_1011 VPWR VGND sg13g2_fill_2
XFILLER_92_840 VPWR VGND sg13g2_decap_8
X_18657_ VGND VPWR net56 _09747_ _09748_ net32 sg13g2_a21oi_1
XFILLER_58_1006 VPWR VGND sg13g2_decap_8
XFILLER_37_767 VPWR VGND sg13g2_fill_2
X_15869_ VGND VPWR net495 _07115_ _00188_ _07116_ sg13g2_a21oi_1
X_17608_ _03272_ net99 _08741_ VPWR VGND sg13g2_nor2_1
XFILLER_92_895 VPWR VGND sg13g2_fill_2
X_18588_ _09694_ net2106 _09655_ VPWR VGND sg13g2_xnor2_1
XFILLER_51_225 VPWR VGND sg13g2_decap_8
X_17539_ net419 _03268_ net177 net220 _08672_ VPWR VGND sg13g2_nor4_1
XFILLER_51_258 VPWR VGND sg13g2_decap_8
XFILLER_33_962 VPWR VGND sg13g2_fill_1
XFILLER_51_269 VPWR VGND sg13g2_fill_1
XFILLER_60_770 VPWR VGND sg13g2_decap_4
XFILLER_32_461 VPWR VGND sg13g2_decap_8
X_23019__1178 VPWR VGND net1177 sg13g2_tiehi
X_20550_ net152 VPWR _01190_ VGND net618 net620 sg13g2_o21ai_1
XFILLER_60_792 VPWR VGND sg13g2_fill_2
X_19209_ _10243_ _10289_ _10290_ VPWR VGND sg13g2_nor2b_1
X_20481_ _01127_ _01128_ _00410_ VPWR VGND sg13g2_nor2_1
XFILLER_121_1031 VPWR VGND sg13g2_decap_8
X_22220_ VGND VPWR _02811_ _02812_ _02814_ _02768_ sg13g2_a21oi_1
X_22151_ _02407_ _02744_ _02389_ _02745_ VPWR VGND sg13g2_nand3_1
XFILLER_118_588 VPWR VGND sg13g2_fill_1
X_23526__1315 VPWR VGND net1314 sg13g2_tiehi
X_21102_ net361 VPWR _01725_ VGND u_LMS.w\[6\]\[6\] net378 sg13g2_o21ai_1
XFILLER_105_249 VPWR VGND sg13g2_fill_1
X_22082_ _02676_ net255 net580 net240 net582 VPWR VGND sg13g2_a22oi_1
XFILLER_114_750 VPWR VGND sg13g2_fill_2
XFILLER_102_901 VPWR VGND sg13g2_fill_2
X_23283__1328 VPWR VGND net1327 sg13g2_tiehi
XFILLER_114_761 VPWR VGND sg13g2_decap_4
Xfanout102 net102 net104 VPWR VGND sg13g2_buf_4
XFILLER_120_208 VPWR VGND sg13g2_decap_4
X_21033_ VGND VPWR _01669_ _01670_ _00420_ net938 sg13g2_a21oi_1
Xfanout113 net114 net113 VPWR VGND sg13g2_buf_2
Xfanout124 net124 _07972_ VPWR VGND sg13g2_buf_16
XFILLER_59_314 VPWR VGND sg13g2_decap_8
Xfanout135 net137 net135 VPWR VGND sg13g2_buf_2
XFILLER_113_271 VPWR VGND sg13g2_decap_4
Xfanout146 net148 net146 VPWR VGND sg13g2_buf_1
Xfanout157 _07987_ net157 VPWR VGND sg13g2_buf_1
Xfanout168 net175 net168 VPWR VGND sg13g2_buf_1
Xfanout179 net181 net179 VPWR VGND sg13g2_buf_2
XFILLER_47_37 VPWR VGND sg13g2_fill_2
XFILLER_41_1032 VPWR VGND sg13g2_fill_2
X_22984_ net996 VGND VPWR _00046_ u_spi_slave.tx_shift\[14\] net1634 sg13g2_dfrbpq_1
XFILLER_28_745 VPWR VGND sg13g2_decap_4
XFILLER_27_211 VPWR VGND sg13g2_decap_8
X_21935_ _02529_ net575 net242 VPWR VGND sg13g2_nand2_1
XFILLER_16_929 VPWR VGND sg13g2_fill_2
XFILLER_70_501 VPWR VGND sg13g2_decap_8
XFILLER_82_372 VPWR VGND sg13g2_fill_2
XFILLER_15_428 VPWR VGND sg13g2_decap_4
X_21866_ _02460_ net576 net185 VPWR VGND sg13g2_nand2_1
XFILLER_82_394 VPWR VGND sg13g2_fill_2
X_20817_ _01457_ net613 net261 VPWR VGND sg13g2_nand2_1
X_23605_ net1015 VGND VPWR _00667_ coeff_force_packed\[45\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
XFILLER_24_962 VPWR VGND sg13g2_fill_2
X_21797_ _02391_ net84 net573 net100 net571 VPWR VGND sg13g2_a22oi_1
X_20748_ _01376_ VPWR _01388_ VGND _01335_ _01372_ sg13g2_o21ai_1
X_23183__1511 VPWR VGND net1510 sg13g2_tiehi
X_23211__1462 VPWR VGND net1461 sg13g2_tiehi
X_23536_ net1013 VGND VPWR _00598_ u_debug_unit.sw_reset\[6\] clknet_leaf_37_clkA
+ sg13g2_dfrbpq_1
XFILLER_128_319 VPWR VGND sg13g2_decap_8
X_23467_ net1528 VGND VPWR _00529_ u_LMS.x_r\[5\]\[2\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
X_20679_ _01311_ VPWR _01319_ VGND _01317_ _01318_ sg13g2_o21ai_1
X_13220_ _04567_ _04559_ _04566_ VPWR VGND sg13g2_xnor2_1
X_22418_ VGND VPWR net432 _03260_ _00517_ _02958_ sg13g2_a21oi_1
XFILLER_12_40 VPWR VGND sg13g2_fill_1
X_23398_ net1154 VGND VPWR _00460_ u_LMS.w\[7\]\[8\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
X_23218__1449 VPWR VGND net1448 sg13g2_tiehi
X_13151_ _04500_ u_FIR.w\[6\]\[6\] _04499_ VPWR VGND sg13g2_xnor2_1
X_22349_ _02922_ _02805_ _02807_ VPWR VGND sg13g2_xnor2_1
XFILLER_3_833 VPWR VGND sg13g2_decap_4
X_12102_ _03514_ _03412_ u_debug_unit.mon_w6_sync\[3\] _03404_ u_debug_unit.mon_w7_sync\[3\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_128_84 VPWR VGND sg13g2_decap_8
X_13082_ _04432_ _04405_ _04433_ VPWR VGND sg13g2_xor2_1
Xclkbuf_leaf_38_clkA clknet_4_6_0_clkA clknet_leaf_38_clkA VPWR VGND sg13g2_buf_8
XFILLER_3_888 VPWR VGND sg13g2_decap_8
X_16910_ _08046_ _08064_ _08044_ _08066_ VPWR VGND sg13g2_nand3_1
X_12033_ _03445_ _03449_ _03450_ VPWR VGND sg13g2_nor2_1
X_17890_ _09022_ _09021_ _09023_ VPWR VGND sg13g2_nor2b_1
XFILLER_77_122 VPWR VGND sg13g2_fill_2
X_16841_ VGND VPWR net86 _07994_ _07997_ _07996_ sg13g2_a21oi_1
XFILLER_77_144 VPWR VGND sg13g2_fill_1
XFILLER_38_509 VPWR VGND sg13g2_fill_2
Xfanout680 u_LMS.x_r\[2\]\[1\] net680 VPWR VGND sg13g2_buf_1
Xfanout691 u_LMS.x_r\[1\]\[4\] net691 VPWR VGND sg13g2_buf_1
X_19560_ VGND VPWR _10622_ net2206 _10624_ _10620_ sg13g2_a21oi_1
XFILLER_19_723 VPWR VGND sg13g2_decap_8
X_16772_ _07928_ _07926_ _07912_ VPWR VGND sg13g2_xnor2_1
X_13984_ _05298_ _05299_ _05300_ VPWR VGND sg13g2_nor2_1
X_18511_ _09620_ _09619_ _09621_ VPWR VGND sg13g2_nor2b_1
XFILLER_46_542 VPWR VGND sg13g2_fill_2
XFILLER_18_233 VPWR VGND sg13g2_fill_2
X_15723_ net979 VPWR _06975_ VGND net483 u_FIR.sum\[7\]\[8\] sg13g2_o21ai_1
X_19491_ VPWR _10555_ _10554_ VGND sg13g2_inv_1
X_12935_ _04294_ _04286_ _04292_ VPWR VGND sg13g2_xnor2_1
XFILLER_33_203 VPWR VGND sg13g2_decap_8
X_18442_ VGND VPWR _09366_ _09387_ _09552_ _09386_ sg13g2_a21oi_1
XFILLER_46_597 VPWR VGND sg13g2_decap_8
X_15654_ _06907_ _06906_ _06902_ VPWR VGND sg13g2_nand2b_1
X_12866_ _04227_ _04218_ _04225_ VPWR VGND sg13g2_xnor2_1
X_14605_ _05895_ _05892_ _05897_ VPWR VGND sg13g2_xor2_1
XFILLER_33_258 VPWR VGND sg13g2_fill_2
X_18373_ net200 _09482_ net679 _09483_ VPWR VGND sg13g2_nand3_1
X_11817_ VPWR _03238_ net627 VGND sg13g2_inv_1
X_15585_ _06799_ _06801_ _06840_ VPWR VGND sg13g2_and2_1
X_12797_ _04160_ _04152_ _04159_ VPWR VGND sg13g2_xnor2_1
X_17324_ VGND VPWR u_LMS.w\[0\]\[21\] u_LMS.w\[0\]\[20\] _08480_ net71 sg13g2_a21oi_1
X_14536_ VGND VPWR _05830_ _05828_ _05794_ sg13g2_or2_1
XFILLER_18_1056 VPWR VGND sg13g2_decap_4
XFILLER_105_1026 VPWR VGND sg13g2_fill_2
XFILLER_119_308 VPWR VGND sg13g2_fill_2
XFILLER_105_1037 VPWR VGND sg13g2_decap_4
XFILLER_105_1048 VPWR VGND sg13g2_decap_8
X_17255_ _08411_ _08369_ _08410_ VPWR VGND sg13g2_xnor2_1
XFILLER_105_1059 VPWR VGND sg13g2_fill_2
X_14467_ _05751_ _05753_ _05758_ _05766_ VPWR VGND sg13g2_mux2_1
X_23015__1184 VPWR VGND net1183 sg13g2_tiehi
X_16206_ _07430_ VPWR _07443_ VGND _07426_ _07428_ sg13g2_o21ai_1
X_13418_ _04758_ _04738_ _04760_ VPWR VGND sg13g2_xor2_1
X_17186_ _08342_ _08319_ _08341_ VPWR VGND sg13g2_xnor2_1
X_14398_ _05701_ _05700_ _05679_ VPWR VGND sg13g2_nand2b_1
X_16137_ _07376_ net797 net832 VPWR VGND sg13g2_nand2_1
XFILLER_6_671 VPWR VGND sg13g2_decap_8
X_13349_ _04693_ u_FIR.sum\[1\]\[11\] net406 VPWR VGND sg13g2_xnor2_1
X_16068_ _07260_ _07262_ _07309_ VPWR VGND sg13g2_and2_1
XFILLER_130_506 VPWR VGND sg13g2_decap_8
XFILLER_64_1032 VPWR VGND sg13g2_decap_8
X_15019_ _06295_ net779 net888 VPWR VGND sg13g2_nand2_1
XFILLER_111_731 VPWR VGND sg13g2_decap_4
XFILLER_97_965 VPWR VGND sg13g2_decap_8
XFILLER_110_230 VPWR VGND sg13g2_decap_8
X_19827_ VGND VPWR u_LMS.w\[4\]\[19\] net310 _10884_ _10879_ sg13g2_a21oi_1
XFILLER_84_604 VPWR VGND sg13g2_fill_2
XFILLER_83_103 VPWR VGND sg13g2_fill_1
X_19758_ _10822_ _10821_ _10820_ VPWR VGND sg13g2_nand2b_1
XFILLER_65_851 VPWR VGND sg13g2_fill_1
X_18709_ _09796_ _09784_ _09795_ VPWR VGND sg13g2_xnor2_1
X_19689_ _10753_ net2135 _10726_ VPWR VGND sg13g2_xnor2_1
X_21720_ _02318_ _02319_ _00458_ VPWR VGND sg13g2_nor2_1
XFILLER_92_692 VPWR VGND sg13g2_fill_2
XFILLER_24_225 VPWR VGND sg13g2_fill_2
XFILLER_24_247 VPWR VGND sg13g2_fill_1
X_21651_ VGND VPWR _02263_ _02264_ _00444_ net932 sg13g2_a21oi_1
X_20602_ VGND VPWR net609 net190 _01242_ _01238_ sg13g2_a21oi_1
X_21582_ u_LMS.w\[7\]\[6\] _02181_ _02199_ VPWR VGND sg13g2_nor2_1
X_23321_ net1280 VGND VPWR _00383_ u_LMS.w\[4\]\[23\] clknet_leaf_5_clkA sg13g2_dfrbpq_1
X_20533_ net151 VPWR _01173_ VGND net612 net614 sg13g2_o21ai_1
XFILLER_20_475 VPWR VGND sg13g2_decap_8
X_23252_ net1388 VGND VPWR _00314_ u_LMS.w\[1\]\[23\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
X_20464_ VGND VPWR _01114_ _01115_ _00406_ net937 sg13g2_a21oi_1
X_22203_ _02796_ VPWR _02797_ VGND _03294_ _02778_ sg13g2_o21ai_1
XFILLER_119_886 VPWR VGND sg13g2_decap_8
XFILLER_106_514 VPWR VGND sg13g2_fill_2
XFILLER_106_525 VPWR VGND sg13g2_decap_8
X_23183_ net1510 VGND VPWR _00245_ u_FIR.w\[4\]\[0\] clknet_leaf_35_clkA sg13g2_dfrbpq_1
X_20395_ _01058_ _03318_ net75 VPWR VGND sg13g2_nand2_1
XFILLER_106_536 VPWR VGND sg13g2_fill_2
XFILLER_109_7 VPWR VGND sg13g2_fill_1
XFILLER_118_396 VPWR VGND sg13g2_fill_2
X_22134_ _02520_ VPWR _02728_ VGND _02725_ _02727_ sg13g2_o21ai_1
X_22065_ _02610_ _02658_ _02659_ VPWR VGND sg13g2_nor2_1
XFILLER_102_720 VPWR VGND sg13g2_decap_8
XFILLER_114_591 VPWR VGND sg13g2_fill_2
XFILLER_0_858 VPWR VGND sg13g2_decap_8
XFILLER_59_122 VPWR VGND sg13g2_fill_1
X_21016_ _01653_ _01654_ _01655_ _01656_ VPWR VGND sg13g2_nor3_1
XFILLER_58_69 VPWR VGND sg13g2_decap_8
XFILLER_87_464 VPWR VGND sg13g2_decap_8
XFILLER_87_475 VPWR VGND sg13g2_fill_1
XFILLER_59_166 VPWR VGND sg13g2_decap_8
XFILLER_74_125 VPWR VGND sg13g2_decap_8
XFILLER_101_296 VPWR VGND sg13g2_fill_1
XFILLER_28_520 VPWR VGND sg13g2_decap_8
XFILLER_28_531 VPWR VGND sg13g2_fill_1
X_12720_ _04083_ _04053_ _04085_ VPWR VGND sg13g2_xor2_1
X_21918_ VGND VPWR net91 _02510_ _02512_ net115 sg13g2_a21oi_1
XFILLER_82_180 VPWR VGND sg13g2_decap_8
XFILLER_16_759 VPWR VGND sg13g2_fill_2
X_22898_ VPWR _00778_ _03177_ VGND sg13g2_inv_1
XFILLER_82_191 VPWR VGND sg13g2_fill_2
XFILLER_128_1026 VPWR VGND sg13g2_decap_8
X_12651_ _04011_ VPWR _04017_ VGND _03982_ _04009_ sg13g2_o21ai_1
XFILLER_130_63 VPWR VGND sg13g2_decap_8
X_21849_ _02443_ _02348_ _02356_ VPWR VGND sg13g2_xnor2_1
XFILLER_24_770 VPWR VGND sg13g2_decap_4
XFILLER_70_397 VPWR VGND sg13g2_decap_4
XFILLER_30_228 VPWR VGND sg13g2_fill_1
X_15370_ VGND VPWR _06605_ _06628_ _06636_ _06627_ sg13g2_a21oi_1
X_12582_ VGND VPWR net531 _03950_ _00066_ _03951_ sg13g2_a21oi_1
XFILLER_24_792 VPWR VGND sg13g2_fill_2
XFILLER_129_606 VPWR VGND sg13g2_fill_2
XFILLER_23_291 VPWR VGND sg13g2_decap_4
X_14321_ _05627_ _05602_ _05626_ VPWR VGND sg13g2_xnor2_1
XFILLER_23_50 VPWR VGND sg13g2_fill_2
X_23519_ net1340 VGND VPWR _00581_ u_LMS.count\[22\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
X_17040_ _08194_ _08180_ _08196_ VPWR VGND sg13g2_xor2_1
X_14252_ VGND VPWR _05518_ _05521_ _05560_ _05558_ sg13g2_a21oi_1
XFILLER_109_341 VPWR VGND sg13g2_decap_4
XFILLER_109_363 VPWR VGND sg13g2_fill_1
X_13203_ _04549_ _04516_ _04551_ VPWR VGND sg13g2_xor2_1
X_14183_ net863 net757 _05490_ _05492_ VPWR VGND sg13g2_a21o_1
XFILLER_3_630 VPWR VGND sg13g2_decap_4
X_23011__1190 VPWR VGND net1189 sg13g2_tiehi
X_13134_ _04483_ _04443_ _04481_ VPWR VGND sg13g2_xnor2_1
XFILLER_48_1038 VPWR VGND sg13g2_fill_1
X_18991_ _10078_ _09980_ _10047_ VPWR VGND sg13g2_xnor2_1
XFILLER_98_718 VPWR VGND sg13g2_fill_1
XFILLER_125_878 VPWR VGND sg13g2_decap_4
XFILLER_112_506 VPWR VGND sg13g2_decap_8
XFILLER_124_366 VPWR VGND sg13g2_fill_1
XFILLER_2_140 VPWR VGND sg13g2_decap_8
XFILLER_112_528 VPWR VGND sg13g2_fill_1
X_17942_ VPWR _09075_ _09074_ VGND sg13g2_inv_1
X_13065_ _04416_ net742 net883 VPWR VGND sg13g2_nand2_1
X_23390__1179 VPWR VGND net1178 sg13g2_tiehi
X_12016_ _03433_ _03398_ _03408_ VPWR VGND sg13g2_nand2_1
XFILLER_79_965 VPWR VGND sg13g2_fill_1
X_23407__1128 VPWR VGND net1127 sg13g2_tiehi
X_17873_ _09006_ net699 net259 VPWR VGND sg13g2_nand2_1
XFILLER_24_7 VPWR VGND sg13g2_decap_4
XFILLER_79_998 VPWR VGND sg13g2_decap_8
XFILLER_78_475 VPWR VGND sg13g2_fill_2
X_19612_ _10676_ net650 net224 VPWR VGND sg13g2_nand2_1
X_16824_ _07980_ _07976_ _07979_ VPWR VGND sg13g2_nand2_1
X_23751__1363 VPWR VGND net1362 sg13g2_tiehi
XFILLER_0_21 VPWR VGND sg13g2_decap_8
X_19543_ _10568_ _10606_ _10607_ VPWR VGND sg13g2_nor2_1
X_16755_ net914 _07906_ net912 _07911_ VPWR VGND net2098 sg13g2_nand4_1
XFILLER_81_618 VPWR VGND sg13g2_decap_8
X_13967_ _05253_ VPWR _05285_ VGND u_FIR.sum\[2\]\[17\] _05252_ sg13g2_o21ai_1
XFILLER_81_629 VPWR VGND sg13g2_decap_4
XFILLER_19_575 VPWR VGND sg13g2_decap_4
XFILLER_80_117 VPWR VGND sg13g2_decap_8
X_15706_ _06958_ _06939_ _06956_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_1014 VPWR VGND sg13g2_decap_4
X_19474_ _10538_ net645 net188 VPWR VGND sg13g2_nand2_1
X_12918_ _04276_ VPWR _04278_ VGND _04242_ _04246_ sg13g2_o21ai_1
X_16686_ VGND VPWR net520 _07854_ _00266_ _07855_ sg13g2_a21oi_1
XFILLER_0_98 VPWR VGND sg13g2_decap_8
X_13898_ _05220_ _05192_ _05218_ VPWR VGND sg13g2_xnor2_1
XFILLER_55_1009 VPWR VGND sg13g2_decap_8
XFILLER_34_556 VPWR VGND sg13g2_decap_8
X_18425_ _09526_ _09532_ _09535_ VPWR VGND sg13g2_nor2_1
XFILLER_62_876 VPWR VGND sg13g2_fill_2
X_15637_ _06891_ _06858_ _06889_ VPWR VGND sg13g2_xnor2_1
X_12849_ _04195_ VPWR _04210_ VGND _04191_ _04193_ sg13g2_o21ai_1
XFILLER_62_887 VPWR VGND sg13g2_decap_8
X_18356_ _09459_ VPWR _09466_ VGND _09426_ _09457_ sg13g2_o21ai_1
X_15568_ _06810_ VPWR _06823_ VGND _06805_ _06808_ sg13g2_o21ai_1
XFILLER_9_63 VPWR VGND sg13g2_decap_8
X_17307_ _08463_ u_LMS.w\[0\]\[13\] _08411_ VPWR VGND sg13g2_xnor2_1
X_14519_ _05812_ _05794_ _05814_ VPWR VGND sg13g2_xor2_1
X_18287_ _09397_ _09396_ _09393_ VPWR VGND sg13g2_nand2b_1
X_15499_ net874 u_FIR.sum\[6\]\[2\] net791 _06757_ VPWR VGND sg13g2_nand3_1
X_23297__1305 VPWR VGND net1304 sg13g2_tiehi
X_17238_ _08394_ _08380_ _08393_ VPWR VGND sg13g2_xnor2_1
XFILLER_116_801 VPWR VGND sg13g2_fill_1
XFILLER_7_980 VPWR VGND sg13g2_fill_2
XFILLER_116_823 VPWR VGND sg13g2_fill_1
X_17169_ _08325_ net713 net246 VPWR VGND sg13g2_nand2_1
XFILLER_7_991 VPWR VGND sg13g2_decap_8
XFILLER_50_0 VPWR VGND sg13g2_decap_8
XFILLER_127_182 VPWR VGND sg13g2_fill_2
XFILLER_115_344 VPWR VGND sg13g2_fill_2
X_20180_ _00843_ net213 net630 net247 net628 VPWR VGND sg13g2_a22oi_1
XFILLER_88_217 VPWR VGND sg13g2_decap_8
XFILLER_130_347 VPWR VGND sg13g2_decap_8
XFILLER_9_1054 VPWR VGND sg13g2_decap_8
XFILLER_69_453 VPWR VGND sg13g2_fill_1
XFILLER_96_250 VPWR VGND sg13g2_decap_8
XFILLER_84_412 VPWR VGND sg13g2_decap_8
XFILLER_85_957 VPWR VGND sg13g2_decap_8
X_22821_ VGND VPWR _07864_ net348 _00750_ _03128_ sg13g2_a21oi_1
XFILLER_38_862 VPWR VGND sg13g2_decap_8
XFILLER_38_884 VPWR VGND sg13g2_decap_8
XFILLER_38_895 VPWR VGND sg13g2_fill_1
X_22752_ u_debug_unit.mon_w2_sync\[6\] net331 _03094_ VPWR VGND sg13g2_nor2_1
XFILLER_25_545 VPWR VGND sg13g2_decap_8
X_21703_ net362 VPWR _02307_ VGND u_LMS.w\[7\]\[2\] net380 sg13g2_o21ai_1
X_22683_ coeff_force_packed\[49\] net473 _03068_ _00672_ VPWR VGND sg13g2_mux2_1
XFILLER_40_515 VPWR VGND sg13g2_fill_2
XFILLER_13_729 VPWR VGND sg13g2_fill_2
XFILLER_40_526 VPWR VGND sg13g2_decap_8
X_21634_ u_LMS.w\[7\]\[24\] _02245_ net63 _02251_ VPWR VGND sg13g2_or3_1
XFILLER_100_33 VPWR VGND sg13g2_fill_1
X_21565_ _02182_ u_LMS.w\[7\]\[6\] _02181_ VPWR VGND sg13g2_nand2_1
X_20516_ _01156_ net606 net160 VPWR VGND sg13g2_nand2_1
X_23304_ net1297 VGND VPWR _00366_ u_LMS.w\[3\]\[6\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
XFILLER_20_283 VPWR VGND sg13g2_fill_1
X_21496_ VGND VPWR net2203 _02006_ _02113_ _01999_ sg13g2_a21oi_1
XFILLER_4_405 VPWR VGND sg13g2_decap_8
X_23235_ net1418 VGND VPWR _00297_ u_LMS.w\[0\]\[6\] clknet_leaf_13_clkA sg13g2_dfrbpq_1
XFILLER_107_834 VPWR VGND sg13g2_fill_2
X_20447_ net23 VPWR _01102_ VGND net21 _01101_ sg13g2_o21ai_1
XFILLER_107_867 VPWR VGND sg13g2_decap_4
XFILLER_109_75 VPWR VGND sg13g2_fill_1
X_23166_ net1540 VGND VPWR _00228_ u_FIR.w\[1\]\[4\] clknet_leaf_49_clkA sg13g2_dfrbpq_1
XFILLER_69_35 VPWR VGND sg13g2_fill_2
XFILLER_109_97 VPWR VGND sg13g2_decap_8
X_20378_ _01041_ u_LMS.w\[5\]\[15\] _00978_ VPWR VGND sg13g2_xnor2_1
X_22117_ _02709_ _02710_ _02711_ VPWR VGND sg13g2_nor2b_1
X_23135__1587 VPWR VGND net1586 sg13g2_tiehi
X_23097_ net1060 VGND VPWR _00159_ u_FIR.sum\[6\]\[2\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
X_22048_ _02641_ _02639_ _02642_ VPWR VGND sg13g2_xor2_1
XFILLER_125_63 VPWR VGND sg13g2_fill_1
XFILLER_47_114 VPWR VGND sg13g2_decap_4
X_14870_ _06155_ _06126_ _06128_ _06091_ net768 VPWR VGND sg13g2_a22oi_1
XFILLER_47_136 VPWR VGND sg13g2_decap_8
X_13821_ _05144_ _05118_ _05146_ VPWR VGND sg13g2_xor2_1
XFILLER_62_106 VPWR VGND sg13g2_decap_4
XFILLER_18_72 VPWR VGND sg13g2_decap_4
XFILLER_16_512 VPWR VGND sg13g2_decap_4
X_16540_ VGND VPWR net479 _07745_ _00229_ _07746_ sg13g2_a21oi_1
XFILLER_16_523 VPWR VGND sg13g2_decap_8
X_13752_ net1033 VPWR _05079_ VGND net535 u_FIR.sum\[3\]\[9\] sg13g2_o21ai_1
XFILLER_44_843 VPWR VGND sg13g2_fill_2
XFILLER_43_320 VPWR VGND sg13g2_fill_2
XFILLER_55_191 VPWR VGND sg13g2_decap_8
XFILLER_43_331 VPWR VGND sg13g2_fill_1
XFILLER_16_545 VPWR VGND sg13g2_fill_2
X_12703_ _04068_ _04062_ _04067_ VPWR VGND sg13g2_nand2_1
X_16471_ _07696_ u_FIR.x\[2\] net525 VPWR VGND sg13g2_nand2_1
X_13683_ _05011_ _05010_ _05006_ VPWR VGND sg13g2_nand2b_1
XFILLER_43_375 VPWR VGND sg13g2_fill_2
X_18210_ _09318_ _09317_ _09320_ VPWR VGND sg13g2_xor2_1
XFILLER_43_386 VPWR VGND sg13g2_fill_2
XFILLER_31_526 VPWR VGND sg13g2_fill_2
X_15422_ _06686_ u_FIR.sum\[5\]\[15\] net393 VPWR VGND sg13g2_xnor2_1
X_19190_ net30 VPWR _10275_ VGND net28 _10274_ sg13g2_o21ai_1
X_12634_ _03978_ _03980_ _04001_ VPWR VGND sg13g2_and2_1
X_18141_ _09251_ _09201_ _09250_ VPWR VGND sg13g2_xnor2_1
X_15353_ _06620_ u_FIR.sum\[5\]\[12\] net394 VPWR VGND sg13g2_nand2_1
X_12565_ VGND VPWR _03914_ _03928_ _03937_ _03936_ sg13g2_a21oi_1
XFILLER_8_733 VPWR VGND sg13g2_fill_1
X_23475__1501 VPWR VGND net1500 sg13g2_tiehi
XFILLER_129_447 VPWR VGND sg13g2_fill_1
X_14304_ _05610_ _05607_ _05608_ VPWR VGND sg13g2_nand2_1
X_18072_ _09181_ _09180_ _09182_ VPWR VGND sg13g2_xor2_1
XFILLER_7_232 VPWR VGND sg13g2_fill_2
X_15284_ VPWR _06553_ _06552_ VGND sg13g2_inv_1
XFILLER_7_243 VPWR VGND sg13g2_decap_8
X_12496_ _03871_ _03866_ _03870_ VPWR VGND sg13g2_nand2_1
X_17023_ _08177_ _08178_ _08179_ VPWR VGND sg13g2_nor2_1
X_14235_ _05543_ _05536_ _05541_ VPWR VGND sg13g2_xnor2_1
XFILLER_109_171 VPWR VGND sg13g2_fill_1
XFILLER_50_92 VPWR VGND sg13g2_decap_4
X_23293__1311 VPWR VGND net1310 sg13g2_tiehi
X_14166_ _05475_ _05447_ _05476_ VPWR VGND sg13g2_xor2_1
XFILLER_4_961 VPWR VGND sg13g2_fill_1
XFILLER_124_163 VPWR VGND sg13g2_fill_2
X_13117_ _04467_ _04458_ _04465_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_174 VPWR VGND sg13g2_fill_2
XFILLER_98_548 VPWR VGND sg13g2_fill_2
X_18974_ _10059_ _10060_ _10061_ VPWR VGND sg13g2_nor2_1
X_14097_ _05386_ _05395_ _05408_ VPWR VGND sg13g2_and2_1
XFILLER_79_740 VPWR VGND sg13g2_fill_1
XFILLER_100_509 VPWR VGND sg13g2_decap_8
X_17925_ _09058_ _08660_ _09057_ VPWR VGND sg13g2_nand2_1
X_13048_ _04400_ net743 net909 VPWR VGND sg13g2_nand2_1
XFILLER_85_209 VPWR VGND sg13g2_decap_4
XFILLER_61_1024 VPWR VGND sg13g2_fill_2
XFILLER_94_721 VPWR VGND sg13g2_decap_8
XFILLER_79_795 VPWR VGND sg13g2_decap_4
XFILLER_67_935 VPWR VGND sg13g2_fill_1
XFILLER_121_892 VPWR VGND sg13g2_fill_2
X_17856_ _08989_ _08964_ _08988_ VPWR VGND sg13g2_xnor2_1
XFILLER_66_445 VPWR VGND sg13g2_fill_1
X_16807_ _07943_ _07962_ _07963_ VPWR VGND sg13g2_nor2_1
XFILLER_38_158 VPWR VGND sg13g2_decap_8
XFILLER_93_253 VPWR VGND sg13g2_decap_8
X_17787_ _08906_ _08919_ _08920_ VPWR VGND sg13g2_nor2_1
X_14999_ VGND VPWR _06272_ _06274_ _06276_ _06264_ sg13g2_a21oi_1
XFILLER_93_275 VPWR VGND sg13g2_decap_8
X_19526_ _10590_ _10587_ _10589_ VPWR VGND sg13g2_nand2_1
X_16738_ _03378_ _07889_ _07894_ VPWR VGND sg13g2_and2_1
XFILLER_46_180 VPWR VGND sg13g2_decap_4
X_19457_ _03249_ net96 _10521_ VPWR VGND sg13g2_nor2_1
X_16669_ VGND VPWR u_LMS.w\[6\]\[16\] _07832_ _07842_ _07833_ sg13g2_a21oi_1
X_18408_ _09518_ _09494_ _09495_ VPWR VGND sg13g2_xnor2_1
XFILLER_98_0 VPWR VGND sg13g2_fill_1
X_19388_ _10452_ _10358_ _10367_ VPWR VGND sg13g2_xnor2_1
X_22996__1213 VPWR VGND net1212 sg13g2_tiehi
X_18339_ _09446_ _09445_ _09449_ VPWR VGND sg13g2_xor2_1
X_21350_ VGND VPWR _01954_ _01966_ _01967_ _01953_ sg13g2_a21oi_1
X_20301_ _00964_ _00962_ _00963_ _10989_ net624 VPWR VGND sg13g2_a22oi_1
X_21281_ _01895_ VPWR _01898_ VGND _03219_ net199 sg13g2_o21ai_1
XFILLER_128_480 VPWR VGND sg13g2_fill_2
X_23020_ net1176 VGND VPWR _00082_ u_FIR.sum\[2\]\[1\] clknet_leaf_34_clkA sg13g2_dfrbpq_1
X_20232_ net636 net230 net633 _00895_ VPWR VGND net213 sg13g2_nand4_1
XFILLER_115_130 VPWR VGND sg13g2_fill_2
XFILLER_118_1003 VPWR VGND sg13g2_decap_8
X_20163_ _00826_ net623 _11172_ VPWR VGND sg13g2_xnor2_1
XFILLER_103_347 VPWR VGND sg13g2_fill_1
XFILLER_103_358 VPWR VGND sg13g2_fill_1
X_20094_ _11135_ net626 net209 VPWR VGND sg13g2_nand2_1
XFILLER_58_924 VPWR VGND sg13g2_decap_8
X_23131__1593 VPWR VGND net1592 sg13g2_tiehi
XFILLER_69_283 VPWR VGND sg13g2_fill_1
XFILLER_85_754 VPWR VGND sg13g2_decap_8
XFILLER_58_968 VPWR VGND sg13g2_decap_8
XFILLER_29_158 VPWR VGND sg13g2_decap_8
XFILLER_72_404 VPWR VGND sg13g2_decap_8
XFILLER_84_275 VPWR VGND sg13g2_decap_8
XFILLER_66_990 VPWR VGND sg13g2_decap_8
XFILLER_26_821 VPWR VGND sg13g2_decap_8
X_22804_ u_debug_unit.mon_w6_sync\[4\] net346 _03120_ VPWR VGND sg13g2_nor2_1
XFILLER_77_1020 VPWR VGND sg13g2_decap_8
X_20996_ _01636_ u_LMS.w\[6\]\[17\] _01565_ VPWR VGND sg13g2_xnor2_1
X_23146__1571 VPWR VGND net1570 sg13g2_tiehi
X_22735_ VGND VPWR _07743_ net333 _00707_ _03085_ sg13g2_a21oi_1
XFILLER_38_1026 VPWR VGND sg13g2_fill_2
XFILLER_41_846 VPWR VGND sg13g2_decap_4
XFILLER_111_87 VPWR VGND sg13g2_decap_4
X_22666_ coeff_force_packed\[36\] net471 _03066_ _00657_ VPWR VGND sg13g2_mux2_1
X_21617_ _02233_ VPWR _02234_ VGND _02156_ _02232_ sg13g2_o21ai_1
XFILLER_40_389 VPWR VGND sg13g2_decap_8
X_22597_ net464 u_debug_unit.sw_reset\[4\] _03058_ _00596_ VPWR VGND sg13g2_mux2_1
X_12350_ _03729_ _03728_ _03724_ VPWR VGND sg13g2_nand2b_1
X_21548_ _02165_ _02129_ _02130_ VPWR VGND sg13g2_xnor2_1
XFILLER_5_714 VPWR VGND sg13g2_fill_1
X_12281_ _03662_ _03657_ _03660_ VPWR VGND sg13g2_xnor2_1
X_21479_ _02096_ _02095_ _02063_ _02093_ net197 VPWR VGND sg13g2_a22oi_1
XFILLER_101_1051 VPWR VGND sg13g2_decap_8
XFILLER_5_758 VPWR VGND sg13g2_decap_8
X_14020_ _05334_ _05326_ _05333_ VPWR VGND sg13g2_nand2_1
XFILLER_84_1002 VPWR VGND sg13g2_fill_2
X_23218_ net1448 VGND VPWR _00280_ u_LMS.w\[0\]\[12\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
XFILLER_107_675 VPWR VGND sg13g2_fill_1
XFILLER_20_62 VPWR VGND sg13g2_decap_4
XFILLER_4_279 VPWR VGND sg13g2_decap_8
XFILLER_20_73 VPWR VGND sg13g2_decap_4
XFILLER_106_174 VPWR VGND sg13g2_decap_4
XFILLER_20_84 VPWR VGND sg13g2_decap_4
X_23149_ net1565 VGND VPWR _00211_ u_FIR.x_reg\[2\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
XFILLER_110_807 VPWR VGND sg13g2_decap_8
XFILLER_110_818 VPWR VGND sg13g2_decap_8
XFILLER_96_55 VPWR VGND sg13g2_fill_2
XFILLER_0_452 VPWR VGND sg13g2_decap_4
X_15971_ _07204_ _07213_ _07193_ _07214_ VPWR VGND sg13g2_nand3_1
XFILLER_1_975 VPWR VGND sg13g2_decap_8
XFILLER_0_463 VPWR VGND sg13g2_fill_1
XFILLER_121_166 VPWR VGND sg13g2_decap_4
XFILLER_96_77 VPWR VGND sg13g2_fill_1
X_17710_ net700 net168 net130 _08843_ VPWR VGND net698 sg13g2_nand4_1
X_14922_ _06159_ _06204_ _06205_ VPWR VGND sg13g2_nor2_1
X_18690_ _09777_ net80 net658 net145 net660 VPWR VGND sg13g2_a22oi_1
X_17641_ _08774_ net688 net240 VPWR VGND sg13g2_nand2_1
XFILLER_64_916 VPWR VGND sg13g2_fill_1
X_14853_ _06139_ _06103_ _06137_ VPWR VGND sg13g2_xnor2_1
XFILLER_76_798 VPWR VGND sg13g2_decap_8
X_13804_ _05129_ _05123_ _05128_ VPWR VGND sg13g2_xnor2_1
X_17572_ _08705_ _08704_ _08702_ VPWR VGND sg13g2_nand2b_1
X_14784_ _06072_ _06068_ _06071_ VPWR VGND sg13g2_xnor2_1
XFILLER_28_180 VPWR VGND sg13g2_decap_4
X_11996_ _03413_ _03412_ u_debug_unit.mon_w6_sync\[6\] _03410_ u_debug_unit.mon_w4_sync\[6\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_16_331 VPWR VGND sg13g2_fill_2
X_19311_ _10375_ net643 net85 VPWR VGND sg13g2_nand2_1
X_16523_ VGND VPWR u_LMS.w\[1\]\[12\] _07733_ _07735_ _07734_ sg13g2_a21oi_1
X_13735_ VGND VPWR _05062_ _05017_ _05015_ sg13g2_or2_1
XFILLER_72_993 VPWR VGND sg13g2_decap_8
XFILLER_71_470 VPWR VGND sg13g2_decap_4
XFILLER_32_824 VPWR VGND sg13g2_fill_1
X_19242_ VGND VPWR net717 net306 _10317_ _10292_ sg13g2_a21oi_1
X_16454_ _07672_ _07667_ _07665_ _07682_ VPWR VGND sg13g2_mux2_1
X_13666_ _04995_ _04963_ _04993_ VPWR VGND sg13g2_xnor2_1
X_15405_ _06670_ net276 _06669_ VPWR VGND sg13g2_xnor2_1
X_19173_ VPWR _10260_ _10259_ VGND sg13g2_inv_1
X_12617_ VPWR _03985_ _03984_ VGND sg13g2_inv_1
XFILLER_129_200 VPWR VGND sg13g2_decap_8
X_16385_ _07591_ _07616_ _07617_ VPWR VGND sg13g2_nor2b_1
X_13597_ _03363_ net911 _04927_ VPWR VGND sg13g2_nor2_1
XFILLER_31_389 VPWR VGND sg13g2_fill_2
X_18124_ _09234_ _09201_ _09233_ VPWR VGND sg13g2_xnor2_1
XFILLER_12_581 VPWR VGND sg13g2_decap_8
X_15336_ _06598_ _06600_ _06603_ VPWR VGND sg13g2_nor2_1
X_12548_ _03921_ _03832_ _03920_ VPWR VGND sg13g2_nand2_1
XFILLER_129_266 VPWR VGND sg13g2_decap_8
X_18055_ net359 VPWR _09168_ VGND u_LMS.w\[1\]\[9\] net375 sg13g2_o21ai_1
X_15267_ net804 VPWR _06536_ VGND net778 u_FIR.w\[2\]\[2\] sg13g2_o21ai_1
XANTENNA_2 VPWR VGND net216 sg13g2_antennanp
X_12479_ net542 VPWR _03855_ VGND _03853_ _03854_ sg13g2_o21ai_1
XFILLER_6_42 VPWR VGND sg13g2_decap_8
XFILLER_126_951 VPWR VGND sg13g2_decap_8
X_17006_ VGND VPWR _08158_ _08159_ _08162_ _08161_ sg13g2_a21oi_1
X_14218_ VGND VPWR _05506_ _05513_ _05526_ _05505_ sg13g2_a21oi_1
XFILLER_99_813 VPWR VGND sg13g2_fill_2
X_15198_ _06467_ _06468_ _06469_ VPWR VGND sg13g2_nor2b_1
XFILLER_98_323 VPWR VGND sg13g2_decap_8
XFILLER_112_111 VPWR VGND sg13g2_fill_2
X_14149_ _05458_ _05417_ _05459_ VPWR VGND sg13g2_xor2_1
Xfanout509 net511 net509 VPWR VGND sg13g2_buf_1
X_18957_ _10044_ net201 net661 net238 net658 VPWR VGND sg13g2_a22oi_1
XFILLER_112_177 VPWR VGND sg13g2_decap_8
XFILLER_67_710 VPWR VGND sg13g2_fill_1
XFILLER_67_721 VPWR VGND sg13g2_decap_4
X_17908_ _08990_ VPWR _09041_ VGND _09040_ _09039_ sg13g2_o21ai_1
XFILLER_6_1046 VPWR VGND sg13g2_decap_8
X_18888_ _09940_ _09935_ _09975_ VPWR VGND sg13g2_xor2_1
XFILLER_13_0 VPWR VGND sg13g2_decap_8
XFILLER_94_562 VPWR VGND sg13g2_decap_8
X_17839_ _08763_ VPWR _08972_ VGND _08700_ _08730_ sg13g2_o21ai_1
XFILLER_82_724 VPWR VGND sg13g2_decap_4
X_20850_ _01475_ _01489_ _01490_ VPWR VGND sg13g2_nor2_1
XFILLER_26_139 VPWR VGND sg13g2_fill_2
XFILLER_81_234 VPWR VGND sg13g2_decap_4
XFILLER_70_919 VPWR VGND sg13g2_fill_2
X_19509_ VGND VPWR _10573_ _10571_ _10538_ sg13g2_or2_1
X_20781_ VGND VPWR _01414_ _01420_ _01421_ _01413_ sg13g2_a21oi_1
XFILLER_22_301 VPWR VGND sg13g2_fill_2
XFILLER_22_312 VPWR VGND sg13g2_decap_8
X_22520_ VGND VPWR u_LMS.count\[5\] _03009_ _03013_ u_LMS.count\[6\] sg13g2_a21oi_1
XFILLER_22_323 VPWR VGND sg13g2_fill_1
X_22451_ net959 VPWR _02975_ VGND net444 net622 sg13g2_o21ai_1
XFILLER_124_1040 VPWR VGND sg13g2_decap_8
XFILLER_41_39 VPWR VGND sg13g2_decap_8
X_21402_ _02019_ _02013_ _02017_ VPWR VGND sg13g2_xnor2_1
X_22382_ VGND VPWR net440 _03278_ _00499_ _02940_ sg13g2_a21oi_1
X_21333_ _01950_ _01945_ _01948_ VPWR VGND sg13g2_xnor2_1
X_21264_ _01881_ _01879_ _01880_ VPWR VGND sg13g2_nand2_1
X_23420__1089 VPWR VGND net1088 sg13g2_tiehi
XFILLER_2_706 VPWR VGND sg13g2_decap_8
XFILLER_104_623 VPWR VGND sg13g2_fill_1
X_20215_ _00876_ _00877_ _00878_ VPWR VGND sg13g2_and2_1
X_23003_ net1201 VGND VPWR _00065_ u_FIR.sum\[1\]\[0\] clknet_leaf_21_clkA sg13g2_dfrbpq_1
XFILLER_1_216 VPWR VGND sg13g2_fill_2
X_21195_ _01812_ net591 net149 VPWR VGND sg13g2_nand2_1
XFILLER_132_954 VPWR VGND sg13g2_decap_8
X_20146_ _11153_ _11186_ _11187_ VPWR VGND sg13g2_nor2_1
XFILLER_106_54 VPWR VGND sg13g2_decap_4
XFILLER_103_177 VPWR VGND sg13g2_decap_8
XFILLER_66_14 VPWR VGND sg13g2_decap_4
X_20077_ _11082_ _11081_ _11118_ VPWR VGND sg13g2_xor2_1
XFILLER_66_47 VPWR VGND sg13g2_fill_2
XFILLER_131_1044 VPWR VGND sg13g2_decap_8
XFILLER_57_264 VPWR VGND sg13g2_decap_8
X_11850_ VPWR _03271_ net693 VGND sg13g2_inv_1
XFILLER_72_234 VPWR VGND sg13g2_fill_2
XFILLER_72_267 VPWR VGND sg13g2_decap_8
XFILLER_32_109 VPWR VGND sg13g2_fill_2
X_23767_ net995 VGND VPWR _00014_ u_spi_slave.rx_shift\[9\] clknet_3_3__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_72_289 VPWR VGND sg13g2_decap_8
X_20979_ _01619_ _03303_ _01583_ VPWR VGND sg13g2_nand2_1
X_13520_ _04832_ _04826_ _04830_ _04853_ VPWR VGND sg13g2_a21o_1
X_22718_ u_debug_unit.mon_w0_sync\[3\] net336 _03077_ VPWR VGND sg13g2_nor2_1
X_23698_ net1530 VGND VPWR _00760_ u_p2s_output.o_valid clknet_leaf_47_clkA sg13g2_dfrbpq_1
X_13451_ VGND VPWR _04643_ _04744_ _04791_ _04790_ sg13g2_a21oi_1
X_22649_ net469 coeff_force_packed\[23\] _03064_ _00642_ VPWR VGND sg13g2_mux2_1
XFILLER_9_338 VPWR VGND sg13g2_decap_4
XFILLER_40_175 VPWR VGND sg13g2_fill_1
X_12402_ _03779_ _03718_ _03780_ VPWR VGND sg13g2_xor2_1
X_16170_ _03375_ net877 _07408_ VPWR VGND sg13g2_nor2_1
XFILLER_127_704 VPWR VGND sg13g2_fill_1
X_13382_ _04724_ net283 _04725_ VPWR VGND sg13g2_xor2_1
XFILLER_127_726 VPWR VGND sg13g2_fill_2
XFILLER_126_203 VPWR VGND sg13g2_decap_4
X_15121_ VGND VPWR net783 net818 _06394_ u_FIR.sum\[5\]\[6\] sg13g2_a21oi_1
XFILLER_31_50 VPWR VGND sg13g2_decap_8
X_12333_ _03712_ _03711_ _00056_ VPWR VGND sg13g2_nor2b_1
XFILLER_127_748 VPWR VGND sg13g2_decap_4
XFILLER_126_247 VPWR VGND sg13g2_decap_8
XFILLER_108_962 VPWR VGND sg13g2_fill_1
X_15052_ _06327_ _06319_ _06326_ VPWR VGND sg13g2_nand2_1
X_12264_ VGND VPWR net540 _03644_ _00054_ _03645_ sg13g2_a21oi_1
XFILLER_99_109 VPWR VGND sg13g2_decap_8
XFILLER_108_984 VPWR VGND sg13g2_decap_4
X_14003_ _05316_ _05317_ _05318_ VPWR VGND sg13g2_nor2b_1
XFILLER_107_494 VPWR VGND sg13g2_fill_2
X_19860_ VGND VPWR net53 _10909_ _10910_ net24 sg13g2_a21oi_1
X_12195_ u_LMS.count\[22\] u_LMS.count\[21\] u_LMS.count\[20\] u_LMS.count\[19\] _03583_
+ VPWR VGND sg13g2_nor4_1
X_18811_ _09898_ _09896_ _09897_ VPWR VGND sg13g2_nand2_1
XFILLER_123_987 VPWR VGND sg13g2_decap_4
XFILLER_1_761 VPWR VGND sg13g2_decap_4
X_19791_ _10855_ net54 _10854_ VPWR VGND sg13g2_nand2_2
XFILLER_49_721 VPWR VGND sg13g2_decap_4
X_18742_ VGND VPWR _09829_ _09814_ _09812_ sg13g2_or2_1
X_15954_ _07198_ _07179_ _07182_ _07197_ VPWR VGND sg13g2_and3_1
XFILLER_49_765 VPWR VGND sg13g2_fill_2
X_14905_ _06189_ _06161_ _06187_ VPWR VGND sg13g2_xnor2_1
XFILLER_48_253 VPWR VGND sg13g2_fill_1
X_18673_ _03253_ net139 _09760_ VPWR VGND sg13g2_nor2_1
X_15885_ _07132_ u_FIR.sum\[6\]\[13\] net391 VPWR VGND sg13g2_xnor2_1
XFILLER_76_584 VPWR VGND sg13g2_decap_4
XFILLER_36_437 VPWR VGND sg13g2_fill_1
X_17624_ _08757_ _08752_ _08755_ VPWR VGND sg13g2_xnor2_1
X_14836_ _06098_ VPWR _06122_ VGND net269 _06099_ sg13g2_o21ai_1
XFILLER_64_757 VPWR VGND sg13g2_decap_8
XFILLER_56_91 VPWR VGND sg13g2_decap_8
XFILLER_91_554 VPWR VGND sg13g2_decap_8
X_17555_ _08686_ _08687_ _08688_ VPWR VGND sg13g2_nor2_1
XFILLER_91_587 VPWR VGND sg13g2_decap_8
X_14767_ _06053_ _05980_ _06054_ _06055_ VPWR VGND sg13g2_a21o_1
X_11979_ spi_addr\[6\] spi_addr\[5\] _03396_ VPWR VGND sg13g2_nor2b_1
XFILLER_72_790 VPWR VGND sg13g2_fill_2
X_16506_ net971 VPWR _07722_ VGND net475 net796 sg13g2_o21ai_1
XFILLER_60_941 VPWR VGND sg13g2_decap_8
XFILLER_108_1013 VPWR VGND sg13g2_decap_8
X_13718_ _05045_ _05008_ _05011_ VPWR VGND sg13g2_nand2_1
X_17486_ _08617_ _08610_ _08619_ VPWR VGND sg13g2_xor2_1
X_14698_ _05970_ _05987_ _05988_ VPWR VGND sg13g2_nor2b_1
XFILLER_108_1046 VPWR VGND sg13g2_decap_8
X_19225_ _10247_ VPWR _10303_ VGND _10246_ _10298_ sg13g2_o21ai_1
X_16437_ VGND VPWR _07634_ _07665_ _07666_ _07654_ sg13g2_a21oi_1
XFILLER_20_827 VPWR VGND sg13g2_fill_1
X_13649_ net826 net754 _04976_ _04978_ VPWR VGND sg13g2_a21o_1
XFILLER_31_175 VPWR VGND sg13g2_fill_2
X_19156_ VGND VPWR _10242_ _10243_ _10241_ _10173_ sg13g2_a21oi_2
X_16368_ _07583_ _07600_ _07601_ VPWR VGND sg13g2_nor2b_1
X_18107_ _09194_ net120 _09192_ _09217_ VPWR VGND sg13g2_nand3_1
X_15319_ _06506_ VPWR _06587_ VGND _03372_ _06536_ sg13g2_o21ai_1
X_19087_ _10174_ _10149_ _10150_ VPWR VGND sg13g2_xnor2_1
X_16299_ _07534_ u_FIR.sum\[7\]\[11\] net387 VPWR VGND sg13g2_nand2_1
X_18038_ net359 VPWR _09156_ VGND u_LMS.w\[1\]\[4\] net375 sg13g2_o21ai_1
XFILLER_132_206 VPWR VGND sg13g2_decap_8
XFILLER_126_792 VPWR VGND sg13g2_fill_2
XFILLER_99_643 VPWR VGND sg13g2_decap_8
XFILLER_28_1014 VPWR VGND sg13g2_decap_8
XFILLER_114_943 VPWR VGND sg13g2_fill_1
XFILLER_113_420 VPWR VGND sg13g2_decap_4
X_20000_ _11039_ _11040_ _11041_ VPWR VGND sg13g2_nor2b_1
Xfanout306 _08500_ net306 VPWR VGND sg13g2_buf_1
XFILLER_98_142 VPWR VGND sg13g2_fill_1
XFILLER_87_805 VPWR VGND sg13g2_decap_8
XFILLER_114_976 VPWR VGND sg13g2_decap_8
Xfanout317 net318 net317 VPWR VGND sg13g2_buf_1
XFILLER_59_507 VPWR VGND sg13g2_decap_8
Xfanout328 _03386_ net328 VPWR VGND sg13g2_buf_1
XFILLER_28_1058 VPWR VGND sg13g2_fill_2
XFILLER_115_1006 VPWR VGND sg13g2_fill_1
X_23370__1232 VPWR VGND net1231 sg13g2_tiehi
Xfanout339 net353 net339 VPWR VGND sg13g2_buf_1
XFILLER_115_1017 VPWR VGND sg13g2_fill_2
X_19989_ _11030_ net626 net173 VPWR VGND sg13g2_nand2_1
X_21951_ _02545_ _02544_ _02541_ VPWR VGND sg13g2_nand2b_1
XFILLER_67_595 VPWR VGND sg13g2_fill_1
Xclkbuf_leaf_0_clkA clknet_4_2_0_clkA clknet_leaf_0_clkA VPWR VGND sg13g2_buf_8
X_20902_ VGND VPWR _01535_ _01539_ _01542_ _01541_ sg13g2_a21oi_1
XFILLER_54_223 VPWR VGND sg13g2_fill_1
X_21882_ _02476_ _02474_ _02475_ VPWR VGND sg13g2_nand2_1
XFILLER_27_459 VPWR VGND sg13g2_decap_8
XFILLER_70_705 VPWR VGND sg13g2_decap_8
X_23621_ net963 VGND VPWR _00683_ coeff_force_packed\[59\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_20833_ _01451_ _01449_ _01473_ VPWR VGND sg13g2_xor2_1
XFILLER_74_1012 VPWR VGND sg13g2_decap_8
XFILLER_74_1023 VPWR VGND sg13g2_fill_2
XFILLER_23_621 VPWR VGND sg13g2_fill_2
X_23552_ net1011 VGND VPWR _00614_ sys_enable_bus\[6\] clknet_leaf_17_clkA sg13g2_dfrbpq_1
X_20764_ _01404_ net615 net209 VPWR VGND sg13g2_nand2_1
XFILLER_51_963 VPWR VGND sg13g2_fill_2
X_22503_ net440 u_LMS.count\[0\] _03002_ VPWR VGND sg13g2_and2_1
XFILLER_22_153 VPWR VGND sg13g2_decap_4
X_20695_ _01335_ net612 net190 VPWR VGND sg13g2_nand2_1
X_23483_ net1472 VGND VPWR _00545_ u_LMS.x_r\[7\]\[2\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
XFILLER_50_484 VPWR VGND sg13g2_fill_2
X_22434_ VGND VPWR net436 _03252_ _00525_ _02966_ sg13g2_a21oi_1
X_22365_ net1027 VPWR _02932_ VGND net454 net707 sg13g2_o21ai_1
X_21316_ _01933_ net592 net249 VPWR VGND sg13g2_nand2_1
X_22296_ VGND VPWR _02880_ _02881_ _00472_ net925 sg13g2_a21oi_1
XFILLER_124_729 VPWR VGND sg13g2_fill_2
XFILLER_105_932 VPWR VGND sg13g2_decap_8
X_21247_ _01864_ net594 net189 VPWR VGND sg13g2_nand2_1
XFILLER_89_120 VPWR VGND sg13g2_decap_8
XFILLER_78_805 VPWR VGND sg13g2_decap_4
XFILLER_132_751 VPWR VGND sg13g2_decap_8
Xrebuffer2060 _01416_ net2059 VPWR VGND sg13g2_buf_1
Xrebuffer2071 _01653_ net2070 VPWR VGND sg13g2_buf_1
X_21178_ net427 _03219_ net110 net93 _01795_ VPWR VGND sg13g2_nor4_1
Xrebuffer2082 net2082 net2081 VPWR VGND sg13g2_buf_1
XFILLER_77_46 VPWR VGND sg13g2_fill_2
XFILLER_131_250 VPWR VGND sg13g2_decap_8
Xrebuffer2093 _09660_ net2092 VPWR VGND sg13g2_buf_1
XFILLER_81_1049 VPWR VGND sg13g2_decap_8
XFILLER_78_838 VPWR VGND sg13g2_decap_4
XFILLER_132_795 VPWR VGND sg13g2_fill_1
Xfanout840 u_FIR.x_reg\[5\] net840 VPWR VGND sg13g2_buf_1
X_20129_ _03242_ net1641 net125 _11170_ VGND VPWR net1668 sg13g2_nor4_2
Xfanout851 net853 net851 VPWR VGND sg13g2_buf_1
Xfanout862 net871 net862 VPWR VGND sg13g2_buf_1
Xfanout873 net874 net873 VPWR VGND sg13g2_buf_1
Xfanout884 net885 net884 VPWR VGND sg13g2_buf_1
Xfanout895 net898 net895 VPWR VGND sg13g2_buf_1
X_12951_ _04310_ _04281_ _04309_ VPWR VGND sg13g2_xnor2_1
X_11902_ VPWR _03323_ u_LMS.w\[4\]\[8\] VGND sg13g2_inv_1
XFILLER_85_392 VPWR VGND sg13g2_decap_8
XFILLER_73_532 VPWR VGND sg13g2_decap_8
X_15670_ _06923_ u_FIR.sum\[6\]\[7\] net392 VPWR VGND sg13g2_xnor2_1
XFILLER_73_543 VPWR VGND sg13g2_fill_2
X_12882_ _04241_ _04209_ _04243_ VPWR VGND sg13g2_xor2_1
XFILLER_61_705 VPWR VGND sg13g2_decap_8
XFILLER_61_716 VPWR VGND sg13g2_fill_1
XFILLER_27_960 VPWR VGND sg13g2_fill_2
X_14621_ _05912_ _05908_ _05913_ VPWR VGND sg13g2_xor2_1
XFILLER_93_89 VPWR VGND sg13g2_fill_2
XFILLER_27_971 VPWR VGND sg13g2_fill_2
X_11833_ VPWR _03254_ net658 VGND sg13g2_inv_1
XFILLER_45_289 VPWR VGND sg13g2_decap_8
XFILLER_61_749 VPWR VGND sg13g2_fill_1
X_17340_ _08496_ net2137 _08461_ VPWR VGND sg13g2_xnor2_1
XFILLER_26_492 VPWR VGND sg13g2_fill_2
XFILLER_14_632 VPWR VGND sg13g2_decap_8
X_14552_ _05846_ _05845_ _05825_ VPWR VGND sg13g2_nand2b_1
X_13503_ net1022 VPWR _04837_ VGND net516 u_FIR.sum\[3\]\[2\] sg13g2_o21ai_1
X_17271_ _03352_ _08426_ _08427_ VPWR VGND sg13g2_nor2_1
XFILLER_41_473 VPWR VGND sg13g2_fill_2
X_14483_ _05780_ net773 net890 u_FIR.sum\[4\]\[1\] VPWR VGND sg13g2_and3_1
X_19010_ net668 net219 net665 _10097_ VPWR VGND net202 sg13g2_nand4_1
XFILLER_41_495 VPWR VGND sg13g2_fill_2
X_16222_ _07459_ _07415_ _07458_ VPWR VGND sg13g2_xnor2_1
X_13434_ _04775_ _04767_ _04773_ VPWR VGND sg13g2_xnor2_1
X_23256__1382 VPWR VGND net1381 sg13g2_tiehi
XFILLER_42_82 VPWR VGND sg13g2_decap_4
X_16153_ _07392_ _07385_ _07391_ VPWR VGND sg13g2_xnor2_1
X_13365_ VGND VPWR _04676_ _04700_ _04708_ _04699_ sg13g2_a21oi_1
XFILLER_127_545 VPWR VGND sg13g2_decap_4
XFILLER_5_330 VPWR VGND sg13g2_decap_8
X_15104_ _03370_ net901 _06377_ VPWR VGND sg13g2_nor2_1
X_12316_ VGND VPWR _03696_ _03695_ _03663_ sg13g2_or2_1
X_16084_ VGND VPWR net476 _07323_ _00195_ _07324_ sg13g2_a21oi_1
XFILLER_114_206 VPWR VGND sg13g2_decap_8
X_13296_ _04641_ _04568_ _04640_ VPWR VGND sg13g2_nand2_1
XFILLER_54_7 VPWR VGND sg13g2_decap_8
X_19912_ _10953_ net627 net87 VPWR VGND sg13g2_nand2_1
X_15035_ _06310_ net777 net900 VPWR VGND sg13g2_nand2_1
X_12247_ VGND VPWR _03598_ _03625_ _03629_ _03628_ sg13g2_a21oi_1
XFILLER_107_291 VPWR VGND sg13g2_fill_1
X_23099__1058 VPWR VGND net1057 sg13g2_tiehi
XFILLER_3_21 VPWR VGND sg13g2_decap_8
X_19843_ VGND VPWR u_LMS.w\[4\]\[22\] net310 _10897_ _10879_ sg13g2_a21oi_1
X_12178_ net944 u_spi_slave.rx_shift\[8\] _00014_ VPWR VGND sg13g2_nor2b_1
XFILLER_69_838 VPWR VGND sg13g2_decap_4
XFILLER_111_957 VPWR VGND sg13g2_fill_2
XFILLER_95_123 VPWR VGND sg13g2_decap_8
X_19774_ _10838_ _10834_ _10836_ _10837_ VPWR VGND sg13g2_and3_1
XFILLER_68_359 VPWR VGND sg13g2_fill_1
X_16986_ _08142_ net708 net172 VPWR VGND sg13g2_nand2_1
XFILLER_3_98 VPWR VGND sg13g2_decap_8
XFILLER_37_702 VPWR VGND sg13g2_decap_8
X_18725_ net423 _03252_ net107 net90 _09812_ VPWR VGND sg13g2_nor4_1
X_15937_ _07180_ VPWR _07182_ VGND _07160_ _07162_ sg13g2_o21ai_1
XFILLER_3_1049 VPWR VGND sg13g2_decap_8
X_18656_ _09747_ _09631_ _09633_ VPWR VGND sg13g2_xnor2_1
X_15868_ net1003 VPWR _07116_ VGND net495 u_FIR.sum\[7\]\[12\] sg13g2_o21ai_1
XFILLER_92_863 VPWR VGND sg13g2_decap_8
XFILLER_92_874 VPWR VGND sg13g2_fill_1
X_17607_ _08740_ _08738_ _08739_ VPWR VGND sg13g2_nand2b_1
X_14819_ _06106_ _06105_ _06070_ VPWR VGND sg13g2_nand2b_1
XFILLER_18_982 VPWR VGND sg13g2_decap_4
X_18587_ VGND VPWR _09692_ _09693_ _00329_ net921 sg13g2_a21oi_1
X_15799_ _07015_ _07048_ _07049_ VPWR VGND sg13g2_nor2b_1
XFILLER_51_248 VPWR VGND sg13g2_fill_1
X_17538_ net419 net219 _08671_ VPWR VGND sg13g2_nor2_1
X_17469_ _08599_ _08601_ _08602_ VPWR VGND sg13g2_nor2_1
XFILLER_80_0 VPWR VGND sg13g2_decap_8
X_19208_ _10241_ _10242_ _10173_ _10289_ VPWR VGND sg13g2_nand3_1
XFILLER_34_1040 VPWR VGND sg13g2_fill_1
X_20480_ net363 VPWR _01128_ VGND u_LMS.w\[5\]\[4\] net381 sg13g2_o21ai_1
X_19139_ VGND VPWR _10223_ _10224_ _10226_ _10188_ sg13g2_a21oi_1
X_23491__1444 VPWR VGND net1443 sg13g2_tiehi
XFILLER_106_718 VPWR VGND sg13g2_fill_1
X_22150_ _02744_ net571 _07986_ VPWR VGND sg13g2_nand2_1
XFILLER_106_729 VPWR VGND sg13g2_fill_1
X_21101_ VGND VPWR _01657_ _01723_ _01724_ net14 sg13g2_a21oi_1
X_22081_ _02675_ _02664_ _02666_ VPWR VGND sg13g2_xnor2_1
X_21032_ _01670_ net317 u_LMS.w\[6\]\[14\] coeff_force_packed\[44\] net565 VPWR VGND
+ sg13g2_a22oi_1
Xfanout103 net103 net104 VPWR VGND sg13g2_buf_4
XFILLER_114_773 VPWR VGND sg13g2_fill_2
Xfanout114 net1645 net114 VPWR VGND sg13g2_buf_2
Xfanout125 net125 net1648 VPWR VGND sg13g2_buf_4
XFILLER_101_412 VPWR VGND sg13g2_fill_2
Xfanout136 net137 net136 VPWR VGND sg13g2_buf_2
XFILLER_87_635 VPWR VGND sg13g2_decap_8
Xfanout147 net148 net147 VPWR VGND sg13g2_buf_1
XFILLER_102_957 VPWR VGND sg13g2_decap_8
Xfanout158 _07986_ net158 VPWR VGND sg13g2_buf_1
Xfanout169 net174 net169 VPWR VGND sg13g2_buf_1
XFILLER_101_467 VPWR VGND sg13g2_decap_8
XFILLER_68_871 VPWR VGND sg13g2_fill_1
XFILLER_28_702 VPWR VGND sg13g2_fill_1
XFILLER_101_478 VPWR VGND sg13g2_fill_2
XFILLER_86_178 VPWR VGND sg13g2_decap_4
X_22983_ net1019 VGND VPWR _00045_ u_spi_slave.tx_shift\[13\] net1633 sg13g2_dfrbpq_1
X_21934_ _02528_ _02521_ _02526_ VPWR VGND sg13g2_xnor2_1
XFILLER_42_204 VPWR VGND sg13g2_fill_1
X_21865_ net570 net574 net222 net196 _02459_ VPWR VGND sg13g2_and4_1
XFILLER_82_384 VPWR VGND sg13g2_decap_4
X_23604_ net1014 VGND VPWR _00666_ coeff_force_packed\[44\] clknet_leaf_17_clkA sg13g2_dfrbpq_1
XFILLER_63_59 VPWR VGND sg13g2_fill_1
X_20816_ net620 net618 net190 _01456_ VPWR VGND net228 sg13g2_nand4_1
XFILLER_42_248 VPWR VGND sg13g2_fill_1
X_21796_ net571 net573 net100 net83 _02390_ VPWR VGND sg13g2_and4_1
XFILLER_11_602 VPWR VGND sg13g2_decap_4
X_23535_ net955 VGND VPWR _00597_ u_debug_unit.sw_reset\[5\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_20747_ VGND VPWR _01383_ _01384_ _01387_ _01386_ sg13g2_a21oi_1
XFILLER_11_635 VPWR VGND sg13g2_decap_8
XFILLER_10_123 VPWR VGND sg13g2_fill_1
X_23466_ net1532 VGND VPWR _00528_ u_LMS.x_r\[5\]\[1\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
X_20678_ _01310_ _01309_ _01318_ VPWR VGND sg13g2_xor2_1
XFILLER_7_628 VPWR VGND sg13g2_fill_2
XFILLER_6_105 VPWR VGND sg13g2_decap_4
XFILLER_10_178 VPWR VGND sg13g2_decap_8
X_22417_ net948 VPWR _02958_ VGND net432 net654 sg13g2_o21ai_1
X_23397_ net1157 VGND VPWR _00459_ u_LMS.w\[7\]\[7\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
XFILLER_12_74 VPWR VGND sg13g2_decap_4
X_13150_ _04497_ _04498_ _04499_ VPWR VGND sg13g2_nor2_1
X_22348_ _02920_ _02921_ _00484_ VPWR VGND sg13g2_nor2_1
XFILLER_128_63 VPWR VGND sg13g2_decap_8
XFILLER_2_300 VPWR VGND sg13g2_fill_1
X_12101_ VPWR VGND coeff_force_packed\[38\] _03504_ net295 u_debug_unit.mon_w3_sync\[3\]
+ _03513_ _03400_ sg13g2_a221oi_1
XFILLER_3_845 VPWR VGND sg13g2_decap_4
X_13081_ _04432_ _04423_ _04430_ VPWR VGND sg13g2_xnor2_1
X_22279_ _02868_ net308 u_LMS.w\[8\]\[17\] coeff_force_packed\[61\] net561 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_78_602 VPWR VGND sg13g2_fill_1
X_12032_ _03446_ _03447_ _03432_ _03449_ VPWR VGND _03448_ sg13g2_nand4_1
XFILLER_77_101 VPWR VGND sg13g2_decap_4
XFILLER_120_721 VPWR VGND sg13g2_fill_1
XFILLER_132_592 VPWR VGND sg13g2_decap_8
X_16840_ _07996_ net86 net706 net155 net708 VPWR VGND sg13g2_a22oi_1
Xfanout670 u_LMS.x_r\[2\]\[6\] net670 VPWR VGND sg13g2_buf_1
X_23095__1064 VPWR VGND net1063 sg13g2_tiehi
Xfanout681 u_LMS.x_r\[2\]\[1\] net681 VPWR VGND sg13g2_buf_1
XFILLER_120_787 VPWR VGND sg13g2_fill_1
Xfanout692 u_LMS.x_r\[1\]\[4\] net692 VPWR VGND sg13g2_buf_1
X_16771_ _07927_ _07912_ _07926_ VPWR VGND sg13g2_nand2b_1
XFILLER_120_798 VPWR VGND sg13g2_fill_1
X_13983_ VGND VPWR net765 net893 _05299_ u_FIR.sum\[3\]\[1\] sg13g2_a21oi_1
XFILLER_77_189 VPWR VGND sg13g2_decap_8
XFILLER_92_126 VPWR VGND sg13g2_decap_8
XFILLER_86_690 VPWR VGND sg13g2_fill_2
XFILLER_18_212 VPWR VGND sg13g2_decap_4
X_18510_ _09620_ u_LMS.w\[2\]\[4\] _09612_ VPWR VGND sg13g2_xnor2_1
X_15722_ _06974_ _06973_ _06972_ VPWR VGND sg13g2_nand2b_1
X_12934_ _04293_ _04292_ _04286_ VPWR VGND sg13g2_nand2b_1
XFILLER_37_60 VPWR VGND sg13g2_fill_1
X_19490_ _10554_ _10549_ _10552_ VPWR VGND sg13g2_xnor2_1
XFILLER_46_554 VPWR VGND sg13g2_decap_8
XFILLER_37_71 VPWR VGND sg13g2_fill_1
XFILLER_19_768 VPWR VGND sg13g2_fill_1
XFILLER_74_874 VPWR VGND sg13g2_fill_1
XFILLER_61_502 VPWR VGND sg13g2_fill_2
X_18441_ _09453_ VPWR _09551_ VGND _09550_ _09548_ sg13g2_o21ai_1
X_15653_ _06904_ _06905_ _06906_ VPWR VGND sg13g2_and2_1
X_12865_ _04226_ _04218_ _04225_ VPWR VGND sg13g2_nand2_1
XFILLER_73_384 VPWR VGND sg13g2_fill_1
XFILLER_73_395 VPWR VGND sg13g2_fill_2
XFILLER_27_790 VPWR VGND sg13g2_decap_4
X_14604_ _05896_ _05895_ _05892_ VPWR VGND sg13g2_nand2b_1
XFILLER_15_941 VPWR VGND sg13g2_fill_2
X_18372_ _09481_ _09456_ _09482_ VPWR VGND sg13g2_xor2_1
X_11816_ VPWR _03237_ net626 VGND sg13g2_inv_1
X_15584_ _06839_ _06803_ _06837_ VPWR VGND sg13g2_xnor2_1
X_12796_ _04159_ _04116_ _04157_ VPWR VGND sg13g2_xnor2_1
X_17323_ _08478_ VPWR _08479_ VGND _08396_ _08473_ sg13g2_o21ai_1
X_14535_ _05829_ net771 net876 VPWR VGND sg13g2_nand2_1
XFILLER_18_1035 VPWR VGND sg13g2_decap_8
XFILLER_30_944 VPWR VGND sg13g2_fill_2
XFILLER_41_292 VPWR VGND sg13g2_fill_1
XFILLER_30_955 VPWR VGND sg13g2_decap_4
X_17254_ _08363_ VPWR _08410_ VGND _08354_ _08364_ sg13g2_o21ai_1
X_14466_ VGND VPWR _05750_ _05762_ _05765_ _05761_ sg13g2_a21oi_1
XFILLER_30_977 VPWR VGND sg13g2_decap_8
X_16205_ _07433_ VPWR _07442_ VGND _07403_ _07434_ sg13g2_o21ai_1
XFILLER_128_832 VPWR VGND sg13g2_decap_8
X_13417_ VGND VPWR _04759_ _04758_ _04738_ sg13g2_or2_1
X_17185_ _08340_ VPWR _08341_ VGND _08310_ _08312_ sg13g2_o21ai_1
X_14397_ _05699_ net277 _05700_ VPWR VGND sg13g2_xor2_1
XFILLER_128_876 VPWR VGND sg13g2_fill_1
X_16136_ _07375_ _07367_ _07374_ VPWR VGND sg13g2_xnor2_1
X_13348_ _04692_ u_FIR.sum\[1\]\[11\] net406 VPWR VGND sg13g2_nand2_1
XFILLER_127_386 VPWR VGND sg13g2_decap_4
X_16067_ _07308_ _07264_ _07306_ VPWR VGND sg13g2_xnor2_1
X_13279_ _04597_ _04624_ _04625_ VPWR VGND sg13g2_nor2b_1
XFILLER_64_1000 VPWR VGND sg13g2_fill_1
X_15018_ _06294_ net781 net874 VPWR VGND sg13g2_nand2_1
XFILLER_68_112 VPWR VGND sg13g2_fill_1
XFILLER_25_1017 VPWR VGND sg13g2_decap_8
X_19826_ net26 VPWR _10883_ VGND net25 _10882_ sg13g2_o21ai_1
XFILLER_111_765 VPWR VGND sg13g2_decap_4
XFILLER_69_679 VPWR VGND sg13g2_decap_4
XFILLER_96_476 VPWR VGND sg13g2_fill_1
X_19757_ _10372_ VPWR _10821_ VGND _10417_ _10423_ sg13g2_o21ai_1
XFILLER_56_329 VPWR VGND sg13g2_decap_8
XFILLER_110_286 VPWR VGND sg13g2_decap_4
X_16969_ _08123_ net122 _08125_ VPWR VGND sg13g2_xor2_1
XFILLER_37_532 VPWR VGND sg13g2_fill_2
X_18708_ _09793_ _09786_ _09795_ VPWR VGND sg13g2_xor2_1
X_19688_ _10752_ u_LMS.w\[4\]\[13\] _10751_ VPWR VGND sg13g2_nand2_1
XFILLER_37_565 VPWR VGND sg13g2_fill_2
XFILLER_25_716 VPWR VGND sg13g2_decap_8
XFILLER_80_822 VPWR VGND sg13g2_fill_2
XFILLER_25_727 VPWR VGND sg13g2_fill_2
X_18639_ _09733_ _09734_ _00340_ VPWR VGND sg13g2_nor2_1
XFILLER_37_598 VPWR VGND sg13g2_decap_4
XFILLER_25_738 VPWR VGND sg13g2_fill_1
X_21650_ _02264_ net312 u_LMS.w\[7\]\[15\] coeff_force_packed\[52\] net563 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_80_877 VPWR VGND sg13g2_fill_1
XFILLER_33_760 VPWR VGND sg13g2_decap_8
X_20601_ _01241_ net610 net171 VPWR VGND sg13g2_nand2_1
X_21581_ VGND VPWR _02195_ _02196_ _02198_ _02184_ sg13g2_a21oi_1
XFILLER_20_410 VPWR VGND sg13g2_decap_4
X_23320_ net1281 VGND VPWR _00382_ u_LMS.w\[4\]\[22\] clknet_leaf_3_clkA sg13g2_dfrbpq_1
X_20532_ VGND VPWR _01163_ _01171_ _01172_ _01161_ sg13g2_a21oi_1
X_20463_ VGND VPWR u_LMS.w\[5\]\[23\] net318 _01115_ _01094_ sg13g2_a21oi_1
X_23251_ net1390 VGND VPWR _00313_ u_LMS.w\[1\]\[22\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
X_22202_ _02796_ _02795_ _02794_ VPWR VGND sg13g2_nand2b_1
XFILLER_106_504 VPWR VGND sg13g2_fill_1
X_20394_ _01050_ _01047_ _01056_ _01057_ VPWR VGND sg13g2_a21o_1
X_23182_ net1512 VGND VPWR _00244_ u_FIR.w\[3\]\[6\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
XFILLER_3_119 VPWR VGND sg13g2_decap_8
X_22133_ VPWR _02727_ _02726_ VGND sg13g2_inv_1
X_22064_ _02658_ net582 net255 VPWR VGND sg13g2_nand2_1
XFILLER_99_281 VPWR VGND sg13g2_fill_1
X_21015_ _01655_ u_LMS.w\[6\]\[24\] net74 VPWR VGND sg13g2_nand2_1
XFILLER_87_443 VPWR VGND sg13g2_fill_1
XFILLER_48_808 VPWR VGND sg13g2_fill_1
XFILLER_74_104 VPWR VGND sg13g2_fill_2
XFILLER_47_329 VPWR VGND sg13g2_decap_8
XFILLER_56_841 VPWR VGND sg13g2_fill_1
XFILLER_28_543 VPWR VGND sg13g2_decap_8
XFILLER_74_159 VPWR VGND sg13g2_decap_8
XFILLER_71_800 VPWR VGND sg13g2_decap_8
XFILLER_71_811 VPWR VGND sg13g2_fill_1
XFILLER_43_502 VPWR VGND sg13g2_fill_2
X_21917_ _02511_ net585 net82 VPWR VGND sg13g2_nand2_1
X_23091__1070 VPWR VGND net1069 sg13g2_tiehi
XFILLER_71_822 VPWR VGND sg13g2_decap_8
XFILLER_83_693 VPWR VGND sg13g2_decap_8
X_22897_ _03177_ net297 u_FIR.x\[5\] net298 u_s2p_input.reg_sh\[4\] VPWR VGND sg13g2_a22oi_1
XFILLER_16_749 VPWR VGND sg13g2_fill_2
XFILLER_128_1005 VPWR VGND sg13g2_decap_8
XFILLER_15_248 VPWR VGND sg13g2_fill_2
XFILLER_130_42 VPWR VGND sg13g2_decap_8
X_12650_ _04015_ _04016_ _00069_ VPWR VGND sg13g2_nor2_1
XFILLER_71_866 VPWR VGND sg13g2_decap_8
X_21848_ VGND VPWR _02434_ _02441_ _02442_ _02433_ sg13g2_a21oi_1
XFILLER_15_259 VPWR VGND sg13g2_fill_1
X_12581_ net1031 VPWR _03951_ VGND net531 u_FIR.sum\[1\]\[1\] sg13g2_o21ai_1
XFILLER_12_933 VPWR VGND sg13g2_decap_4
X_21779_ _02373_ _02361_ _02372_ VPWR VGND sg13g2_xnor2_1
X_14320_ _05626_ _05603_ _05624_ VPWR VGND sg13g2_xnor2_1
X_23518_ net1344 VGND VPWR _00580_ u_LMS.count\[21\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
XFILLER_11_465 VPWR VGND sg13g2_fill_2
XFILLER_109_320 VPWR VGND sg13g2_decap_8
X_14251_ _05559_ _05518_ _05521_ _05558_ VPWR VGND sg13g2_and3_1
XFILLER_128_0 VPWR VGND sg13g2_decap_8
X_23449_ net1584 VGND VPWR _00511_ u_LMS.x_r\[3\]\[0\] clknet_leaf_63_clkA sg13g2_dfrbpq_1
X_13202_ _04516_ _04549_ _04550_ VPWR VGND sg13g2_nor2_1
XFILLER_87_1022 VPWR VGND sg13g2_fill_1
X_14182_ net863 _05490_ net757 _05491_ VPWR VGND sg13g2_nand3_1
XFILLER_109_386 VPWR VGND sg13g2_fill_2
XFILLER_124_323 VPWR VGND sg13g2_decap_4
X_13133_ _04482_ _04481_ _04443_ VPWR VGND sg13g2_nand2b_1
XFILLER_124_334 VPWR VGND sg13g2_decap_8
X_18990_ _10077_ _10068_ _10075_ VPWR VGND sg13g2_xnor2_1
X_17941_ _09074_ u_LMS.w\[1\]\[20\] net77 VPWR VGND sg13g2_nand2_1
X_13064_ _04415_ net745 net867 VPWR VGND sg13g2_nand2_1
XFILLER_105_592 VPWR VGND sg13g2_decap_8
X_12015_ _03432_ net291 u_debug_unit.force_w6\[7\] net292 u_debug_unit.force_w2\[7\]
+ VPWR VGND sg13g2_a22oi_1
X_17872_ _09005_ _08910_ _08938_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_914 VPWR VGND sg13g2_fill_2
X_19611_ _10629_ _10673_ _10675_ VPWR VGND sg13g2_nor2_1
XFILLER_93_402 VPWR VGND sg13g2_decap_4
X_16823_ _07978_ _07977_ _07979_ VPWR VGND sg13g2_xor2_1
XFILLER_17_7 VPWR VGND sg13g2_decap_8
XFILLER_93_446 VPWR VGND sg13g2_fill_1
XFILLER_65_137 VPWR VGND sg13g2_fill_1
XFILLER_19_532 VPWR VGND sg13g2_decap_4
X_19542_ _10606_ net257 u_LMS.x_r\[4\]\[6\] net241 net644 VPWR VGND sg13g2_a22oi_1
X_16754_ _07910_ net914 net2098 VPWR VGND sg13g2_nand2_1
X_13966_ _05273_ _05283_ _05284_ VPWR VGND sg13g2_nor2_1
XFILLER_47_874 VPWR VGND sg13g2_decap_8
XFILLER_62_800 VPWR VGND sg13g2_fill_2
XFILLER_62_811 VPWR VGND sg13g2_decap_8
X_15705_ _06939_ _06956_ _06957_ VPWR VGND sg13g2_nor2b_1
X_12917_ _04242_ _04246_ _04276_ _04277_ VPWR VGND sg13g2_nor3_1
X_19473_ _10504_ _10502_ _10537_ VPWR VGND sg13g2_xor2_1
X_16685_ net1024 VPWR _07855_ VGND net520 net738 sg13g2_o21ai_1
XFILLER_0_77 VPWR VGND sg13g2_decap_8
X_13897_ _05192_ _05218_ _05219_ VPWR VGND sg13g2_nor2b_1
X_18424_ _09534_ _09501_ _09533_ VPWR VGND sg13g2_xnor2_1
XFILLER_94_1059 VPWR VGND sg13g2_fill_2
X_15636_ _06858_ _06889_ _06890_ VPWR VGND sg13g2_nor2_1
X_12848_ VGND VPWR _04170_ _04200_ _04209_ _04199_ sg13g2_a21oi_1
X_18355_ _09465_ _09438_ _09464_ VPWR VGND sg13g2_nand2_1
X_15567_ _06815_ VPWR _06822_ VGND _06786_ _06813_ sg13g2_o21ai_1
X_12779_ _04142_ _04136_ _04140_ VPWR VGND sg13g2_xnor2_1
XFILLER_9_42 VPWR VGND sg13g2_decap_8
X_17306_ VGND VPWR _08459_ _08460_ _08462_ _08414_ sg13g2_a21oi_1
X_14518_ VGND VPWR _05813_ _05812_ _05794_ sg13g2_or2_1
XFILLER_9_75 VPWR VGND sg13g2_fill_1
X_18286_ _09396_ _09357_ _09395_ VPWR VGND sg13g2_xnor2_1
X_15498_ VGND VPWR net481 _06755_ _00177_ _06756_ sg13g2_a21oi_1
XFILLER_30_774 VPWR VGND sg13g2_fill_2
XFILLER_31_1021 VPWR VGND sg13g2_decap_4
X_17237_ _08393_ _08381_ _08392_ VPWR VGND sg13g2_xnor2_1
X_14449_ _05748_ _05749_ _00135_ VPWR VGND sg13g2_nor2_1
X_17168_ VGND VPWR net715 net246 _08324_ _08323_ sg13g2_a21oi_1
XFILLER_115_323 VPWR VGND sg13g2_fill_1
X_16119_ _07359_ _07325_ _07358_ VPWR VGND sg13g2_nand2_1
XFILLER_6_491 VPWR VGND sg13g2_decap_8
X_17099_ _08255_ net709 net246 VPWR VGND sg13g2_nand2_1
XFILLER_43_0 VPWR VGND sg13g2_decap_8
XFILLER_9_1033 VPWR VGND sg13g2_decap_8
XFILLER_69_421 VPWR VGND sg13g2_decap_8
XFILLER_69_432 VPWR VGND sg13g2_fill_2
XFILLER_111_551 VPWR VGND sg13g2_decap_8
XFILLER_97_785 VPWR VGND sg13g2_fill_2
X_19809_ _10869_ _10745_ _10807_ VPWR VGND sg13g2_xnor2_1
XFILLER_96_273 VPWR VGND sg13g2_fill_1
XFILLER_57_638 VPWR VGND sg13g2_decap_4
X_22820_ u_debug_unit.mon_w7_sync\[5\] net348 _03128_ VPWR VGND sg13g2_nor2_1
X_22751_ VGND VPWR _07765_ net329 _00715_ _03093_ sg13g2_a21oi_1
XFILLER_53_833 VPWR VGND sg13g2_fill_2
XFILLER_52_310 VPWR VGND sg13g2_decap_8
XFILLER_52_332 VPWR VGND sg13g2_fill_2
X_21702_ VGND VPWR net49 _02305_ _02306_ net10 sg13g2_a21oi_1
X_23053__1127 VPWR VGND net1126 sg13g2_tiehi
XFILLER_25_557 VPWR VGND sg13g2_fill_1
X_22682_ net430 _03429_ _03068_ VPWR VGND sg13g2_and2_1
XFILLER_52_365 VPWR VGND sg13g2_fill_2
X_21633_ _02250_ net2139 _02218_ VPWR VGND sg13g2_xnor2_1
Xclkbuf_leaf_28_clkA clknet_4_15_0_clkA clknet_leaf_28_clkA VPWR VGND sg13g2_buf_8
XFILLER_127_1060 VPWR VGND sg13g2_fill_1
X_21564_ _02181_ _02090_ _02097_ VPWR VGND sg13g2_xnor2_1
X_23068__1105 VPWR VGND net1104 sg13g2_tiehi
X_23303_ net1298 VGND VPWR _00365_ u_LMS.w\[3\]\[5\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
X_20515_ _03229_ net102 _01155_ VPWR VGND sg13g2_nor2_1
XFILLER_121_7 VPWR VGND sg13g2_decap_8
X_21495_ _02002_ _02001_ _02004_ _02112_ VPWR VGND sg13g2_a21o_1
X_23234_ net1420 VGND VPWR _00296_ u_LMS.w\[0\]\[5\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
X_20446_ _01100_ _01053_ _01101_ VPWR VGND sg13g2_xor2_1
XFILLER_118_172 VPWR VGND sg13g2_decap_4
XFILLER_107_846 VPWR VGND sg13g2_decap_8
XFILLER_69_14 VPWR VGND sg13g2_decap_8
XFILLER_118_194 VPWR VGND sg13g2_fill_2
X_23165_ net1541 VGND VPWR _00227_ u_FIR.w\[1\]\[3\] clknet_leaf_48_clkA sg13g2_dfrbpq_1
XFILLER_106_356 VPWR VGND sg13g2_decap_8
X_20377_ u_LMS.w\[5\]\[15\] _00978_ _01040_ VPWR VGND sg13g2_nor2b_1
X_22116_ _02514_ _02508_ _02710_ VPWR VGND sg13g2_xor2_1
XFILLER_79_218 VPWR VGND sg13g2_fill_1
XFILLER_121_304 VPWR VGND sg13g2_fill_1
XFILLER_0_612 VPWR VGND sg13g2_decap_8
XFILLER_79_229 VPWR VGND sg13g2_decap_8
X_23096_ net1062 VGND VPWR _00158_ u_FIR.sum\[6\]\[1\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
XFILLER_122_849 VPWR VGND sg13g2_fill_1
XFILLER_88_741 VPWR VGND sg13g2_fill_2
XFILLER_125_42 VPWR VGND sg13g2_decap_8
XFILLER_121_348 VPWR VGND sg13g2_decap_8
X_22047_ _02618_ _02640_ _02641_ VPWR VGND sg13g2_and2_1
XFILLER_87_251 VPWR VGND sg13g2_decap_8
XFILLER_88_785 VPWR VGND sg13g2_decap_8
XFILLER_85_35 VPWR VGND sg13g2_decap_8
XFILLER_75_446 VPWR VGND sg13g2_decap_8
X_13820_ _05118_ _05144_ _05145_ VPWR VGND sg13g2_nor2_1
XFILLER_75_479 VPWR VGND sg13g2_decap_8
X_13751_ VGND VPWR _05078_ _05077_ _05076_ sg13g2_or2_1
X_22949_ net466 u_spi_slave.rx_shift\[2\] _03575_ _00806_ VPWR VGND sg13g2_mux2_1
X_12702_ _04066_ _04063_ _04067_ VPWR VGND sg13g2_xor2_1
X_16470_ VGND VPWR _07694_ _07695_ _00210_ net938 sg13g2_a21oi_1
X_13682_ _05008_ _05009_ _05010_ VPWR VGND sg13g2_and2_1
XFILLER_71_685 VPWR VGND sg13g2_decap_4
X_15421_ _06685_ u_FIR.sum\[5\]\[15\] net393 VPWR VGND sg13g2_nand2_1
X_12633_ _04000_ _03991_ _03998_ VPWR VGND sg13g2_xnor2_1
XFILLER_54_1021 VPWR VGND sg13g2_fill_1
XFILLER_54_1032 VPWR VGND sg13g2_fill_1
X_18140_ _09249_ _09243_ _09250_ VPWR VGND sg13g2_xor2_1
X_15352_ _06619_ _06607_ _06618_ VPWR VGND sg13g2_xnor2_1
XFILLER_15_1016 VPWR VGND sg13g2_decap_4
X_12564_ _03936_ _03932_ _03935_ VPWR VGND sg13g2_xnor2_1
XFILLER_129_437 VPWR VGND sg13g2_fill_1
X_14303_ _05607_ _05608_ _05609_ VPWR VGND sg13g2_nor2_1
XFILLER_15_1049 VPWR VGND sg13g2_decap_8
X_18071_ _09181_ net671 net127 VPWR VGND sg13g2_nand2_1
X_15283_ _06507_ VPWR _06552_ VGND _06464_ _06505_ sg13g2_o21ai_1
X_12495_ _03868_ _03869_ _03870_ VPWR VGND sg13g2_and2_1
X_17022_ _08178_ net263 net704 net246 u_LMS.x_r\[0\]\[5\] VPWR VGND sg13g2_a22oi_1
X_14234_ _05536_ _05541_ _05542_ VPWR VGND sg13g2_nor2b_1
XFILLER_50_60 VPWR VGND sg13g2_fill_2
X_14165_ _05474_ _05466_ _05475_ VPWR VGND sg13g2_xor2_1
XFILLER_112_304 VPWR VGND sg13g2_fill_1
X_13116_ _04466_ _04458_ _04465_ VPWR VGND sg13g2_nand2_1
XFILLER_113_838 VPWR VGND sg13g2_decap_4
X_18973_ _10060_ _10024_ _10030_ VPWR VGND sg13g2_xnor2_1
X_14096_ _05393_ VPWR _05407_ VGND _05388_ _05391_ sg13g2_o21ai_1
XFILLER_106_890 VPWR VGND sg13g2_decap_8
XFILLER_112_359 VPWR VGND sg13g2_fill_1
X_17924_ _09056_ VPWR _09057_ VGND _08609_ _08653_ sg13g2_o21ai_1
X_13047_ _04399_ net742 net896 VPWR VGND sg13g2_nand2_1
XFILLER_79_752 VPWR VGND sg13g2_fill_1
XFILLER_61_1014 VPWR VGND sg13g2_fill_2
XFILLER_78_262 VPWR VGND sg13g2_decap_8
X_17855_ VGND VPWR _08830_ _08959_ _08988_ _08829_ sg13g2_a21oi_1
XFILLER_39_638 VPWR VGND sg13g2_fill_2
XFILLER_94_755 VPWR VGND sg13g2_fill_2
XFILLER_15_4 VPWR VGND sg13g2_fill_1
XFILLER_93_232 VPWR VGND sg13g2_decap_4
X_16806_ _07962_ net173 net703 net179 net702 VPWR VGND sg13g2_a22oi_1
XFILLER_38_148 VPWR VGND sg13g2_fill_2
XFILLER_82_917 VPWR VGND sg13g2_fill_1
X_17786_ _08919_ _08916_ _08918_ VPWR VGND sg13g2_nand2_1
X_14998_ _06275_ _06264_ _06272_ _06274_ VPWR VGND sg13g2_and3_1
X_19525_ _10549_ _10588_ _10589_ VPWR VGND sg13g2_nor2_1
XFILLER_81_427 VPWR VGND sg13g2_fill_2
XFILLER_53_118 VPWR VGND sg13g2_decap_4
X_16737_ VPWR _07893_ net1643 VGND sg13g2_inv_1
X_13949_ _05256_ VPWR _05268_ VGND _05251_ _05253_ sg13g2_o21ai_1
X_19456_ _03249_ _03250_ _10520_ VPWR VGND sg13g2_nor2_1
X_16668_ VGND VPWR net527 _07840_ _00262_ _07841_ sg13g2_a21oi_1
XFILLER_35_888 VPWR VGND sg13g2_fill_1
X_18407_ VGND VPWR _09515_ _09516_ _09517_ _09514_ sg13g2_a21oi_1
X_15619_ _06872_ _06868_ _06873_ VPWR VGND sg13g2_xor2_1
X_19387_ VGND VPWR _10444_ _10450_ _10451_ _10443_ sg13g2_a21oi_1
X_16599_ u_LMS.w\[4\]\[20\] u_LMS.w\[4\]\[19\] u_LMS.w\[4\]\[18\] _07790_ VPWR VGND
+ sg13g2_nor3_1
X_18338_ _09441_ _09443_ _09448_ VPWR VGND sg13g2_nor2_1
X_18269_ _09379_ _09340_ _09339_ VPWR VGND sg13g2_xnor2_1
X_20300_ VGND VPWR _10989_ _11010_ _00963_ _11009_ sg13g2_a21oi_1
XFILLER_129_993 VPWR VGND sg13g2_decap_8
X_21280_ _01897_ net594 net226 VPWR VGND sg13g2_nand2_1
X_23064__1111 VPWR VGND net1110 sg13g2_tiehi
XFILLER_128_470 VPWR VGND sg13g2_decap_4
X_20231_ _00894_ net636 net213 VPWR VGND sg13g2_nand2_1
X_20162_ _11193_ VPWR _00825_ VGND _11159_ _11191_ sg13g2_o21ai_1
XFILLER_130_112 VPWR VGND sg13g2_fill_1
XFILLER_118_1059 VPWR VGND sg13g2_fill_2
X_20093_ _11134_ net625 net244 VPWR VGND sg13g2_nand2_1
XFILLER_29_104 VPWR VGND sg13g2_fill_2
XFILLER_84_210 VPWR VGND sg13g2_decap_8
XFILLER_29_126 VPWR VGND sg13g2_decap_8
X_22803_ VGND VPWR _07840_ net351 _00741_ _03119_ sg13g2_a21oi_1
XFILLER_25_310 VPWR VGND sg13g2_decap_8
X_20995_ _01570_ _01573_ _01635_ VPWR VGND _01633_ sg13g2_nand3b_1
XFILLER_81_950 VPWR VGND sg13g2_fill_1
XFILLER_53_641 VPWR VGND sg13g2_fill_1
XFILLER_111_33 VPWR VGND sg13g2_decap_8
X_22734_ u_debug_unit.mon_w1_sync\[4\] net333 _03085_ VPWR VGND sg13g2_nor2_1
XFILLER_111_44 VPWR VGND sg13g2_fill_1
XFILLER_41_814 VPWR VGND sg13g2_fill_2
XFILLER_53_696 VPWR VGND sg13g2_fill_1
XFILLER_40_313 VPWR VGND sg13g2_decap_8
XFILLER_111_77 VPWR VGND sg13g2_decap_4
X_22665_ coeff_force_packed\[35\] net473 _03066_ _00656_ VPWR VGND sg13g2_mux2_1
XFILLER_25_398 VPWR VGND sg13g2_fill_2
X_21616_ net64 VPWR _02233_ VGND u_LMS.w\[7\]\[19\] u_LMS.w\[7\]\[18\] sg13g2_o21ai_1
XFILLER_40_368 VPWR VGND sg13g2_decap_8
X_22596_ net466 u_debug_unit.sw_reset\[3\] _03058_ _00595_ VPWR VGND sg13g2_mux2_1
X_23432__1053 VPWR VGND net1052 sg13g2_tiehi
X_21547_ u_LMS.w\[7\]\[15\] _02163_ _02164_ VPWR VGND sg13g2_nor2_1
X_12280_ _03661_ _03660_ _03657_ VPWR VGND sg13g2_nand2b_1
XFILLER_4_203 VPWR VGND sg13g2_decap_8
X_21478_ _02095_ _02067_ _02094_ VPWR VGND sg13g2_xnor2_1
XFILLER_119_492 VPWR VGND sg13g2_fill_1
X_23217_ net1450 VGND VPWR _00279_ u_FIR.w\[8\]\[6\] clknet_leaf_22_clkA sg13g2_dfrbpq_1
X_20429_ _01088_ net316 u_LMS.w\[5\]\[16\] coeff_force_packed\[39\] net566 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_20_41 VPWR VGND sg13g2_fill_1
XFILLER_105_2 VPWR VGND sg13g2_fill_1
X_23148_ net1567 VGND VPWR _00210_ u_FIR.x_reg\[1\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
XFILLER_121_101 VPWR VGND sg13g2_fill_2
XFILLER_0_431 VPWR VGND sg13g2_decap_8
XFILLER_1_954 VPWR VGND sg13g2_decap_8
XFILLER_122_657 VPWR VGND sg13g2_fill_1
X_23079_ net1087 VGND VPWR _00141_ u_FIR.sum\[5\]\[3\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
X_15970_ _07213_ _07203_ _07212_ VPWR VGND sg13g2_xnor2_1
XFILLER_49_925 VPWR VGND sg13g2_fill_2
XFILLER_48_413 VPWR VGND sg13g2_decap_4
X_14921_ _06203_ _06183_ _06204_ VPWR VGND sg13g2_xor2_1
XFILLER_49_958 VPWR VGND sg13g2_decap_8
X_17640_ _08773_ net685 net251 VPWR VGND sg13g2_nand2_1
X_14852_ _06138_ _06137_ _06103_ VPWR VGND sg13g2_nand2b_1
X_23324__1278 VPWR VGND net1277 sg13g2_tiehi
X_13803_ _05128_ _05127_ _05126_ VPWR VGND sg13g2_nand2b_1
X_17571_ _08701_ _08703_ _08704_ VPWR VGND sg13g2_nor2_1
X_14783_ _06071_ u_FIR.sum\[4\]\[10\] net398 VPWR VGND sg13g2_xnor2_1
X_11995_ net327 _03411_ _03412_ VPWR VGND sg13g2_nor2_1
XFILLER_91_758 VPWR VGND sg13g2_decap_8
XFILLER_17_844 VPWR VGND sg13g2_fill_1
X_19310_ _10355_ VPWR _10374_ VGND _10352_ _10353_ sg13g2_o21ai_1
XFILLER_17_866 VPWR VGND sg13g2_fill_1
X_16522_ u_LMS.w\[1\]\[24\] _07733_ _07734_ VPWR VGND sg13g2_nor2_1
X_13734_ _05061_ _05044_ _05060_ VPWR VGND sg13g2_xnor2_1
XFILLER_45_60 VPWR VGND sg13g2_fill_2
XFILLER_16_343 VPWR VGND sg13g2_decap_8
XFILLER_72_972 VPWR VGND sg13g2_decap_8
XFILLER_45_71 VPWR VGND sg13g2_decap_8
XFILLER_17_899 VPWR VGND sg13g2_fill_1
X_19241_ _10316_ _10314_ _10315_ VPWR VGND sg13g2_nand2b_1
XFILLER_91_1029 VPWR VGND sg13g2_decap_8
X_16453_ _07676_ VPWR _07681_ VGND _07664_ _07677_ sg13g2_o21ai_1
X_13665_ _04963_ _04993_ _04994_ VPWR VGND sg13g2_and2_1
XFILLER_71_493 VPWR VGND sg13g2_fill_2
X_15404_ _06669_ u_FIR.sum\[5\]\[14\] net393 VPWR VGND sg13g2_xnor2_1
X_12616_ _03963_ _03960_ _03983_ _03984_ VPWR VGND sg13g2_a21o_1
XFILLER_31_357 VPWR VGND sg13g2_fill_2
X_19172_ net67 VPWR _10259_ VGND u_LMS.w\[3\]\[23\] u_LMS.w\[3\]\[22\] sg13g2_o21ai_1
X_16384_ _07616_ _07594_ _07614_ VPWR VGND sg13g2_xnor2_1
X_13596_ _04926_ net750 net879 VPWR VGND sg13g2_nand2_1
XFILLER_84_7 VPWR VGND sg13g2_decap_8
X_18123_ _09233_ _09225_ _09231_ VPWR VGND sg13g2_xnor2_1
X_15335_ VGND VPWR net504 _06601_ _00168_ _06602_ sg13g2_a21oi_1
X_12547_ _03920_ _03918_ _03919_ _03866_ net720 VPWR VGND sg13g2_a22oi_1
XFILLER_129_245 VPWR VGND sg13g2_decap_8
XFILLER_8_564 VPWR VGND sg13g2_fill_2
XFILLER_117_418 VPWR VGND sg13g2_decap_8
X_18054_ _09167_ net57 _09166_ VPWR VGND sg13g2_nand2_1
X_15266_ _06502_ _06495_ _06510_ _06535_ VPWR VGND sg13g2_a21o_1
XFILLER_6_21 VPWR VGND sg13g2_decap_8
X_12478_ VGND VPWR _03816_ _03819_ _03854_ _03852_ sg13g2_a21oi_1
XANTENNA_3 VPWR VGND net216 sg13g2_antennanp
X_17005_ _08156_ _08160_ _08161_ VPWR VGND sg13g2_nor2_1
X_14217_ _05512_ VPWR _05525_ VGND _05508_ _05510_ sg13g2_o21ai_1
X_15197_ _06464_ VPWR _06468_ VGND _06465_ _06466_ sg13g2_o21ai_1
XFILLER_6_98 VPWR VGND sg13g2_decap_8
X_14148_ _05458_ net762 net836 VPWR VGND sg13g2_nand2_1
XFILLER_113_635 VPWR VGND sg13g2_fill_1
XFILLER_125_495 VPWR VGND sg13g2_fill_1
XFILLER_101_808 VPWR VGND sg13g2_fill_1
X_18956_ _10015_ _10042_ _10043_ VPWR VGND sg13g2_nor2_1
X_14079_ _05391_ _05389_ _05390_ VPWR VGND sg13g2_nand2_1
XFILLER_112_156 VPWR VGND sg13g2_decap_8
XFILLER_67_700 VPWR VGND sg13g2_fill_1
X_17907_ _09040_ u_LMS.w\[1\]\[13\] _08989_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_1025 VPWR VGND sg13g2_decap_8
XFILLER_79_593 VPWR VGND sg13g2_fill_1
X_18887_ VGND VPWR _09972_ _09973_ _09974_ _09971_ sg13g2_a21oi_1
XFILLER_67_744 VPWR VGND sg13g2_decap_4
XFILLER_94_552 VPWR VGND sg13g2_decap_4
X_17838_ _08968_ _08970_ _08971_ VPWR VGND sg13g2_and2_1
XFILLER_67_777 VPWR VGND sg13g2_fill_2
XFILLER_48_991 VPWR VGND sg13g2_decap_8
X_17769_ VGND VPWR _08900_ _08901_ _08902_ _08899_ sg13g2_a21oi_1
XFILLER_35_641 VPWR VGND sg13g2_fill_1
X_19508_ _10572_ u_LMS.x_r\[4\]\[4\] net225 VPWR VGND sg13g2_nand2_1
XFILLER_25_19 VPWR VGND sg13g2_decap_4
X_20780_ _01419_ net2059 _01420_ VPWR VGND sg13g2_xor2_1
XFILLER_23_836 VPWR VGND sg13g2_decap_8
X_19439_ _10500_ VPWR _10503_ VGND _03244_ net199 sg13g2_o21ai_1
XFILLER_22_346 VPWR VGND sg13g2_fill_2
XFILLER_37_1060 VPWR VGND sg13g2_fill_1
XFILLER_10_508 VPWR VGND sg13g2_fill_2
X_22450_ VGND VPWR net444 _03244_ _00533_ _02974_ sg13g2_a21oi_1
XFILLER_10_519 VPWR VGND sg13g2_fill_1
X_21401_ _02018_ _02017_ _02013_ VPWR VGND sg13g2_nand2b_1
X_22381_ net957 VPWR _02940_ VGND net440 net692 sg13g2_o21ai_1
X_21332_ _01949_ _01948_ _01945_ VPWR VGND sg13g2_nand2b_1
XFILLER_129_790 VPWR VGND sg13g2_fill_1
XFILLER_117_963 VPWR VGND sg13g2_decap_4
X_21263_ _01880_ _01840_ _01845_ VPWR VGND sg13g2_xnor2_1
X_23374__1227 VPWR VGND net1226 sg13g2_tiehi
X_23002_ net1203 VGND VPWR _00064_ u_FIR.sum\[0\]\[14\] clknet_leaf_29_clkA sg13g2_dfrbpq_1
X_20214_ _00877_ _11155_ _00846_ VPWR VGND sg13g2_xnor2_1
XFILLER_132_933 VPWR VGND sg13g2_decap_8
X_21194_ _01800_ VPWR _01811_ VGND _01767_ _01801_ sg13g2_o21ai_1
XFILLER_104_668 VPWR VGND sg13g2_fill_1
X_20145_ VGND VPWR _11184_ _11185_ _11186_ _11183_ sg13g2_a21oi_1
XFILLER_104_679 VPWR VGND sg13g2_fill_2
XFILLER_106_33 VPWR VGND sg13g2_decap_4
XFILLER_89_379 VPWR VGND sg13g2_fill_2
XFILLER_98_891 VPWR VGND sg13g2_decap_4
XFILLER_106_77 VPWR VGND sg13g2_decap_8
XFILLER_131_498 VPWR VGND sg13g2_decap_8
X_20076_ _11109_ VPWR _11117_ VGND _11110_ _11116_ sg13g2_o21ai_1
XFILLER_131_1023 VPWR VGND sg13g2_decap_8
XFILLER_85_574 VPWR VGND sg13g2_decap_8
XFILLER_122_21 VPWR VGND sg13g2_decap_8
XFILLER_45_438 VPWR VGND sg13g2_fill_2
X_23766_ net995 VGND VPWR _00013_ u_spi_slave.rx_shift\[8\] clknet_3_3__leaf_spi_sclk
+ sg13g2_dfrbpq_1
X_20978_ _01586_ VPWR _01618_ VGND _01615_ _01616_ sg13g2_o21ai_1
XFILLER_53_460 VPWR VGND sg13g2_decap_8
XFILLER_53_471 VPWR VGND sg13g2_fill_2
X_22717_ VGND VPWR _07719_ net340 _00698_ _03076_ sg13g2_a21oi_1
X_23697_ net1537 VGND VPWR _00759_ net5 clknet_leaf_46_clkA sg13g2_dfrbpq_1
XFILLER_25_195 VPWR VGND sg13g2_fill_2
XFILLER_15_63 VPWR VGND sg13g2_fill_2
X_13450_ _04790_ _04786_ _04789_ VPWR VGND sg13g2_xnor2_1
XFILLER_15_74 VPWR VGND sg13g2_fill_2
X_22648_ net470 coeff_force_packed\[22\] _03064_ _00641_ VPWR VGND sg13g2_mux2_1
XFILLER_51_1013 VPWR VGND sg13g2_decap_8
X_12401_ _03777_ _03752_ _03779_ VPWR VGND sg13g2_xor2_1
X_13381_ _04724_ u_FIR.sum\[1\]\[12\] net406 VPWR VGND sg13g2_xnor2_1
X_22579_ net917 _03049_ _03050_ _00586_ VPWR VGND sg13g2_nor3_1
X_15120_ _06393_ net783 net818 u_FIR.sum\[5\]\[6\] VPWR VGND sg13g2_and3_1
X_12332_ net1037 VPWR _03712_ VGND net543 u_FIR.sum\[0\]\[6\] sg13g2_o21ai_1
XFILLER_110_0 VPWR VGND sg13g2_decap_8
X_15051_ _06326_ _06288_ _06324_ VPWR VGND sg13g2_xnor2_1
XFILLER_107_440 VPWR VGND sg13g2_decap_8
X_12263_ net1037 VPWR _03645_ VGND net540 u_FIR.sum\[0\]\[4\] sg13g2_o21ai_1
XFILLER_107_451 VPWR VGND sg13g2_fill_1
XFILLER_5_567 VPWR VGND sg13g2_fill_1
X_14002_ _05301_ VPWR _05317_ VGND _05297_ _05302_ sg13g2_o21ai_1
Xoutput5 net5 y_serial VPWR VGND sg13g2_buf_1
X_12194_ u_LMS.count\[2\] u_LMS.count\[1\] u_LMS.count\[0\] _03581_ _03582_ VPWR VGND
+ sg13g2_nor4_1
XFILLER_123_966 VPWR VGND sg13g2_fill_1
X_18810_ _09897_ _09854_ _09859_ VPWR VGND sg13g2_xnor2_1
XFILLER_96_806 VPWR VGND sg13g2_fill_1
X_19790_ _10830_ _10847_ _03324_ _10854_ VPWR VGND sg13g2_nand3_1
XFILLER_110_627 VPWR VGND sg13g2_decap_8
X_18741_ _09817_ VPWR _09828_ VGND _09785_ _09818_ sg13g2_o21ai_1
X_15953_ _07197_ _07196_ _07195_ VPWR VGND sg13g2_nand2b_1
XFILLER_49_733 VPWR VGND sg13g2_fill_1
X_14904_ _06161_ _06187_ _06188_ VPWR VGND sg13g2_nor2b_1
X_18672_ net423 _03252_ net183 net159 _09759_ VPWR VGND sg13g2_nor4_1
X_15884_ _07131_ u_FIR.sum\[6\]\[13\] net390 VPWR VGND sg13g2_nand2_1
X_17623_ _08756_ _08752_ _08755_ VPWR VGND sg13g2_nand2_1
X_14835_ VGND VPWR _06089_ _06100_ _06121_ _06108_ sg13g2_a21oi_1
XFILLER_63_257 VPWR VGND sg13g2_decap_8
XFILLER_45_961 VPWR VGND sg13g2_fill_1
X_17554_ _08604_ _08595_ _08687_ VPWR VGND sg13g2_xor2_1
X_14766_ _03369_ _06053_ _06054_ VPWR VGND sg13g2_nor2_1
X_11978_ VGND VPWR u_spi_slave.tx_cnt\[0\] _03393_ _00792_ _03395_ sg13g2_a21oi_1
XFILLER_17_674 VPWR VGND sg13g2_fill_2
XFILLER_16_162 VPWR VGND sg13g2_fill_1
X_16505_ VGND VPWR u_LMS.w\[0\]\[15\] _07713_ _07721_ _07714_ sg13g2_a21oi_1
X_13717_ _05012_ _05005_ _05020_ _05044_ VPWR VGND sg13g2_a21o_1
X_17485_ _08610_ _08617_ _08618_ VPWR VGND sg13g2_and2_1
X_14697_ _05987_ _05979_ _05985_ VPWR VGND sg13g2_xnor2_1
XFILLER_32_644 VPWR VGND sg13g2_fill_1
XFILLER_20_806 VPWR VGND sg13g2_decap_8
X_19224_ _10302_ u_LMS.w\[3\]\[21\] net68 VPWR VGND sg13g2_xnor2_1
X_16436_ _07589_ _07652_ _07665_ VPWR VGND sg13g2_nor2_1
X_13648_ net826 _04976_ net753 _04977_ VPWR VGND sg13g2_nand3_1
XFILLER_32_699 VPWR VGND sg13g2_fill_1
XFILLER_20_839 VPWR VGND sg13g2_fill_2
X_19155_ _10242_ u_LMS.w\[3\]\[18\] net68 VPWR VGND sg13g2_xnor2_1
X_16367_ _07600_ _07593_ _07598_ VPWR VGND sg13g2_xnor2_1
X_13579_ _04910_ _04909_ _04871_ VPWR VGND sg13g2_nand2b_1
XFILLER_118_716 VPWR VGND sg13g2_fill_2
X_18106_ VGND VPWR _09192_ _09194_ _09216_ net120 sg13g2_a21oi_1
X_15318_ VGND VPWR net779 _06504_ _06586_ _06538_ sg13g2_a21oi_1
X_19086_ _10173_ u_LMS.w\[3\]\[17\] net2081 VPWR VGND sg13g2_nand2b_1
X_16298_ VGND VPWR net800 _07485_ _07533_ _07456_ sg13g2_a21oi_1
XFILLER_117_248 VPWR VGND sg13g2_decap_4
X_18037_ _09155_ _09093_ _09154_ VPWR VGND sg13g2_nand2_1
X_15249_ _06519_ _06476_ _06517_ VPWR VGND sg13g2_xnor2_1
XFILLER_126_782 VPWR VGND sg13g2_decap_8
XFILLER_114_922 VPWR VGND sg13g2_fill_1
XFILLER_67_1042 VPWR VGND sg13g2_fill_1
XFILLER_28_1004 VPWR VGND sg13g2_fill_1
XFILLER_125_270 VPWR VGND sg13g2_fill_2
Xfanout307 net309 net307 VPWR VGND sg13g2_buf_1
XFILLER_99_666 VPWR VGND sg13g2_fill_2
Xfanout318 net319 net318 VPWR VGND sg13g2_buf_1
X_19988_ net193 _11027_ net625 _11029_ VPWR VGND sg13g2_nand3_1
Xfanout329 net331 net329 VPWR VGND sg13g2_buf_1
X_18939_ net667 net165 net128 _10026_ VPWR VGND net664 sg13g2_nand4_1
XFILLER_86_338 VPWR VGND sg13g2_decap_8
XFILLER_100_126 VPWR VGND sg13g2_fill_1
XFILLER_67_530 VPWR VGND sg13g2_fill_1
X_21950_ _02543_ _02522_ _02544_ VPWR VGND sg13g2_xor2_1
XFILLER_39_254 VPWR VGND sg13g2_decap_8
XFILLER_94_360 VPWR VGND sg13g2_fill_2
XFILLER_39_276 VPWR VGND sg13g2_fill_1
X_20901_ _01541_ _01540_ _01301_ VPWR VGND sg13g2_nand2b_1
XFILLER_94_393 VPWR VGND sg13g2_decap_8
XFILLER_27_438 VPWR VGND sg13g2_decap_8
X_21881_ _02475_ _02435_ _02441_ VPWR VGND sg13g2_xnor2_1
XFILLER_82_555 VPWR VGND sg13g2_fill_2
X_23620_ net963 VGND VPWR _00682_ coeff_force_packed\[58\] clknet_leaf_4_clkA sg13g2_dfrbpq_1
X_20832_ VGND VPWR _01470_ _01471_ _01472_ _01469_ sg13g2_a21oi_1
XFILLER_54_268 VPWR VGND sg13g2_decap_8
XFILLER_54_279 VPWR VGND sg13g2_fill_1
XFILLER_35_482 VPWR VGND sg13g2_decap_4
X_23551_ net1012 VGND VPWR _00613_ sys_enable_bus\[5\] clknet_leaf_18_clkA sg13g2_dfrbpq_1
XFILLER_51_942 VPWR VGND sg13g2_decap_8
X_20763_ _01403_ net616 net190 VPWR VGND sg13g2_nand2_1
XFILLER_35_1008 VPWR VGND sg13g2_decap_8
X_22502_ net440 u_LMS.count\[0\] _03001_ VPWR VGND sg13g2_nor2_1
XFILLER_35_1019 VPWR VGND sg13g2_fill_2
X_23482_ net1476 VGND VPWR _00544_ u_LMS.x_r\[7\]\[1\] clknet_leaf_9_clkA sg13g2_dfrbpq_1
XFILLER_51_997 VPWR VGND sg13g2_fill_1
X_20694_ _01303_ _01333_ _01334_ VPWR VGND sg13g2_nor2b_1
XFILLER_23_699 VPWR VGND sg13g2_decap_8
X_22433_ net949 VPWR _02966_ VGND net436 u_LMS.x_r\[4\]\[6\] sg13g2_o21ai_1
XFILLER_108_204 VPWR VGND sg13g2_decap_4
XFILLER_109_749 VPWR VGND sg13g2_fill_1
X_22364_ VGND VPWR net454 _03287_ _00490_ _02931_ sg13g2_a21oi_1
X_21315_ _01932_ _01926_ _01930_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_708 VPWR VGND sg13g2_fill_2
XFILLER_11_1052 VPWR VGND sg13g2_decap_8
X_22295_ VGND VPWR u_LMS.w\[8\]\[20\] net308 _02881_ _02871_ sg13g2_a21oi_1
X_21246_ _03218_ _03219_ _08068_ net208 _01863_ VPWR VGND sg13g2_nor4_1
XFILLER_2_526 VPWR VGND sg13g2_decap_8
XFILLER_2_537 VPWR VGND sg13g2_fill_2
XFILLER_132_730 VPWR VGND sg13g2_decap_4
XFILLER_105_966 VPWR VGND sg13g2_fill_2
Xrebuffer2061 _01456_ net2060 VPWR VGND sg13g2_buf_1
Xrebuffer2072 _01453_ net2071 VPWR VGND sg13g2_buf_1
X_21177_ _01794_ net594 net149 VPWR VGND sg13g2_nand2_1
Xrebuffer2083 net2083 net2082 VPWR VGND sg13g2_buf_1
Xfanout830 net831 net830 VPWR VGND sg13g2_buf_1
Xrebuffer2094 _09381_ net2093 VPWR VGND sg13g2_buf_1
Xfanout841 net844 net841 VPWR VGND sg13g2_buf_1
X_20128_ _11167_ _11166_ _11169_ VPWR VGND sg13g2_xor2_1
Xfanout852 net853 net852 VPWR VGND sg13g2_buf_1
XFILLER_77_349 VPWR VGND sg13g2_decap_8
Xfanout863 net865 net863 VPWR VGND sg13g2_buf_1
Xfanout874 net875 net874 VPWR VGND sg13g2_buf_1
Xfanout885 u_FIR.x_reg\[2\] net885 VPWR VGND sg13g2_buf_1
Xfanout896 net898 net896 VPWR VGND sg13g2_buf_1
X_12950_ _04307_ _04282_ _04309_ VPWR VGND sg13g2_xor2_1
X_20059_ _11100_ net631 net113 VPWR VGND sg13g2_nand2_1
X_11901_ VPWR _03322_ u_LMS.w\[4\]\[10\] VGND sg13g2_inv_1
XFILLER_93_35 VPWR VGND sg13g2_decap_8
X_12881_ _04209_ _04241_ _04242_ VPWR VGND sg13g2_nor2_1
X_14620_ _05912_ u_FIR.w\[3\]\[6\] _05911_ VPWR VGND sg13g2_xnor2_1
X_11832_ VPWR _03253_ net656 VGND sg13g2_inv_1
XFILLER_33_419 VPWR VGND sg13g2_fill_2
XFILLER_73_599 VPWR VGND sg13g2_fill_1
X_14551_ _05844_ _05817_ _05845_ VPWR VGND sg13g2_xor2_1
XFILLER_60_238 VPWR VGND sg13g2_fill_1
X_23749_ net1378 VGND VPWR _00811_ u_LMS.x\[0\] clknet_leaf_25_clkA sg13g2_dfrbpq_1
XFILLER_53_290 VPWR VGND sg13g2_decap_4
X_13502_ _04834_ _04833_ _04836_ VPWR VGND sg13g2_xor2_1
X_17270_ _08426_ _08331_ _08336_ VPWR VGND sg13g2_xnor2_1
X_14482_ _05778_ _05779_ _00138_ VPWR VGND sg13g2_nor2_1
XFILLER_42_997 VPWR VGND sg13g2_fill_1
XFILLER_41_485 VPWR VGND sg13g2_fill_1
XFILLER_14_699 VPWR VGND sg13g2_fill_1
X_16221_ VGND VPWR net818 _07456_ _07458_ _07455_ sg13g2_a21oi_1
X_13433_ _04767_ _04773_ _04774_ VPWR VGND sg13g2_nor2b_1
XFILLER_9_158 VPWR VGND sg13g2_decap_8
X_11964__1629 VPWR net1628 clknet_3_5__leaf_spi_sclk VGND sg13g2_inv_1
XFILLER_10_861 VPWR VGND sg13g2_decap_8
X_16152_ _07391_ _07386_ _07389_ VPWR VGND sg13g2_xnor2_1
X_13364_ _04702_ _04704_ _04707_ VPWR VGND sg13g2_nor2_1
XFILLER_127_524 VPWR VGND sg13g2_decap_8
XFILLER_10_894 VPWR VGND sg13g2_fill_2
X_15103_ _06376_ net777 net875 VPWR VGND sg13g2_nand2_1
X_12315_ _03695_ _03686_ _03693_ VPWR VGND sg13g2_xnor2_1
XFILLER_6_854 VPWR VGND sg13g2_fill_2
XFILLER_127_568 VPWR VGND sg13g2_fill_1
X_16083_ net973 VPWR _07324_ VGND net476 u_FIR.sum\[8\]\[5\] sg13g2_o21ai_1
XFILLER_6_865 VPWR VGND sg13g2_fill_1
X_13295_ _04609_ _04639_ net813 _04640_ VPWR VGND sg13g2_nand3_1
XFILLER_5_353 VPWR VGND sg13g2_fill_1
XFILLER_114_218 VPWR VGND sg13g2_decap_8
X_19911_ net629 net154 net627 _10952_ VPWR VGND sg13g2_nand3_1
X_15034_ VGND VPWR _06273_ _06292_ _06309_ _06291_ sg13g2_a21oi_1
XFILLER_107_270 VPWR VGND sg13g2_fill_2
X_12246_ _03628_ net894 net722 net881 net724 VPWR VGND sg13g2_a22oi_1
XFILLER_47_7 VPWR VGND sg13g2_decap_8
X_19842_ net26 VPWR _10896_ VGND net25 _10895_ sg13g2_o21ai_1
X_12177_ net944 u_spi_slave.rx_shift\[7\] _00013_ VPWR VGND sg13g2_nor2b_1
XFILLER_110_402 VPWR VGND sg13g2_fill_2
XFILLER_122_273 VPWR VGND sg13g2_fill_1
X_19773_ _10837_ u_LMS.w\[4\]\[21\] net65 VPWR VGND sg13g2_nand2_1
X_16985_ _08141_ net711 net112 VPWR VGND sg13g2_nand2_1
XFILLER_3_77 VPWR VGND sg13g2_decap_8
XFILLER_110_468 VPWR VGND sg13g2_decap_4
X_18724_ _09811_ net656 net144 VPWR VGND sg13g2_nand2_1
X_15936_ _07160_ _07162_ _07180_ _07181_ VPWR VGND sg13g2_nor3_1
XFILLER_114_1051 VPWR VGND sg13g2_decap_8
XFILLER_83_319 VPWR VGND sg13g2_decap_8
XFILLER_3_1028 VPWR VGND sg13g2_decap_8
X_18655_ _09745_ _09746_ _00344_ VPWR VGND sg13g2_nor2_1
X_15867_ _07113_ _07085_ _07115_ VPWR VGND sg13g2_xor2_1
X_17606_ _08704_ _08702_ _08739_ VPWR VGND sg13g2_xor2_1
X_14818_ _06104_ net267 _06105_ VPWR VGND sg13g2_xor2_1
X_18586_ _09693_ net304 u_LMS.w\[2\]\[15\] coeff_force_packed\[17\] net559 VPWR VGND
+ sg13g2_a22oi_1
XFILLER_36_279 VPWR VGND sg13g2_fill_2
X_15798_ _07046_ _07016_ _07048_ VPWR VGND sg13g2_xor2_1
XFILLER_91_396 VPWR VGND sg13g2_fill_2
X_17537_ _08670_ _08668_ _08669_ VPWR VGND sg13g2_nand2_1
XFILLER_33_942 VPWR VGND sg13g2_fill_1
X_14749_ _06009_ _06037_ _06038_ VPWR VGND sg13g2_nor2b_1
X_17468_ _08601_ net81 net691 net147 net693 VPWR VGND sg13g2_a22oi_1
XFILLER_32_474 VPWR VGND sg13g2_fill_2
XFILLER_60_794 VPWR VGND sg13g2_fill_1
X_19207_ VGND VPWR _10287_ _10288_ _00354_ net928 sg13g2_a21oi_1
X_16419_ _07649_ u_FIR.sum\[7\]\[16\] net388 VPWR VGND sg13g2_xnor2_1
Xclkbuf_leaf_61_clkA clknet_4_0_0_clkA clknet_leaf_61_clkA VPWR VGND sg13g2_buf_8
X_23752__1355 VPWR VGND net1354 sg13g2_tiehi
X_17399_ _08543_ _08486_ _08544_ VPWR VGND sg13g2_xor2_1
XFILLER_9_670 VPWR VGND sg13g2_fill_1
XFILLER_73_0 VPWR VGND sg13g2_fill_2
X_19138_ _10225_ _10224_ _10188_ VPWR VGND sg13g2_nand2b_1
XFILLER_9_692 VPWR VGND sg13g2_fill_2
XFILLER_106_708 VPWR VGND sg13g2_fill_2
X_19069_ _10156_ _09831_ _09834_ VPWR VGND sg13g2_nand2_1
X_21100_ _01723_ _01606_ _01607_ VPWR VGND sg13g2_xnor2_1
X_22080_ _02674_ _02669_ _02670_ VPWR VGND sg13g2_xnor2_1
XFILLER_99_430 VPWR VGND sg13g2_decap_4
XFILLER_126_590 VPWR VGND sg13g2_decap_4
XFILLER_114_752 VPWR VGND sg13g2_fill_1
X_21031_ net18 VPWR _01669_ VGND net16 _01668_ sg13g2_o21ai_1
Xfanout104 net105 net104 VPWR VGND sg13g2_buf_8
Xfanout115 _02376_ net115 VPWR VGND sg13g2_buf_1
XFILLER_113_251 VPWR VGND sg13g2_fill_1
Xfanout126 net1642 net126 VPWR VGND sg13g2_buf_8
XFILLER_59_327 VPWR VGND sg13g2_decap_8
Xfanout137 net2149 net137 VPWR VGND sg13g2_buf_8
Xfanout148 _07987_ net148 VPWR VGND sg13g2_buf_1
XFILLER_59_338 VPWR VGND sg13g2_fill_2
Xfanout159 net163 net159 VPWR VGND sg13g2_buf_1
XFILLER_68_861 VPWR VGND sg13g2_fill_2
X_22982_ net1019 VGND VPWR _00044_ u_spi_slave.tx_shift\[12\] net1632 sg13g2_dfrbpq_1
XFILLER_74_319 VPWR VGND sg13g2_fill_1
XFILLER_55_511 VPWR VGND sg13g2_fill_2
XFILLER_83_831 VPWR VGND sg13g2_fill_2
X_21933_ _02527_ _02526_ _02521_ VPWR VGND sg13g2_nand2b_1
XFILLER_27_235 VPWR VGND sg13g2_decap_8
XFILLER_82_330 VPWR VGND sg13g2_fill_1
XFILLER_103_45 VPWR VGND sg13g2_fill_1
XFILLER_55_566 VPWR VGND sg13g2_decap_8
X_21864_ _02458_ _02446_ _02453_ VPWR VGND sg13g2_xnor2_1
XFILLER_43_728 VPWR VGND sg13g2_fill_2
XFILLER_82_374 VPWR VGND sg13g2_fill_1
XFILLER_63_27 VPWR VGND sg13g2_decap_4
X_23603_ net1015 VGND VPWR _00665_ coeff_force_packed\[43\] clknet_leaf_19_clkA sg13g2_dfrbpq_1
XFILLER_24_931 VPWR VGND sg13g2_fill_2
X_20815_ _01455_ net621 net227 VPWR VGND sg13g2_nand2_1
X_21795_ _02389_ net576 net149 VPWR VGND sg13g2_nand2_1
XFILLER_23_452 VPWR VGND sg13g2_decap_8
X_23534_ net1013 VGND VPWR _00596_ u_debug_unit.sw_reset\[4\] clknet_leaf_37_clkA
+ sg13g2_dfrbpq_1
X_20746_ _03227_ _01385_ _01386_ VPWR VGND sg13g2_nor2_1
X_23465_ net1535 VGND VPWR _00527_ u_LMS.x_r\[5\]\[0\] clknet_leaf_6_clkA sg13g2_dfrbpq_1
XFILLER_7_607 VPWR VGND sg13g2_decap_4
X_20677_ _01317_ _01312_ _01315_ VPWR VGND sg13g2_xnor2_1
X_22416_ VGND VPWR net431 _03261_ _00516_ _02957_ sg13g2_a21oi_1
X_23396_ net1160 VGND VPWR _00458_ u_LMS.w\[7\]\[6\] clknet_leaf_8_clkA sg13g2_dfrbpq_1
XFILLER_6_128 VPWR VGND sg13g2_decap_4
X_22347_ net357 VPWR _02921_ VGND u_LMS.w\[8\]\[9\] net374 sg13g2_o21ai_1
XFILLER_128_42 VPWR VGND sg13g2_decap_8
XFILLER_124_516 VPWR VGND sg13g2_decap_8
X_12100_ VGND VPWR coeff_force_packed\[17\] net292 _03512_ _03385_ sg13g2_a21oi_1
X_13080_ _04431_ _04423_ _04430_ VPWR VGND sg13g2_nand2_1
X_22278_ _02867_ net9 _02866_ VPWR VGND sg13g2_nand2_1
XFILLER_105_741 VPWR VGND sg13g2_decap_8
XFILLER_105_752 VPWR VGND sg13g2_decap_4
X_23080__1087 VPWR VGND net1086 sg13g2_tiehi
X_12031_ _03448_ net287 u_debug_unit.force_w4\[7\] net293 u_debug_unit.force_w7\[7\]
+ VPWR VGND sg13g2_a22oi_1
XFILLER_88_68 VPWR VGND sg13g2_fill_2
X_21229_ VGND VPWR _01839_ _01845_ _01846_ _01838_ sg13g2_a21oi_1
XFILLER_132_571 VPWR VGND sg13g2_decap_8
X_23259__1376 VPWR VGND net1375 sg13g2_tiehi
Xfanout660 net661 net660 VPWR VGND sg13g2_buf_1
Xfanout671 u_LMS.x_r\[2\]\[6\] net671 VPWR VGND sg13g2_buf_1
XFILLER_77_168 VPWR VGND sg13g2_decap_8
Xfanout682 u_LMS.x_r\[2\]\[0\] net682 VPWR VGND sg13g2_buf_1
X_16770_ _07926_ _07921_ _07925_ _07914_ net239 VPWR VGND sg13g2_a22oi_1
Xfanout693 net695 net693 VPWR VGND sg13g2_buf_1
X_13982_ _05298_ net765 net893 u_FIR.sum\[3\]\[1\] VPWR VGND sg13g2_and3_1
XFILLER_93_639 VPWR VGND sg13g2_fill_2
XFILLER_58_382 VPWR VGND sg13g2_fill_2
X_15721_ _06971_ VPWR _06973_ VGND _06931_ _06933_ sg13g2_o21ai_1
XFILLER_37_50 VPWR VGND sg13g2_fill_2
X_12933_ _04292_ _04254_ _04290_ VPWR VGND sg13g2_xnor2_1
XFILLER_18_246 VPWR VGND sg13g2_decap_8
X_18440_ VPWR _09550_ _09549_ VGND sg13g2_inv_1
X_15652_ net875 net785 _06903_ _06905_ VPWR VGND sg13g2_a21o_1
XFILLER_18_279 VPWR VGND sg13g2_fill_2
X_12864_ _04225_ _04219_ _04223_ VPWR VGND sg13g2_xnor2_1
X_14603_ _05895_ _05855_ _05893_ VPWR VGND sg13g2_xnor2_1
XFILLER_33_238 VPWR VGND sg13g2_decap_8
X_18371_ _09481_ net675 net254 VPWR VGND sg13g2_nand2_1
X_11815_ VPWR _03236_ net625 VGND sg13g2_inv_1
XFILLER_61_558 VPWR VGND sg13g2_decap_8
X_15583_ _06838_ _06837_ _06803_ VPWR VGND sg13g2_nand2b_1
X_12795_ _04158_ _04157_ _04116_ VPWR VGND sg13g2_nand2b_1
XFILLER_18_1003 VPWR VGND sg13g2_decap_8
XFILLER_42_750 VPWR VGND sg13g2_fill_1
X_17322_ _08478_ _08474_ _08476_ _08477_ VPWR VGND sg13g2_and3_1
X_14534_ _05828_ net770 net876 VPWR VGND sg13g2_nand2_1
XFILLER_42_783 VPWR VGND sg13g2_fill_1
XFILLER_105_1028 VPWR VGND sg13g2_fill_1
X_17253_ u_LMS.w\[0\]\[14\] _08408_ _08409_ VPWR VGND sg13g2_and2_1
X_14465_ VGND VPWR net513 _05763_ _00136_ _05764_ sg13g2_a21oi_1
XFILLER_128_811 VPWR VGND sg13g2_fill_2
X_16204_ _07436_ _07438_ _07441_ VPWR VGND sg13g2_nor2_1
X_13416_ _04758_ _04739_ _04757_ VPWR VGND sg13g2_xnor2_1
X_23404__1137 VPWR VGND net1136 sg13g2_tiehi
X_17184_ _08304_ _08309_ _08283_ _08340_ VPWR VGND sg13g2_nand3_1
X_14396_ _05699_ u_FIR.sum\[3\]\[14\] net399 VPWR VGND sg13g2_xnor2_1
XFILLER_10_680 VPWR VGND sg13g2_fill_2
XFILLER_127_343 VPWR VGND sg13g2_fill_2
X_16135_ _07374_ _07368_ _07372_ VPWR VGND sg13g2_xnor2_1
X_13347_ _04609_ _04642_ _04691_ VPWR VGND sg13g2_and2_1
X_16066_ _07307_ _07306_ _07264_ VPWR VGND sg13g2_nand2b_1
X_13278_ _04624_ _04615_ _04622_ VPWR VGND sg13g2_xnor2_1
X_23443__1603 VPWR VGND net1602 sg13g2_tiehi
X_15017_ _06293_ _06272_ _06292_ VPWR VGND sg13g2_xnor2_1
X_12229_ net907 _03598_ net722 _03612_ VPWR VGND sg13g2_nand3_1
XFILLER_68_102 VPWR VGND sg13g2_fill_1
XFILLER_96_422 VPWR VGND sg13g2_decap_8
XFILLER_123_582 VPWR VGND sg13g2_decap_4
X_19825_ _10882_ _10833_ _10881_ VPWR VGND sg13g2_xnor2_1
XFILLER_123_593 VPWR VGND sg13g2_decap_4
XFILLER_84_606 VPWR VGND sg13g2_fill_1
XFILLER_110_265 VPWR VGND sg13g2_decap_8
X_19756_ VGND VPWR _10417_ _10423_ _10820_ _10372_ sg13g2_a21oi_1
XFILLER_111_799 VPWR VGND sg13g2_fill_1
X_16968_ net122 _08123_ _08124_ VPWR VGND sg13g2_nor2b_1
XFILLER_37_500 VPWR VGND sg13g2_fill_2
XFILLER_83_116 VPWR VGND sg13g2_fill_2
X_18707_ _09786_ _09793_ _09794_ VPWR VGND sg13g2_and2_1
X_15919_ VGND VPWR net498 _07163_ _00190_ _07164_ sg13g2_a21oi_1
X_19687_ _10751_ _10727_ _10728_ VPWR VGND sg13g2_xnor2_1
X_16899_ _08055_ _08032_ _08053_ VPWR VGND sg13g2_xnor2_1
X_18638_ net354 VPWR _09734_ VGND u_LMS.w\[2\]\[3\] net370 sg13g2_o21ai_1
XFILLER_65_897 VPWR VGND sg13g2_fill_1
XFILLER_92_694 VPWR VGND sg13g2_fill_1
XFILLER_91_193 VPWR VGND sg13g2_fill_2
X_18569_ _09679_ net321 _09678_ VPWR VGND sg13g2_nand2_1
XFILLER_40_709 VPWR VGND sg13g2_fill_2
X_20600_ net190 _01238_ net609 _01240_ VPWR VGND sg13g2_nand3_1
X_21580_ _02197_ _02196_ _02184_ VPWR VGND sg13g2_nand2b_1
XFILLER_71_1027 VPWR VGND sg13g2_decap_4
XFILLER_21_934 VPWR VGND sg13g2_fill_1
XFILLER_32_271 VPWR VGND sg13g2_fill_2
X_20531_ _01171_ _01164_ _01169_ VPWR VGND sg13g2_xnor2_1
XFILLER_21_956 VPWR VGND sg13g2_decap_4
X_23337__1265 VPWR VGND net1264 sg13g2_tiehi
X_23250_ net1392 VGND VPWR _00312_ u_LMS.w\[1\]\[21\] clknet_leaf_57_clkA sg13g2_dfrbpq_1
XFILLER_119_833 VPWR VGND sg13g2_decap_8
X_20462_ net23 VPWR _01114_ VGND net21 _01113_ sg13g2_o21ai_1
X_22201_ _02795_ u_LMS.w\[8\]\[6\] _02778_ VPWR VGND sg13g2_xnor2_1
X_23181_ net1513 VGND VPWR _00243_ u_FIR.w\[3\]\[5\] clknet_leaf_39_clkA sg13g2_dfrbpq_1
X_20393_ VGND VPWR _01056_ _01055_ _01054_ sg13g2_or2_1
X_22132_ _02519_ _02489_ _02726_ VPWR VGND sg13g2_xor2_1
X_23186__1506 VPWR VGND net1505 sg13g2_tiehi
X_23214__1457 VPWR VGND net1456 sg13g2_tiehi
X_22063_ VGND VPWR _02657_ _02656_ _02655_ sg13g2_or2_1
XFILLER_114_571 VPWR VGND sg13g2_decap_8
XFILLER_58_38 VPWR VGND sg13g2_fill_2
X_21014_ _01650_ VPWR _01654_ VGND _03309_ _01560_ sg13g2_o21ai_1
XFILLER_114_593 VPWR VGND sg13g2_fill_1
XFILLER_101_232 VPWR VGND sg13g2_decap_4
XFILLER_28_500 VPWR VGND sg13g2_decap_8
XFILLER_56_820 VPWR VGND sg13g2_decap_4
X_22965_ net946 _11197_ VPWR VGND sg13g2_buf_1
XFILLER_55_341 VPWR VGND sg13g2_fill_1
XFILLER_16_706 VPWR VGND sg13g2_decap_8
XFILLER_16_717 VPWR VGND sg13g2_fill_1
X_21916_ net585 net588 _02510_ VPWR VGND sg13g2_and2_1
XFILLER_55_374 VPWR VGND sg13g2_decap_8
X_22896_ VPWR _00777_ _03176_ VGND sg13g2_inv_1
XFILLER_28_599 VPWR VGND sg13g2_fill_2
XFILLER_16_739 VPWR VGND sg13g2_fill_2
XFILLER_70_311 VPWR VGND sg13g2_fill_2
XFILLER_55_385 VPWR VGND sg13g2_fill_2
XFILLER_130_21 VPWR VGND sg13g2_decap_8
X_21847_ _02440_ _02349_ _02441_ VPWR VGND sg13g2_xor2_1
XFILLER_70_366 VPWR VGND sg13g2_decap_4
XFILLER_24_761 VPWR VGND sg13g2_decap_4
XFILLER_12_912 VPWR VGND sg13g2_decap_8
X_12580_ _03950_ _03944_ _03949_ VPWR VGND sg13g2_xnor2_1
XFILLER_90_36 VPWR VGND sg13g2_fill_2
XFILLER_30_219 VPWR VGND sg13g2_decap_8
X_21778_ _02370_ _02363_ _02372_ VPWR VGND sg13g2_xor2_1
XFILLER_130_98 VPWR VGND sg13g2_decap_8
XFILLER_24_794 VPWR VGND sg13g2_fill_1
XFILLER_90_69 VPWR VGND sg13g2_decap_8
X_20729_ _01369_ _01346_ _01347_ VPWR VGND sg13g2_xnor2_1
X_23517_ net1348 VGND VPWR _00579_ u_LMS.count\[20\] clknet_leaf_60_clkA sg13g2_dfrbpq_1
X_14250_ _05556_ _05524_ _05558_ VPWR VGND sg13g2_xor2_1
X_23448_ net1587 VGND VPWR _00510_ u_LMS.x_r\[2\]\[7\] clknet_leaf_0_clkA sg13g2_dfrbpq_1
XFILLER_104_1050 VPWR VGND sg13g2_decap_8
X_13201_ _04549_ _04517_ _04547_ VPWR VGND sg13g2_xnor2_1
XFILLER_109_354 VPWR VGND sg13g2_decap_8
X_14181_ _03365_ net878 _05490_ VPWR VGND sg13g2_nor2_1
X_23379_ net1211 VGND VPWR _00441_ u_LMS.w\[7\]\[12\] clknet_leaf_15_clkA sg13g2_dfrbpq_1
X_13132_ _03361_ net909 _04481_ VPWR VGND sg13g2_nor2_1
XFILLER_3_654 VPWR VGND sg13g2_decap_8
XFILLER_3_0 VPWR VGND sg13g2_decap_8
XFILLER_112_519 VPWR VGND sg13g2_decap_8
X_17940_ VGND VPWR _09069_ _09070_ _09073_ _09072_ sg13g2_a21oi_1
X_13063_ _04414_ net741 net909 VPWR VGND sg13g2_nand2_1
XFILLER_79_912 VPWR VGND sg13g2_decap_8
XFILLER_124_379 VPWR VGND sg13g2_decap_8
X_12014_ _03411_ net326 _03431_ VPWR VGND sg13g2_nor2_1
X_17871_ _03346_ _09003_ _09004_ VPWR VGND sg13g2_nor2_1
X_19610_ VPWR _10674_ _10673_ VGND sg13g2_inv_1
X_16822_ _07978_ net703 net134 VPWR VGND sg13g2_nand2_1
XFILLER_94_937 VPWR VGND sg13g2_fill_1
XFILLER_48_60 VPWR VGND sg13g2_fill_2
Xfanout490 net491 net490 VPWR VGND sg13g2_buf_1
X_19541_ _10605_ _10600_ _10603_ VPWR VGND sg13g2_xnor2_1
X_16753_ _07909_ _07906_ net914 net2098 net912 VPWR VGND sg13g2_a22oi_1
X_13965_ _05272_ _05268_ _05266_ _05283_ VPWR VGND sg13g2_mux2_1
X_15704_ _06956_ _06948_ _06954_ VPWR VGND sg13g2_xnor2_1
XFILLER_0_56 VPWR VGND sg13g2_decap_8
X_19472_ _10535_ VPWR _10536_ VGND _10531_ _10532_ sg13g2_o21ai_1
X_12916_ _04275_ _04249_ _04276_ VPWR VGND sg13g2_xor2_1
XFILLER_19_588 VPWR VGND sg13g2_decap_8
X_16684_ VGND VPWR u_LMS.w\[7\]\[12\] _07852_ _07854_ _07853_ sg13g2_a21oi_1
X_13896_ _05218_ _05195_ _05216_ VPWR VGND sg13g2_xnor2_1
XFILLER_62_845 VPWR VGND sg13g2_decap_8
X_18423_ _09526_ _09532_ _09533_ VPWR VGND sg13g2_nor2b_1
XFILLER_73_182 VPWR VGND sg13g2_fill_2
X_15635_ _06889_ _06859_ _06888_ VPWR VGND sg13g2_xnor2_1
X_12847_ VGND VPWR net545 _04207_ _00074_ _04208_ sg13g2_a21oi_1
XFILLER_62_878 VPWR VGND sg13g2_fill_1
XFILLER_15_761 VPWR VGND sg13g2_decap_8
X_18354_ _09437_ VPWR _09464_ VGND _03266_ net139 sg13g2_o21ai_1
XFILLER_9_21 VPWR VGND sg13g2_decap_8
X_15566_ VGND VPWR net477 _06820_ _00180_ _06821_ sg13g2_a21oi_1
X_12778_ _04141_ _04140_ _04136_ VPWR VGND sg13g2_nand2b_1
XFILLER_30_720 VPWR VGND sg13g2_decap_4
XFILLER_15_794 VPWR VGND sg13g2_fill_2
X_17305_ _08461_ _08460_ _08414_ VPWR VGND sg13g2_nand2b_1
X_14517_ _05812_ net770 net902 VPWR VGND sg13g2_nand2_1
X_18285_ _09395_ net674 net217 VPWR VGND sg13g2_nand2_1
X_15497_ net973 VPWR _06756_ VGND net477 u_FIR.sum\[7\]\[1\] sg13g2_o21ai_1
XFILLER_119_129 VPWR VGND sg13g2_fill_2
X_17236_ _08392_ _08383_ _08391_ VPWR VGND sg13g2_xnor2_1
X_14448_ net1006 VPWR _05749_ VGND net512 u_FIR.sum\[4\]\[16\] sg13g2_o21ai_1
XFILLER_31_1055 VPWR VGND sg13g2_decap_4
X_17167_ _08323_ net713 net214 VPWR VGND sg13g2_nand2_1
XFILLER_128_674 VPWR VGND sg13g2_fill_2
XFILLER_116_814 VPWR VGND sg13g2_decap_8
X_14379_ _05683_ _05650_ _05681_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_982 VPWR VGND sg13g2_fill_1
X_16118_ _07357_ _07326_ _07358_ VPWR VGND sg13g2_xor2_1
X_17098_ _08254_ net710 net231 VPWR VGND sg13g2_nand2_1
XFILLER_115_346 VPWR VGND sg13g2_fill_1
X_16049_ _07289_ VPWR _07290_ VGND _07238_ _07270_ sg13g2_o21ai_1
XFILLER_9_1001 VPWR VGND sg13g2_decap_4
XFILLER_69_411 VPWR VGND sg13g2_decap_4
XFILLER_36_0 VPWR VGND sg13g2_decap_8
XFILLER_97_742 VPWR VGND sg13g2_decap_8
XFILLER_97_775 VPWR VGND sg13g2_fill_2
X_19808_ VGND VPWR _10867_ _10868_ _00375_ net931 sg13g2_a21oi_1
X_19739_ _10752_ VPWR _10803_ VGND _10802_ _10801_ sg13g2_o21ai_1
XFILLER_53_801 VPWR VGND sg13g2_fill_1
X_22750_ u_debug_unit.mon_w2_sync\[5\] net329 _03093_ VPWR VGND sg13g2_nor2_1
X_21701_ _02305_ u_LMS.w\[7\]\[2\] _02092_ VPWR VGND sg13g2_xnor2_1
X_22681_ u_debug_unit.force_w6\[7\] net459 _03067_ _00671_ VPWR VGND sg13g2_mux2_1
XFILLER_53_878 VPWR VGND sg13g2_fill_2
XFILLER_25_569 VPWR VGND sg13g2_decap_8
X_21632_ net322 net50 _02249_ VPWR VGND sg13g2_and2_1
XFILLER_40_517 VPWR VGND sg13g2_fill_1
XFILLER_33_580 VPWR VGND sg13g2_decap_4
X_21563_ _02180_ _02099_ _02100_ VPWR VGND sg13g2_xnor2_1
X_23302_ net1299 VGND VPWR _00364_ u_LMS.w\[3\]\[4\] clknet_leaf_58_clkA sg13g2_dfrbpq_1
XFILLER_21_775 VPWR VGND sg13g2_decap_8
X_20514_ _01153_ _01151_ _01150_ _01154_ VPWR VGND sg13g2_a21o_1
X_21494_ _02011_ VPWR _02111_ VGND _02110_ _02108_ sg13g2_o21ai_1
X_23233_ net1421 VGND VPWR _00295_ u_LMS.w\[0\]\[4\] clknet_leaf_12_clkA sg13g2_dfrbpq_1
X_20445_ _01054_ _01059_ _01100_ VPWR VGND sg13g2_nor2b_1
XFILLER_109_33 VPWR VGND sg13g2_decap_4
XFILLER_107_836 VPWR VGND sg13g2_fill_1
XFILLER_119_696 VPWR VGND sg13g2_decap_4
X_23164_ net1543 VGND VPWR _00226_ u_FIR.w\[1\]\[2\] clknet_leaf_49_clkA sg13g2_dfrbpq_1
X_20376_ VGND VPWR _01036_ _01037_ _01039_ _00981_ sg13g2_a21oi_1
XFILLER_69_37 VPWR VGND sg13g2_fill_1
X_22115_ VGND VPWR _02596_ _02602_ _02709_ _02595_ sg13g2_a21oi_1
XFILLER_122_817 VPWR VGND sg13g2_fill_2
XFILLER_0_602 VPWR VGND sg13g2_decap_4
X_23095_ net1063 VGND VPWR _00157_ u_FIR.sum\[6\]\[0\] clknet_leaf_49_clkA sg13g2_dfrbpq_1
XFILLER_121_327 VPWR VGND sg13g2_fill_2
XFILLER_115_891 VPWR VGND sg13g2_fill_1
XFILLER_125_21 VPWR VGND sg13g2_decap_8
XFILLER_121_338 VPWR VGND sg13g2_fill_1
X_22046_ _02617_ VPWR _02640_ VGND _03225_ net163 sg13g2_o21ai_1
XFILLER_0_657 VPWR VGND sg13g2_decap_8
XFILLER_76_948 VPWR VGND sg13g2_decap_8
XFILLER_29_831 VPWR VGND sg13g2_decap_8
XFILLER_18_41 VPWR VGND sg13g2_fill_2
XFILLER_63_609 VPWR VGND sg13g2_decap_4
XFILLER_18_52 VPWR VGND sg13g2_fill_2
XFILLER_29_875 VPWR VGND sg13g2_fill_2
XFILLER_84_981 VPWR VGND sg13g2_fill_1
XFILLER_28_363 VPWR VGND sg13g2_decap_8
X_13750_ VGND VPWR _05035_ _05038_ _05077_ _05075_ sg13g2_a21oi_1
X_22948_ net469 u_spi_slave.rx_shift\[1\] _03575_ _00805_ VPWR VGND sg13g2_mux2_1
XFILLER_90_439 VPWR VGND sg13g2_decap_8
XFILLER_55_160 VPWR VGND sg13g2_fill_1
XFILLER_71_620 VPWR VGND sg13g2_fill_2
X_12701_ _04066_ _04025_ _04064_ VPWR VGND sg13g2_xnor2_1
X_13681_ net864 net748 _05007_ _05009_ VPWR VGND sg13g2_a21o_1
X_22879_ _03165_ _03166_ _03167_ _00769_ VPWR VGND sg13g2_nor3_1
X_23029__1163 VPWR VGND net1162 sg13g2_tiehi
X_15420_ VGND VPWR _06666_ _06676_ _06684_ _06675_ sg13g2_a21oi_1
XFILLER_43_377 VPWR VGND sg13g2_fill_1
XFILLER_31_517 VPWR VGND sg13g2_decap_4
X_12632_ _03999_ _03998_ _03991_ VPWR VGND sg13g2_nand2b_1
XFILLER_54_1011 VPWR VGND sg13g2_decap_4
XFILLER_24_580 VPWR VGND sg13g2_fill_1
XFILLER_34_73 VPWR VGND sg13g2_fill_2
X_23521__1333 VPWR VGND net1332 sg13g2_tiehi
X_15351_ _06618_ net250 _06616_ VPWR VGND sg13g2_xnor2_1
X_12563_ _03935_ _03933_ _03934_ VPWR VGND sg13g2_xnor2_1
XFILLER_12_753 VPWR VGND sg13g2_fill_1
X_14302_ _05608_ net758 net825 VPWR VGND sg13g2_nand2_1
X_18070_ _09180_ net669 net159 VPWR VGND sg13g2_nand2_1
XFILLER_11_263 VPWR VGND sg13g2_decap_8
X_23493__1437 VPWR VGND net1436 sg13g2_tiehi
X_15282_ _06551_ _06535_ _06550_ VPWR VGND sg13g2_xnor2_1
X_12494_ net828 net719 _03867_ _03869_ VPWR VGND sg13g2_a21o_1
XFILLER_7_234 VPWR VGND sg13g2_fill_1
X_17021_ VPWR _08177_ _08176_ VGND sg13g2_inv_1
X_23528__1309 VPWR VGND net1308 sg13g2_tiehi
X_14233_ _05541_ _05497_ _05540_ VPWR VGND sg13g2_xnor2_1
XFILLER_7_278 VPWR VGND sg13g2_fill_2
X_14164_ _05474_ _05467_ _05473_ VPWR VGND sg13g2_xnor2_1
XFILLER_124_132 VPWR VGND sg13g2_decap_4
X_13115_ _04465_ _04425_ _04463_ VPWR VGND sg13g2_xnor2_1
XFILLER_4_974 VPWR VGND sg13g2_fill_2
X_18972_ VGND VPWR _10040_ _10048_ _10059_ _10058_ sg13g2_a21oi_1
X_14095_ VGND VPWR _05371_ _05398_ _05406_ _05397_ sg13g2_a21oi_1
XFILLER_124_165 VPWR VGND sg13g2_fill_1
XFILLER_112_327 VPWR VGND sg13g2_fill_1
XFILLER_124_187 VPWR VGND sg13g2_fill_1
X_17923_ _09056_ _08653_ _08659_ VPWR VGND sg13g2_nand2_1
X_13046_ _04398_ net745 net883 VPWR VGND sg13g2_nand2_1
X_17854_ _03348_ _08986_ _08987_ VPWR VGND sg13g2_nor2_1
XFILLER_94_734 VPWR VGND sg13g2_decap_8
X_16805_ _03277_ net141 _07961_ VPWR VGND sg13g2_nor2_1
XFILLER_120_393 VPWR VGND sg13g2_decap_8
X_17785_ _08889_ _08917_ _08918_ VPWR VGND sg13g2_and2_1
XFILLER_54_609 VPWR VGND sg13g2_fill_1
X_14997_ net876 net782 u_FIR.sum\[5\]\[2\] _06274_ VPWR VGND sg13g2_a21o_1
X_19524_ _10588_ net85 net652 net114 net650 VPWR VGND sg13g2_a22oi_1
X_16736_ _07892_ _07890_ _07891_ _07887_ _07888_ VPWR VGND sg13g2_a22oi_1
XFILLER_75_80 VPWR VGND sg13g2_fill_2
X_13948_ VGND VPWR _05236_ _05266_ _05267_ _05259_ sg13g2_a21oi_1
X_19455_ _10512_ VPWR _10519_ VGND _10478_ _10510_ sg13g2_o21ai_1
XFILLER_90_951 VPWR VGND sg13g2_decap_8
X_16667_ net1030 VPWR _07841_ VGND net527 net743 sg13g2_o21ai_1
X_13879_ _05185_ _05201_ _05202_ VPWR VGND sg13g2_nor2b_1
XFILLER_50_804 VPWR VGND sg13g2_fill_2
XFILLER_35_878 VPWR VGND sg13g2_decap_4
XFILLER_90_984 VPWR VGND sg13g2_decap_8
XFILLER_34_366 VPWR VGND sg13g2_fill_1
X_18406_ _09513_ _09499_ _09516_ VPWR VGND sg13g2_xor2_1
X_15618_ _06872_ _06830_ _06870_ VPWR VGND sg13g2_xnor2_1
X_19386_ _10449_ _10360_ _10450_ VPWR VGND sg13g2_xor2_1
X_16598_ u_LMS.w\[4\]\[23\] u_LMS.w\[4\]\[22\] u_LMS.w\[4\]\[24\] _07789_ VPWR VGND
+ u_LMS.w\[4\]\[21\] sg13g2_nand4_1
XFILLER_22_539 VPWR VGND sg13g2_decap_8
XFILLER_61_196 VPWR VGND sg13g2_decap_8
X_18337_ _09445_ _09446_ _09447_ VPWR VGND sg13g2_nor2_1
X_15549_ _06782_ _06784_ _06805_ VPWR VGND sg13g2_and2_1
X_18268_ VGND VPWR _09372_ _09373_ _09378_ _09377_ sg13g2_a21oi_1
Xclkbuf_4_2_0_clkA clknet_0_clkA clknet_4_2_0_clkA VPWR VGND sg13g2_buf_8
X_17219_ _08374_ VPWR _08375_ VGND _08370_ _08372_ sg13g2_o21ai_1
XFILLER_129_972 VPWR VGND sg13g2_fill_2
X_18199_ VPWR _09309_ _09308_ VGND sg13g2_inv_1
XFILLER_128_482 VPWR VGND sg13g2_fill_1
X_20230_ _00893_ _00889_ _00891_ VPWR VGND sg13g2_xnor2_1
Xfanout6 _02897_ net6 VPWR VGND sg13g2_buf_2
XFILLER_89_506 VPWR VGND sg13g2_fill_1
XFILLER_131_603 VPWR VGND sg13g2_decap_4
X_20161_ net637 net634 net172 _00824_ VPWR VGND net135 sg13g2_nand4_1
XFILLER_89_539 VPWR VGND sg13g2_decap_4
XFILLER_116_699 VPWR VGND sg13g2_decap_8
XFILLER_118_1038 VPWR VGND sg13g2_decap_8
X_20092_ _11133_ net623 net252 VPWR VGND sg13g2_nand2_1
XFILLER_130_168 VPWR VGND sg13g2_fill_1
XFILLER_112_883 VPWR VGND sg13g2_decap_8
XFILLER_84_200 VPWR VGND sg13g2_fill_1
XFILLER_84_255 VPWR VGND sg13g2_fill_1
XFILLER_73_918 VPWR VGND sg13g2_decap_8
XFILLER_66_970 VPWR VGND sg13g2_decap_8
X_22802_ u_debug_unit.mon_w6_sync\[3\] net351 _03119_ VPWR VGND sg13g2_nor2_1
XFILLER_72_428 VPWR VGND sg13g2_fill_2
XFILLER_37_160 VPWR VGND sg13g2_fill_1
X_20994_ _01632_ _01573_ _01572_ _01634_ VPWR VGND sg13g2_a21o_1
XFILLER_77_1044 VPWR VGND sg13g2_fill_2
XFILLER_25_333 VPWR VGND sg13g2_fill_2
X_22733_ VGND VPWR _07741_ net333 _00706_ _03084_ sg13g2_a21oi_1
XFILLER_26_867 VPWR VGND sg13g2_decap_4
XFILLER_38_1017 VPWR VGND sg13g2_fill_1
XFILLER_38_1028 VPWR VGND sg13g2_fill_1
XFILLER_26_889 VPWR VGND sg13g2_decap_8
X_22664_ net430 _03425_ _03066_ VPWR VGND sg13g2_and2_1
X_21615_ _02228_ _02159_ _02231_ _02232_ VPWR VGND sg13g2_a21o_1
XFILLER_40_347 VPWR VGND sg13g2_decap_8
X_22595_ net468 u_debug_unit.sw_reset\[2\] _03058_ _00594_ VPWR VGND sg13g2_mux2_1
X_21546_ _02132_ _02133_ _02163_ VPWR VGND sg13g2_xor2_1
X_21477_ _02085_ _02092_ _02094_ VPWR VGND sg13g2_nor2b_1
X_23216_ net1452 VGND VPWR _00278_ u_FIR.w\[8\]\[5\] clknet_leaf_27_clkA sg13g2_dfrbpq_1
X_20428_ net22 VPWR _01087_ VGND net20 _01086_ sg13g2_o21ai_1
X_23147_ net1568 VGND VPWR _00209_ u_FIR.x_reg\[0\] clknet_leaf_24_clkA sg13g2_dfrbpq_1
X_20359_ VGND VPWR _01019_ _01020_ _01022_ _00994_ sg13g2_a21oi_1
XFILLER_122_625 VPWR VGND sg13g2_fill_1
XFILLER_1_933 VPWR VGND sg13g2_decap_8
XFILLER_121_124 VPWR VGND sg13g2_fill_2
X_23078_ net1089 VGND VPWR _00140_ u_FIR.sum\[5\]\[2\] clknet_leaf_50_clkA sg13g2_dfrbpq_1
XFILLER_96_68 VPWR VGND sg13g2_fill_2
X_22029_ _02623_ _02619_ _02621_ VPWR VGND sg13g2_xnor2_1
X_14920_ _06201_ net268 _06203_ VPWR VGND sg13g2_xor2_1
XFILLER_103_883 VPWR VGND sg13g2_decap_8
XFILLER_0_487 VPWR VGND sg13g2_decap_8
XFILLER_102_382 VPWR VGND sg13g2_decap_4
XFILLER_48_436 VPWR VGND sg13g2_decap_4
X_14851_ _06136_ net267 _06137_ VPWR VGND sg13g2_xor2_1
XFILLER_29_650 VPWR VGND sg13g2_fill_1
XFILLER_21_1021 VPWR VGND sg13g2_decap_4
XFILLER_57_970 VPWR VGND sg13g2_fill_2
X_13802_ _05127_ _05124_ _05125_ VPWR VGND sg13g2_nand2_1
XFILLER_63_417 VPWR VGND sg13g2_decap_4
X_17570_ _08703_ net195 net684 net220 net687 VPWR VGND sg13g2_a22oi_1
XFILLER_21_1054 VPWR VGND sg13g2_decap_8
X_14782_ _06070_ u_FIR.sum\[4\]\[10\] net398 VPWR VGND sg13g2_nand2_1
XFILLER_91_748 VPWR VGND sg13g2_fill_1
XFILLER_75_299 VPWR VGND sg13g2_decap_8
XFILLER_17_834 VPWR VGND sg13g2_fill_2
X_23332__1270 VPWR VGND net1269 sg13g2_tiehi
X_11994_ net474 _03401_ _03411_ VPWR VGND spi_addr\[0\] sg13g2_nand3b_1
X_16521_ _07732_ VPWR _07733_ VGND _07728_ _07729_ sg13g2_o21ai_1
XFILLER_72_951 VPWR VGND sg13g2_decap_8
XFILLER_16_333 VPWR VGND sg13g2_fill_1
X_13733_ _05060_ _05053_ _05058_ VPWR VGND sg13g2_xnor2_1
XFILLER_72_962 VPWR VGND sg13g2_fill_2
X_19240_ net321 VPWR _10315_ VGND net717 net67 sg13g2_o21ai_1
XFILLER_31_303 VPWR VGND sg13g2_decap_8
X_16452_ VGND VPWR net497 _07679_ _00207_ _07680_ sg13g2_a21oi_1
XFILLER_31_314 VPWR VGND sg13g2_fill_1
X_13664_ _04992_ _04964_ _04993_ VPWR VGND sg13g2_xor2_1
XFILLER_32_859 VPWR VGND sg13g2_fill_2
X_15403_ _06668_ u_FIR.sum\[5\]\[14\] net393 VPWR VGND sg13g2_nand2_1
X_19171_ _10250_ _10251_ _10256_ _10258_ VPWR VGND sg13g2_or3_1
X_12615_ _03983_ _03974_ _03981_ VPWR VGND sg13g2_xnor2_1
X_16383_ _07615_ _07614_ _07594_ VPWR VGND sg13g2_nand2b_1
X_13595_ _04903_ _04912_ _04925_ VPWR VGND sg13g2_and2_1
X_18122_ _09232_ _09225_ _09231_ VPWR VGND sg13g2_nand2_1
X_15334_ net1003 VPWR _06602_ VGND net504 u_FIR.sum\[6\]\[11\] sg13g2_o21ai_1
X_12546_ VGND VPWR _03866_ _03896_ _03919_ _03895_ sg13g2_a21oi_1
XFILLER_77_7 VPWR VGND sg13g2_decap_4
X_18053_ _09166_ _09027_ _09029_ VPWR VGND sg13g2_xnor2_1
X_15265_ VGND VPWR _06494_ _06511_ _06534_ _06520_ sg13g2_a21oi_1
X_12477_ _03853_ _03816_ _03819_ _03852_ VPWR VGND sg13g2_and3_1
X_23718__1397 VPWR VGND net1396 sg13g2_tiehi
XANTENNA_4 VPWR VGND net1043 sg13g2_antennanp
X_17004_ _08160_ _08158_ _08159_ VPWR VGND sg13g2_xnor2_1
X_14216_ _05515_ VPWR _05524_ VGND _05485_ _05516_ sg13g2_o21ai_1
X_15196_ _06464_ _06465_ _06466_ _06467_ VPWR VGND sg13g2_nor3_1
XFILLER_99_815 VPWR VGND sg13g2_fill_1
XFILLER_6_77 VPWR VGND sg13g2_decap_8
XFILLER_126_986 VPWR VGND sg13g2_fill_1
X_22999__1208 VPWR VGND net1207 sg13g2_tiehi
X_14147_ _05457_ _05449_ _05456_ VPWR VGND sg13g2_xnor2_1
XFILLER_125_474 VPWR VGND sg13g2_fill_2
X_18955_ _10042_ net661 net238 VPWR VGND sg13g2_nand2_1
X_14078_ net840 net766 u_FIR.sum\[3\]\[5\] _05390_ VPWR VGND sg13g2_a21o_1
Xclkbuf_leaf_18_clkA clknet_4_12_0_clkA clknet_leaf_18_clkA VPWR VGND sg13g2_buf_8
XFILLER_6_1004 VPWR VGND sg13g2_decap_8
Xclkbuf_4_10_0_clkA clknet_0_clkA clknet_4_10_0_clkA VPWR VGND sg13g2_buf_8
X_17906_ VGND VPWR _09036_ _09037_ _09039_ _08992_ sg13g2_a21oi_1
X_13029_ VPWR _04382_ _04381_ VGND sg13g2_inv_1
XFILLER_117_1060 VPWR VGND sg13g2_fill_1
X_18886_ _09973_ _09969_ _09970_ VPWR VGND sg13g2_xnor2_1
X_17837_ _08730_ _08700_ _08970_ VPWR VGND sg13g2_xor2_1
XFILLER_27_609 VPWR VGND sg13g2_fill_2
XFILLER_55_929 VPWR VGND sg13g2_decap_8
XFILLER_66_277 VPWR VGND sg13g2_decap_8
X_17768_ _08898_ _08897_ _08901_ VPWR VGND sg13g2_xor2_1
X_19507_ _10571_ u_LMS.x_r\[4\]\[3\] net221 VPWR VGND sg13g2_nand2_1
X_16719_ VGND VPWR net526 _07878_ _00275_ _07879_ sg13g2_a21oi_1
X_17699_ _08832_ net692 net205 VPWR VGND sg13g2_nand2_1
X_19438_ _10502_ net643 net225 VPWR VGND sg13g2_nand2_1
XFILLER_22_303 VPWR VGND sg13g2_fill_1
X_19369_ _10414_ _10431_ _10412_ _10433_ VPWR VGND sg13g2_nand3_1
X_21400_ _02015_ _02016_ _02017_ VPWR VGND sg13g2_nor2_1
XFILLER_109_909 VPWR VGND sg13g2_decap_8
X_22380_ VGND VPWR net453 _03279_ _00498_ _02939_ sg13g2_a21oi_1
X_21331_ _01947_ _01927_ _01948_ VPWR VGND sg13g2_xor2_1
X_23149__1566 VPWR VGND net1565 sg13g2_tiehi
X_21262_ _01869_ _01868_ _01878_ _01879_ VPWR VGND sg13g2_a21o_1
X_23001_ net1204 VGND VPWR _00063_ u_FIR.sum\[0\]\[13\] clknet_leaf_29_clkA sg13g2_dfrbpq_1
Xrebuffer2210 _08843_ net2209 VPWR VGND sg13g2_buf_1
X_20213_ _00873_ net2123 _00876_ VPWR VGND sg13g2_xor2_1
XFILLER_132_912 VPWR VGND sg13g2_decap_8
X_21193_ _01804_ VPWR _01810_ VGND _01792_ _01802_ sg13g2_o21ai_1
XFILLER_1_218 VPWR VGND sg13g2_fill_1
XFILLER_89_347 VPWR VGND sg13g2_fill_1
X_20144_ _11182_ _11181_ _11185_ VPWR VGND sg13g2_xor2_1
XFILLER_77_509 VPWR VGND sg13g2_decap_8
XFILLER_132_989 VPWR VGND sg13g2_decap_8
X_20075_ _11116_ _11111_ _11114_ VPWR VGND sg13g2_xnor2_1
XFILLER_131_1002 VPWR VGND sg13g2_decap_8
XFILLER_100_820 VPWR VGND sg13g2_fill_1
XFILLER_66_49 VPWR VGND sg13g2_fill_1
XFILLER_58_767 VPWR VGND sg13g2_fill_1
XFILLER_111_190 VPWR VGND sg13g2_decap_8
XFILLER_73_704 VPWR VGND sg13g2_fill_1
XFILLER_58_789 VPWR VGND sg13g2_decap_4
XFILLER_39_992 VPWR VGND sg13g2_fill_1
XFILLER_26_631 VPWR VGND sg13g2_decap_8
XFILLER_26_642 VPWR VGND sg13g2_fill_2
XFILLER_72_258 VPWR VGND sg13g2_decap_4
XFILLER_54_962 VPWR VGND sg13g2_decap_8
X_20977_ _01585_ u_LMS.w\[6\]\[9\] _01617_ VPWR VGND sg13g2_xor2_1
X_23765_ net994 VGND VPWR _00012_ u_spi_slave.rx_shift\[7\] clknet_3_6__leaf_spi_sclk
+ sg13g2_dfrbpq_1
XFILLER_81_770 VPWR VGND sg13g2_fill_2
XFILLER_41_601 VPWR VGND sg13g2_decap_8
X_22716_ u_debug_unit.mon_w0_sync\[2\] net340 _03076_ VPWR VGND sg13g2_nor2_1
XFILLER_25_174 VPWR VGND sg13g2_decap_8
XFILLER_25_185 VPWR VGND sg13g2_fill_1
X_23696_ net989 VGND VPWR _00758_ u_debug_unit.mon_w8_sync\[6\] clknet_leaf_38_clkA
+ sg13g2_dfrbpq_1
XFILLER_80_280 VPWR VGND sg13g2_decap_8
XFILLER_14_859 VPWR VGND sg13g2_fill_2
XFILLER_80_291 VPWR VGND sg13g2_fill_2
XFILLER_41_656 VPWR VGND sg13g2_fill_2
X_22647_ net472 coeff_force_packed\[21\] _03064_ _00640_ VPWR VGND sg13g2_mux2_1
X_12400_ _03778_ _03752_ _03777_ VPWR VGND sg13g2_nand2b_1
X_13380_ _04723_ u_FIR.sum\[1\]\[12\] net406 VPWR VGND sg13g2_nand2_1
X_22578_ _03214_ _03047_ _03050_ VPWR VGND sg13g2_nor2_1
XFILLER_21_380 VPWR VGND sg13g2_fill_1
X_12331_ net541 VPWR _03711_ VGND _03709_ _03710_ sg13g2_o21ai_1
X_21529_ _02146_ net589 _07986_ VPWR VGND sg13g2_nand2_1
X_15050_ _06325_ _06324_ _06288_ VPWR VGND sg13g2_nand2b_1
X_12262_ _03644_ _03641_ _03642_ VPWR VGND sg13g2_xnor2_1
XFILLER_103_0 VPWR VGND sg13g2_decap_4
X_14001_ _05316_ _05309_ _05315_ VPWR VGND sg13g2_xnor2_1
X_12193_ u_LMS.count\[3\] _03579_ u_LMS.count\[6\] _03581_ VPWR VGND _03580_ sg13g2_nand4_1
XFILLER_123_945 VPWR VGND sg13g2_fill_1
XFILLER_95_306 VPWR VGND sg13g2_decap_8
XFILLER_122_477 VPWR VGND sg13g2_fill_2
X_18740_ _09821_ VPWR _09827_ VGND _09809_ _09819_ sg13g2_o21ai_1
X_22995__1214 VPWR VGND net1213 sg13g2_tiehi
X_15952_ _07177_ _07194_ _07173_ _07196_ VPWR VGND sg13g2_nand3_1
XFILLER_49_745 VPWR VGND sg13g2_decap_4
XFILLER_0_284 VPWR VGND sg13g2_decap_8
X_14903_ _06187_ _06164_ _06185_ VPWR VGND sg13g2_xnor2_1
X_18671_ _09757_ _09758_ _00348_ VPWR VGND sg13g2_nor2_1
XFILLER_49_767 VPWR VGND sg13g2_fill_1
X_15883_ _07130_ _07121_ _07129_ VPWR VGND sg13g2_xnor2_1
X_23227__1433 VPWR VGND net1432 sg13g2_tiehi
X_17622_ VGND VPWR net92 _08753_ _08755_ _08623_ sg13g2_a21oi_1
XFILLER_64_726 VPWR VGND sg13g2_fill_1
X_14834_ _06106_ VPWR _06120_ VGND net267 _06104_ sg13g2_o21ai_1
XFILLER_56_60 VPWR VGND sg13g2_fill_1
XFILLER_45_951 VPWR VGND sg13g2_fill_2
X_17553_ VGND VPWR _08677_ _08678_ _08686_ _08685_ sg13g2_a21oi_1
X_14765_ _06053_ _06021_ _06052_ VPWR VGND sg13g2_nand2b_1
XFILLER_51_409 VPWR VGND sg13g2_fill_2
XFILLER_16_130 VPWR VGND sg13g2_decap_8
X_11977_ VGND VPWR u_spi_slave.tx_active _03387_ _03395_ u_spi_slave.tx_cnt\[0\] sg13g2_a21oi_1
X_16504_ VGND VPWR net482 _07719_ _00219_ _07720_ sg13g2_a21oi_1
X_13716_ VGND VPWR _05023_ _05030_ _05043_ _05022_ sg13g2_a21oi_1
X_17484_ _08617_ _08611_ _08616_ VPWR VGND sg13g2_xnor2_1
XFILLER_31_100 VPWR VGND sg13g2_decap_4
X_14696_ _05979_ _05985_ _05986_ VPWR VGND sg13g2_nor2b_1
X_19223_ VGND VPWR _10300_ _10301_ _00357_ net927 sg13g2_a21oi_1
X_16435_ _07658_ _07661_ _07664_ VPWR VGND sg13g2_and2_1
X_13647_ _04975_ _04934_ _04976_ VPWR VGND sg13g2_xor2_1
XFILLER_31_155 VPWR VGND sg13g2_decap_8
XFILLER_31_177 VPWR VGND sg13g2_fill_1
X_19154_ _10240_ VPWR _10241_ VGND _10175_ _10239_ sg13g2_o21ai_1
XFILLER_9_830 VPWR VGND sg13g2_decap_8
X_16366_ _07593_ _07598_ _07599_ VPWR VGND sg13g2_nor2b_1
XFILLER_9_841 VPWR VGND sg13g2_fill_1
XFILLER_13_892 VPWR VGND sg13g2_fill_1
X_13578_ _04908_ _04905_ _04909_ VPWR VGND sg13g2_xor2_1
X_18105_ net145 VPWR _09215_ VGND net680 net682 sg13g2_o21ai_1
X_15317_ _06585_ _06573_ _06584_ VPWR VGND sg13g2_xnor2_1
X_19085_ _10151_ _10171_ _10172_ VPWR VGND sg13g2_xor2_1
X_12529_ _03903_ _03891_ _03901_ VPWR VGND sg13g2_xnor2_1
XFILLER_118_739 VPWR VGND sg13g2_decap_8
X_16297_ _07532_ _07520_ _07531_ VPWR VGND sg13g2_xnor2_1
XFILLER_8_384 VPWR VGND sg13g2_fill_2
X_18036_ _09154_ _09012_ _09013_ VPWR VGND sg13g2_xnor2_1
X_15248_ _06518_ _06517_ _06476_ VPWR VGND sg13g2_nand2b_1
XFILLER_67_1010 VPWR VGND sg13g2_decap_8
X_23145__1572 VPWR VGND net1571 sg13g2_tiehi
XFILLER_99_623 VPWR VGND sg13g2_decap_8
X_15179_ VGND VPWR net485 _06449_ _00164_ _06450_ sg13g2_a21oi_1
XFILLER_126_794 VPWR VGND sg13g2_fill_1
XFILLER_125_293 VPWR VGND sg13g2_fill_2
Xfanout308 net309 net308 VPWR VGND sg13g2_buf_1
Xfanout319 net320 net319 VPWR VGND sg13g2_buf_1
X_19987_ net425 _03236_ net179 net229 _11028_ VPWR VGND sg13g2_nor4_1
XFILLER_86_306 VPWR VGND sg13g2_decap_4
XFILLER_101_628 VPWR VGND sg13g2_fill_2
XFILLER_100_105 VPWR VGND sg13g2_decap_8
X_18938_ _10025_ net664 net165 VPWR VGND sg13g2_nand2_1
XFILLER_98_199 VPWR VGND sg13g2_decap_8
.ends
